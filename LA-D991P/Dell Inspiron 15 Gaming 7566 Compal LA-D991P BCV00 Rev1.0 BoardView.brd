# Allegro board Dell Inspiron 15 Gaming 7566 Compal LA-D991P BCV00 Rev1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
V1N: length 63.6
  IN1 w0.254: v2(122.56,117.59) 122.25,117.91 120.92,117.91 119.26,116.25 119.26,114.67 118.5,113.91 118.5,111.75 118.96,111.29 118.96,108.42 118.13,107.58 109.34,107.58 109.13,107.38 88.1,107.38 82.36,101.64 76.92,101.64 v2(76.46,102.1)
  BOTTOM w0.254: v2(76.46,102.1) PR1411.1 PR1412.1 PR1413.1 ; v2(122.56,117.59) 122.76,117.78 123.52,117.78 123.77,117.53 PR1408.2
V2N: length 55.1
  IN1 w0.254: v2(113.55,117.72) 113.42,117.85 111.77,117.85 110.88,116.96 110.88,110.99 108.19,108.3 102.7,108.3 102.52,108.47 87.87,108.47 82.13,102.73 v2(73.29,102.73)
  BOTTOM w0.254: PR1427.1 PR1426.1 PR1425.1 73.37,102.17 v2(73.29,102.73) ; v2(113.55,117.72) 113.67,117.85 114.63,117.85 114.88,117.59 PR1422.2
V3N: length 47.7
  IN1 w0.254: v2(71.72,103.04) 72.38,103.7 76.54,103.7 76.72,103.88 81.98,103.88 87.79,109.69 101.84,109.69 102.79,110.64 102.79,117.47 103.04,117.72 103.9,117.72 v2(104.02,117.59)
  BOTTOM w0.254: v2(71.72,103.04) 70.95,102.27 PR1439.1 PR1441.1 PR1440.1 ; v2(104.02,117.59) 104.12,117.69 104.98,117.69 105.23,117.43 PR1436.2
VBATT: length 52.3
  TOP w0.508: v2(27.75,35.12) 27.72,35.09 27.72,34.48 26.28,33.05 PD300.2
  IN1 w0.508: v2(27.75,35.12) 24.27,31.64 24.27,29.2 23.31,28.25 20.9,28.25 16.65,23.99 16.65,20.69 17.66,19.68 17.66,18.53 18.93,17.26 24.39,17.26 25.11,16.55 26.93,16.55 27.62,15.87 36.28,15.87 37.55,14.6 40.78,14.6 41.28,15.1 v2(41.28,15.99)
  vias: v2(41.92,16.12) v2(42.55,15.99) v3(41.51,17.03)
VCC_CORE_PT1: length 2.2
  BOTTOM w0.102: PT1400.1 121.04,125.57 121.9,126.43 PU1400.22
VCC_CORE_PT2: length 2.2
  BOTTOM w0.102: PU1401.22 111.72,126.43 110.88,125.59 PT1401.1
VCC_CORE_PT3: length 2.1
  BOTTOM w0.102: PT1402.1 100.97,125.47 101.81,126.3 PU1402.22
VCC_GT_PT1: length 2.9
  BOTTOM w0.102: PU1500.22 91.53,126.3 90.31,125.09 PT1500.1
VCC_GT_PT2: length 1.8
  BOTTOM w0.102: PU1501.22 72.86,108.65 PT1501.1
VCC_SA_PT1: length 1.6
  BOTTOM w0.114: PT1503.1 131.12,124.75 131.56,124.75 131.8,124.99 PU1503.9
VCC_SENSE: length 41.4
  TOP w0.127: v1(71.87,94.52) 71.52,94.86 PR1146.2
  TOP w0.254: PC1134.2 71.51,96.79 v2(71.97,96.33) 71.52,95.89 PR1146.2
  IN1 w0.254: v2(103.54,105.93) 103.54,105.45 102.96,104.87 89.13,104.87 82.78,98.52 79.44,98.52 76.18,95.27 73.03,95.27 v2(71.97,96.33)
  BOTTOM w0.254: RH198.2 104.7,106.47 103.82,106.47 103.54,106.19 v2(103.54,105.93)
VCCGT_B+:
  vias: v2(64.68,116.42) v2(64.7,115.84) v2(64.68,115.1) v2(65.31,116.42) v2(65.31,115.79) v2(65.31,115.13) v2(65.95,116.42) v2(65.95,115.79) v2(66.1,117.8) v2(66.08,117.13) v2(66.58,116.42) v2(66.58,115.79) v2(67.22,116.42) v2(67.22,115.79) v2(97.57,129.25) v2(98.18,129.91) v2(98.21,129.25) v2(98.82,129.91) v2(98.84,129.25) v2(99.45,129.91) v2(99.48,129.25) v3(69.38,116.7)
VCCGT_SENSE: length 58.7
  IN1 w0.254: v2(64.04,87.81) 64.04,87.92 65.62,89.5 65.62,91.13 64.5,92.24 64.5,96.87 67.14,99.51 71.36,99.51 72.73,98.14 77.38,98.14 78.8,99.56 82.38,99.56 88.71,105.88 102.22,105.88 v2(102.27,105.93)
  BOTTOM w0.254: v2(102.27,105.93) 102.37,105.83 102.37,105.09 v1(103.5,103.96) 104.65,102.81 RH204.2 ; v2(64.04,87.81) PR1127.1 PC1109.1
VCCIO_PG: length 209.2
  TOP w0.102: PU700.9 65.58,67.04 65.29,66.75 65.29,65.83 64.09,64.63 62.16,64.63 61.5,63.98 61.5,61.81 v3(61.6,61.71) 61.6,55.06 57.08,50.54 51.95,50.54 50.88,49.47 50.88,48.62 56.84,42.66 62.06,42.66 62.43,42.29 v2(63.75,42.29) ; v2(186.57,17.14) 186.99,16.73 188.3,16.73 189.54,17.97 189.54,20.58 191.17,22.22 PR712.1
  IN1 w0.114: v2(186.57,17.14) 186.57,17.45 186.3,17.72 180.73,17.72 180.17,17.16 179.14,17.16 178.23,18.07 173.02,18.07 172.51,17.57 171.64,17.57 171.2,18.01 169.48,18.01 169.23,18.25 168.86,18.62 167.74,18.62 167.02,19.34 161.49,19.34 160.54,18.39 155,18.39 154.06,17.45 150.5,17.45 149.68,18.28 142.69,18.28 142.15,18.83 140.46,18.83 139.93,19.36 101.74,19.36 101.25,18.88 101.25,18.28 100.95,17.98 71.73,17.98 70.9,17.15 66.78,17.15 62.44,21.49 62.44,24.82 61.71,25.55 61.59,25.55 61.58,25.55 61.04,25.55 61.04,25.55 60.91,25.55 60.18,26.28 60.18,34.19 62.59,36.6 62.59,36.67 62.59,41.67 63.21,42.29 v2(63.75,42.29)
VCCIO_SENSE: length 71.4
  TOP w0.254: v2(119.95,83.86) 120.3,84.22 RH514.2 ; PR705.2 v2(64.63,60.57)
  IN3 w0.254: v2(64.63,60.57) 65.64,60.57 68.67,63.59 70.82,63.59 71.99,64.76 72.29,64.76 72.81,65.28 72.81,67.23 74.97,69.4 74.97,72.22 74.97,73.32 85.85,84.19 92.5,84.19 93.07,83.62 103.79,83.62 103.85,83.56 106.59,83.56 107.32,82.82 109.31,82.82 110.35,83.86 v2(119.95,83.86)
VCCSA_SENSE: length 55.1
  IN1 w0.254: v2(118.41,104.78) 118.28,104.65 118.28,103.89 117.48,103.09 105.65,103.09 104.99,102.43 90.18,102.43 89.06,101.31 89.06,100.65 88.12,99.71 88.12,96.52 85,93.39 85,91.17 84.11,90.29 82.51,90.29 v2(82.28,90.06)
  BOTTOM w0.254: v2(82.28,90.06) 82.38,89.96 82.38,88.36 82.71,88.03 83.17,88.03 83.4,88.26 83.4,90.44 83.12,90.72 82.23,90.72 81.67,90.16 PR1129.2 81.61,90.17 PC1115.2 ; RH202.2 v2(118.41,104.78)
VCCSENSE_VGA: length 35.9
  IN1 w0.406: v2(173.39,78.91) 173.39,78.93 173.55,78.77 173.55,78.63 173.91,78.28 173.91,77.07 173.26,76.43 173.26,75.88 173.26,73.27 174.28,72.26 174.28,69.96 174.63,69.62 174.63,67.08 180.27,61.43 182.35,61.43 184.91,58.87 v2(185.71,58.87)
  BOTTOM w0.406: PR1017.1 182.03,52.64 183.09,53.71 183.09,56.02 185.71,58.64 v2(185.71,58.87) ; UV1.L4 v2(173.39,78.91)
VCCST: length 1
  TOP w0.102: v1(133.03,94.35) 132.45,93.77 132.29,93.77
VCCST_PWRGD_CPU: length 10.3
  TOP w0.102: RH154.2 130.24,76.44 129.68,77 v3(129.68,77.08) v2(129.68,77.92)
  IN1 w0.114: v2(123.96,81.6) 123.96,81.55 125.1,80.41 126.22,80.41 126.32,80.51 127.33,80.51 127.77,80.07 127.77,80.01 129.68,78.1 v2(129.68,77.92)
  BOTTOM w0.102: v2(123.96,81.6) 123.99,81.6 123.99,81.62 123.96,81.65 123.96,81.66 123.63,81.99 UH1.H13
VCCSTG:
  vias: v1(135.93,97.7)
VIN: length 50.3
  TOP w0.508: 20.58,39.67 22.48,41.57 v3(25.46,41.57) 26.86,41.57 28.12,40.31 28.12,36.72 26.98,35.59 26.98,34.84 26.49,34.35 PD300.3 ; v2(22.95,39.59) 23.53,39.59 24.04,39.08 PC303.1 23.76,38.67 23.76,37.81 PC324.1
  IN3 w0.508: v2(46.59,40.12) 44.1,40.12 42.45,38.47 39.23,38.47 36.89,40.81 24.17,40.81 v2(22.95,39.59)
  BOTTOM w0.254: v2(46.59,40.12) 46.34,40.38 PR209.1 PR210.1 PR203.1
  BOTTOM w0.508: PR317.1 25.97,41.6 23.33,41.6 23.15,41.77
  vias: v2(17.23,37.99) v2(17.28,37.3) v2(17.74,38.29) v2(17.74,37.68) v2(18.27,38.65) v2(18.27,37.99) v2(18.25,37.38) v2(22.95,38.98) v2(22.95,38.34)
VSS_SENSE: length 44.2
  TOP w0.127: v2(104.18,105.93) v1(104.18,106.62)
  IN1 w0.254: v2(104.18,105.93) 104.18,105.37 103.17,104.36 89.34,104.36 82.99,98.01 79.65,98.01 76.4,94.76 72.78,94.76 71.82,95.72 71.21,95.72 70.88,95.39 70.88,94.88 71.38,94.38 v2(71.38,94.15)
  BOTTOM w0.203: PC1135.1 71.38,94.66 v2(71.38,94.15) 71.43,94.1 71.43,93.28 71.54,93.18 PU1100.18
  BOTTOM w0.254: RH28.2 104.86,105.25 v2(104.18,105.93)
VSSGT_SENSE: length 57.9
  IN1 w0.254: v2(102.96,105.92) 102.97,105.91 102.97,105.63 102.72,105.37 88.92,105.37 82.59,99.05 79.01,99.05 77.55,97.59 72.41,97.59 71.03,98.97 67.37,98.97 65.03,96.64 65.03,92.47 66.15,91.35 66.15,89.12 66.41,88.86 67.04,88.86 v2(67.29,89.12)
  BOTTOM w0.203: v2(67.29,89.12) 67.54,89.37 PU1100.6
  BOTTOM w0.254: RH32.2 103.91,104.27 v1(102.88,105.3) 102.88,105.85 v2(102.96,105.92) ; v2(67.29,89.12) 66.76,89.65 PC1114.1
VSSIO_SENSE: length 72.6
  TOP w0.254: v2(119.97,83.1) 120.22,83.34 RH513.2 ; PR710.2 65.21,60.06 64.75,60.06 v2(64.63,59.93)
  IN3 w0.254: v2(119.97,83.1) 119.97,83.15 119.77,83.35 110.56,83.35 109.52,82.31 107.11,82.31 106.38,83.05 103.64,83.05 103.58,83.11 92.86,83.11 92.29,83.68 86.06,83.68 75.48,73.11 75.48,72.43 75.48,69.19 73.31,67.02 73.31,65.07 72.5,64.25 72.2,64.25 71.03,63.08 68.88,63.08 65.85,60.06 64.75,60.06 v2(64.63,59.93)
  BOTTOM w0.254: v2(64.63,59.93) v3(63.75,59.93)
VSSSA_SENSE: length 55.2
  IN1 w0.254: v2(117.56,104.77) 117.56,104.78 117.77,104.56 117.77,104.1 117.27,103.6 105.44,103.6 104.78,102.94 89.97,102.94 88.55,101.52 88.55,100.86 87.62,99.92 87.62,96.73 84.49,93.6 84.49,91.38 83.9,90.8 82.2,90.8 81.75,90.34 81.75,89.63 v2(81.87,89.5)
  BOTTOM w0.254: v2(81.87,89.5) 80.37,89.5 80.11,89.75 77.25,89.75 PC1116.1 76.33,89.14 76.11,89.37 PU1100.31 ; v2(117.56,104.77) 117.52,104.73 RH31.2
VSSSENSE_VGA: length 35.6
  IN1 w0.406: v2(185.84,59.63) 185.73,59.53 185.19,59.53 182.62,62.09 180.55,62.09 175.29,67.35 175.29,69.89 174.94,70.24 174.94,72.53 173.92,73.55 173.92,76.16 174.57,76.8 174.57,78.55 v2(174.21,78.91)
  BOTTOM w0.406: v2(185.84,59.63) 185.76,59.71 185.3,59.71 185.05,59.45 185.05,58.91 182.43,56.3 182.43,54.63 181.97,54.17 181.28,54.17 181.13,54.32 181.09,54.32 PR1012.1 ; v2(174.21,78.91) 173.81,79.31 UV1.L5
+AMP:
  vias: v2(259.5,20.44) v2(259.52,19.83) v2(259.52,19.22) v2(266.94,18.78) v2(266.95,18.16) v2(267.54,18.89) v2(267.55,18.29) v3(266.93,14.66)
+DC_IN: length 6.7
  TOP w0.102: PC101.1 v3(12.66,38.06) ; v3(10.55,41.87) v2(10.55,41.01) 9.94,41.01 v3(9.36,40.43)
  TOP w0.508: PC101.1 13.5,40.07 13.5,40.33 v2(13.52,40.35) ; PC100.1 v2(10.55,41.01)
+DCPRTC: length 3.2
  TOP w0.102: v1(166.8,23.57) 166.28,23.05 CH70.1 166.15,23.46 166.15,24.02 v2(165.93,24.24)
  BOTTOM w0.102: v2(165.93,24.24) 165.97,24.2 166,24.2 UH2.BA26
+EDPVDD:
  vias: v2(61.1,34.15) v2(61.6,34.53) v2(61.6,33.77) v3(61.45,35.35) v3(62.77,37.46) v3(63.46,39.49)
+FB_PLLAVDD: length 8.1
  TOP w0.381: CV152.1 175.31,96.57 v2(175.57,96.82)
  TOP w0.508: v2(176.79,89.8) 176.73,89.86 CV153.1 ; CV154.1 168.99,98.19 v2(169.2,98.19)
  BOTTOM w0.254: UV1.H17 v2(176.79,89.8) ; UV1.U27 169.17,98.19 v2(169.2,98.19)
  BOTTOM w0.305: UV1.K27 174.66,97.79 174.67,97.79 175.25,97.21 175.25,97.14 v2(175.57,96.82)
  BOTTOM w0.508: CV155.1 v2(148.6,100.32) ; v2(148.22,102.1) 148.64,102.1 CV156.1 148.64,101.34 v2(148.22,101.34)
  vias: v1(148.19,103.27) v2(148.73,103.11)
+FBA_VREFC0: length 58.6
  TOP w0.406: v2(156.7,124.89) 156.39,124.58 155.33,124.58 154.95,124.96 154.95,132.2 v3(155.76,133.01) 156.22,133.47 171.59,133.47 v2(172.35,132.71) 172.73,132.71 173.24,132.2 173.24,130.97 172.83,130.57 RV127.1 ; RV127.1 171.7,130.57 CV158.1 ; RV127.1 172.52,130.51 RV125.2 172.51,129.68 RV126.2
  IN3 w0.406: v2(172.35,132.71) 173.11,133.47 184.95,133.47 187.64,130.77 187.64,125.92 186.6,124.89 v2(185.6,124.89)
  BOTTOM w0.406: UV6.J14 v2(185.6,124.89) ; UV7.J14 v2(156.7,124.89)
+FBA_VREFD_L: length 63.5
  TOP w0.406: RV130.1 169.87,130.54 CV159.1 ; CV159.1 168.49,130.54 168.21,130.83 168.21,131.86 168.67,132.32 v2(169.76,132.32) ; CV159.1 168.97,130.14 168.99,130.12 RV128.2 RV129.2 ; v2(159.9,131.29) v1(161.93,129.25) 161.93,125.02 161.47,124.55 161.47,120.17 160.58,119.29 v2(159.9,119.29)
  IN3 w0.508: v2(182.56,117.77) 182.43,117.77 181.92,118.28 181.92,123.45 181.01,124.36 181.01,130.19 182.11,131.29 v2(182.4,131.29) 182.4,131.8 181.47,132.73 174.88,132.73 173.45,131.31 170.21,131.31 169.76,131.76 v2(169.76,132.32) 164.42,132.32 164.04,131.94 160.55,131.94 v2(159.9,131.29)
  BOTTOM w0.254: v2(182.56,117.77) 182.69,117.9 182.69,118.77 UV6.A10 ; UV6.U10 v2(182.4,131.29) ; UV7.U10 v2(159.9,119.29) ; UV7.A10 v2(159.9,131.29)
+FBC_VREFC1: length 51
  TOP w0.102: v1(208.09,95.25) 207.73,95.61 v2(207.24,95.61)
  TOP w0.406: RV142.1 206.15,94.84 206.91,95.61 v2(207.24,95.61) ; RV142.1 206.14,94.75 RV141.2 205.24,94.74 RV140.2 ; RV142.1 206.15,93.79 CV177.1
  IN3 w0.508: v2(203.46,106.19) 205.16,106.19 205.88,105.48 205.88,104.23 210.96,99.15 210.96,95.85 210.25,95.14 208.04,95.14 207.57,95.61 v2(207.24,95.61) 207.02,95.39 207.02,93.84 211.77,89.09 211.77,85.31 206,79.54 206,77.45 205.31,76.75 204.04,76.75 203.46,77.32 v2(203.46,77.48)
  BOTTOM w0.305: UV8.J14 v2(203.46,77.48)
  BOTTOM w0.356: UV9.J14 v2(203.46,106.19)
+FBC_VREFD_H: length 64.6
  TOP w0.406: v2(210.71,92.57) 209.42,91.28 206.71,91.28 206.19,91.81 RV145.1 ; v2(209.86,80.68) 209.86,81.6 209.56,81.91 206.26,81.91 205.75,82.41 198.26,82.41 197.88,82.03 197.88,80.76 197.1,79.99 v2(197.1,79.87) ; RV145.1 206.17,91.96 RV144.2 205.25,91.12 RV143.2 ; RV145.1 CV178.1
  TOP w0.508: v2(197.86,102.99) 197.86,101.73 198.76,100.83 v1(208.67,100.83) 209.31,101.46 209.31,102.44 v2(209.86,102.99)
  VCC w0.406: v2(209.86,80.68) 210.45,81.27 210.45,85.69 210.43,85.71 210.43,86.54 210.94,87.06 210.94,92.33 v2(210.71,92.57)
  IN2 w0.508: v2(209.86,102.99) 210.7,102.16 210.7,92.58 v2(210.71,92.57)
  BOTTOM w0.254: v2(197.1,79.87) 197.46,80.22 UV8.A10 ; UV9.A10 v2(209.86,102.99) ; UV9.U10 v2(197.86,102.99) ; UV8.U10 v2(209.86,80.68)
+GPU_CORE: length 110
  TOP w0.381: v2(164.83,95.9) 164.45,95.9 PC1010.1
  TOP w0.508: PC1054.1 167.15,78.71 PC1053.1 ; v2(154.91,75.65) 155.1,75.83 RZ10.1 ; PC1080.1 PC1077.1
  IN2 w0.508: 186.45,60.24 186.45,58.79 v2(186.5,58.74)
  BOTTOM w0.254: UV1.M16 173.89,88.37 v2(173.52,88.74) 172.95,89.31 UV1.N17 172.77,89.31 v2(172.22,89.86)
  BOTTOM w0.305: 167.32,94.81 166.89,95.24 UV1.W23 ; 167.32,94.81 v2(167.32,94.86) ; 167.32,94.81 167.83,94.31 UV1.V22 UV1.U22 UV1.T23 169.89,95.34 v2(169.4,95.83) ; UV1.T12 169.82,84.31 v2(169.34,84.79) 168.89,85.24 UV1.U13 168.53,85.66 v2(168.39,85.66) 168.28,85.66 167.93,85.31 UV1.V13 167.89,85.28 v2(167.39,84.78) 166.92,84.31 UV1.W12 ; UV1.AA12 165.02,84.31 165.46,84.75 v2(165.52,84.75) 165.52,84.81 165.89,85.18 UV1.Y13 UV1.W14 UV1.V15 UV1.U15 169.13,87.31 169.37,87.06 v2(169.4,87.06) 169.4,86.99 169.89,86.5 UV1.T14 v2(170.41,85.79) UV1.R13 171.29,84.91 v2(171.29,84.78) 171.76,84.31 UV1.P12 ; UV1.M12 173.76,84.31 v2(173.29,84.78) 172.89,85.18 UV1.N13 172.71,85.49 172.71,85.64 172.4,85.95 v2(172.4,86.02) 172.35,86.02 172.09,86.27 171.92,86.27 UV1.P14 171.31,86.88 ; v2(172.32,95.7) 171.92,95.31 UV1.P23 UV1.R22 UV1.T21 169.41,92.83 v2(169.41,92.58) 169.15,92.31 UV1.U20 UV1.V20 167.36,92.84 v2(167.3,92.84) 167.3,92.9 UV1.W21 166.89,93.35 165.89,94.35 ; v2(172.22,89.86) 172.67,90.31 UV1.N18 173.16,90.31 173.62,90.77 v2(173.62,90.8) 173.62,91.04 UV1.M19 ; 165.89,94.35 164.93,95.31 UV1.AA23 164.89,95.84 v2(164.83,95.9) ; 165.89,94.35 UV1.Y22 ; 171.31,86.88 UV1.R15 UV1.T16 UV1.U17 168.89,89.33 168.4,89.81 ; 171.31,86.88 v2(171.41,86.88) ; 168.4,89.81 v2(169.63,89.81) 169.69,89.81 169.7,89.83 170.41,89.83 UV1.R18 ; 168.4,89.81 168.4,89.82 ; UV1.AC14 v2(163.35,86.77) UV1.AB15 UV1.AA16 UV1.Y17 165.89,89.46 v2(165.41,89.93) 165.79,90.31 UV1.Y18 UV1.AA19 UV1.AB20 163.8,92.31 v2(163.36,92.75) 162.89,93.22 UV1.AC21 ; v2(167.32,90.85) 167.32,90.88 ; 167.32,90.88 UV1.V18 ; 167.32,90.88 UV1.W19 UV1.Y20 UV1.AA21 UV1.AB22 163.89,94.42 163.38,94.92 ; 168.4,89.82 167.91,90.31 UV1.V18 ; 168.4,89.82 UV1.V17 167.89,89.26 v2(167.34,88.71) 166.94,88.31 UV1.W16 UV1.Y15 UV1.AA14 164.6,86.02 v2(164.4,86.02) 163.89,85.51 UV1.AB13 163.89,85.14 163.43,84.68 ; 168.4,89.82 UV1.U18 169.17,90.31 v2(169.66,90.8) 169.66,91.07 UV1.T19 UV1.R20 UV1.P21 172.32,93.74 ; UV1.R18 UV1.P19 171.89,91.48 v2(172.22,91.81) 172.72,92.31 UV1.N20 173.12,92.54 173.33,92.54 v2(173.59,92.8) 173.59,93.01 UV1.M21 ; UV1.R18 170.95,90.25 170.95,89.37 UV1.R17 170.89,89.05 v2(171.36,88.58) 171.39,88.58 171.66,88.31 UV1.P16 172.39,87.81 v2(172.39,87.55) 172.65,87.55 UV1.N15 173.36,86.83 v2(173.36,86.78) 173.42,86.78 UV1.M14 ; UV1.V18 167.39,89.81 v2(167.29,89.81) ; 163.43,84.68 163.06,84.31 UV1.AC12 ; 163.43,84.68 v2(163.43,84.75) ; 163.38,94.92 163,95.31 UV1.AC23 ; 163.38,94.92 v2(163.38,94.91) ; v2(174.23,95.85) 173.89,95.51 UV1.M23 UV1.N22 172.32,93.74 ; 172.32,93.74 v2(172.32,93.79) ; UV1.AC16 v2(163.44,88.86) UV1.AB17 163.97,89.39 163.97,90.23 UV1.AB18 163.89,90.34 v2(163.39,90.83) 162.92,91.31 UV1.AC19
  BOTTOM w0.508: PR1019.1 182.23,51.76 183.96,53.48 183.96,55.77 186.47,58.28 186.47,58.71 v2(186.5,58.74)
  vias: v2(147.58,66.67) v2(147.84,66.03) v2(147.84,65.4) v2(147.84,64.76) v2(147.84,64.13) v2(147.84,63.49) v2(147.84,62.86) v2(147.84,62.22) v2(148.22,66.67) v2(148.47,66.03) v2(148.47,65.4) v2(148.47,64.76) v2(148.47,64.13) v2(148.47,63.49) v2(148.47,62.86) v2(148.85,66.67) v2(148.98,65.71) v2(148.98,65.08) v2(148.98,64.44) v2(148.98,63.81) v2(148.98,63.17) v2(149.49,66.67) v2(149.49,66.03) v2(149.49,65.4) v2(149.49,64.76) v2(149.49,64.13) v2(149.49,63.49) v2(150.12,66.67) v2(150.12,66.03) v2(150.12,65.4) v2(150.12,64.76) v2(150.12,64.13) v2(150.12,63.49) v2(150.63,65.7) v2(150.63,65.06) v2(150.63,64.43) v2(150.63,63.79) v2(151.14,65.4) v2(151.14,64.76) v2(151.14,64.13) v2(161.68,71.12) v2(162.32,71.12) v2(162.95,71.12) v2(163.59,71.12) v2(164.22,71.12) v2(164.6,66.41) v2(164.6,65.78) v2(164.6,65.14) v2(164.6,64.51) v2(164.6,63.87) v2(164.6,63.24) v2(164.86,71.12) v2(165.24,66.41) v2(165.24,65.78) v2(165.24,65.14) v2(165.24,64.51) v2(165.24,63.87) v2(165.24,63.24) v2(165.9,81.4) v2(165.9,80.58) v2(165.87,67.68) v2(165.87,67.05) v2(165.87,66.41) v2(165.87,65.78) v2(165.87,65.14) v2(165.87,64.51) v2(165.87,63.87) v2(165.87,63.24) v2(165.87,62.6) v2(166.51,67.68) v2(166.51,67.05) v2(166.51,66.41) v2(166.51,65.78) v2(166.51,65.14) v2(166.51,64.51) v2(166.51,63.87) v2(166.51,63.24) v2(166.51,62.6) v2(167.14,67.68) v2(167.14,67.05) v2(167.14,66.41) v2(167.14,65.78) v2(167.14,65.14) v2(167.14,64.51) v2(167.14,63.87) v2(167.14,63.24) v2(167.14,62.6) v2(167.14,61.97) v2(167.27,70.6) v2(167.27,69.97) v2(167.27,69.33) v2(167.27,68.7) v2(167.5,80.42) v2(167.53,79.79) v2(167.6,83.33) v2(167.55,81.38) v2(167.78,67.68) v2(167.78,67.05) v2(167.78,66.41) v2(167.78,65.78) v2(167.78,65.14) v2(167.78,64.51) v2(167.78,63.87) v2(167.78,63.24) v2(167.78,62.6) v2(167.78,61.97) v2(168.36,83.63) v2(168.41,67.68) v2(168.41,67.05) v2(168.41,66.41) v2(168.41,65.78) v2(168.41,65.14) v2(168.41,64.51) v2(168.41,63.87) v2(168.41,63.24) v2(168.41,62.6) v2(168.41,61.97) v2(178.52,67.71) v2(178.52,67.07) v2(178.52,66.44) v2(178.52,65.8) v2(179.03,65.37) v2(179.08,68.57) v2(179.08,67.94) v2(179.08,67.3) v2(179.08,66.67) v2(179.08,66.03) v2(179.71,68.57) v2(179.71,67.94) v2(179.71,67.3) v2(179.71,66.67) v2(179.71,66.03) v2(179.71,65.42) v2(179.71,64.79) v2(180.35,69.21) v2(180.35,68.57) v2(180.35,67.94) v2(180.35,67.3) v2(180.35,66.67) v2(180.35,66.03) v2(180.35,65.4) v2(180.35,64.38) v2(180.35,63.74) v2(180.98,70.48) v2(180.98,69.84) v2(180.98,69.21) v2(180.98,64.38) v2(180.98,63.74) v2(181.62,70.48) v2(181.62,69.84) v2(181.62,69.21) v2(181.62,64.38) v2(181.62,63.74) v2(182.25,70.48) v2(182.25,69.84) v2(182.25,69.21) v2(182.25,64.38) v2(182.25,63.74) v2(182.89,64.38) v2(182.89,63.74) v2(183.52,64.38) v2(183.52,63.74) v2(184.16,64.38) v2(184.16,63.74) v2(184.46,70.48) v2(184.46,69.84) v2(184.46,69.21) v2(184.79,64.38) v2(184.79,63.49) v2(185.1,70.48) v2(185.1,69.84) v2(185.1,69.21) v2(185.3,65.65) v2(185.38,65.01) v2(185.38,64.38) v2(185.38,63.74) v3(158.84,64.51)
+INV_PWR_SRC:
  vias: v2(61.17,24.65) v2(61.71,23.92) v2(61.77,24.53) v3(60,20.39) v3(60.31,24.93) v3(61.05,21.83)
+LAN_IO: length 1.9
  BOTTOM w0.203: CL15.1 288.82,45.29 UL1.11
  vias: v2(281.82,48.25) v2(282.46,48.25) v2(282.53,47.67) v2(283.22,46.6) v2(284.57,41.27) v2(284.9,41.85) v2(289.7,47.74) v2(290.28,47.72) v3(282.23,44.52)
+LAN_VDD: length 4.3
  TOP w0.508: v2(283.14,45.34) 283.33,45.53 CL32.1 ; v2(285.4,47.59) 285.58,47.41 CL20.1 ; CL22.1 287.82,47.18 v2(287.82,47.4)
  BOTTOM w0.203: v2(283.14,45.34) 283.19,45.29 UL1.30 ; UL1.3 285.41,47.26
  BOTTOM w0.381: 285.41,47.26 285.41,47.58 v2(285.4,47.59)
  vias: v2(282.69,41.53) v2(283.27,41.53) v2(283.91,41.53)
+PLLVDD: length 6.1
  TOP w0.127: LV8.1 163.28,78.98 162.9,78.6 v1(162.9,77.24)
  TOP w0.508: LV8.1 163.41,79.04 CV73.1 163.41,82.2 CV72.1
  BOTTOM w0.305: v2(162.63,82.24) 162.63,82.17 UV1.AD8
+RTCBATT: length 3.7
  BOTTOM w0.102: RC11.2 155.38,15.92 v3(155.69,15.6)
  BOTTOM w0.508: JRTC.1 154.17,14.9 154.51,15.23 RC11.2
+RTCVCC: length 183
  TOP w0.508: v2(179.11,20.26) 179.03,20.18 179.03,19.37 v3(178.55,18.89) 177.84,18.89 177.71,18.76 RH83.1 RH143.2 RH84.1 ; v2(281.19,16.6) 281.42,16.6 282.03,17.21 RA18.2 ; CH173.1 CH80.1 168.64,25.72 168.64,24.83 v2(169.15,24.32)
  IN1 w0.508: v2(245.68,20.18) 248.32,20.18 248.9,19.6 250.5,19.6 252.13,17.97 252.13,14.11 254.77,11.47 v2(254.77,10.89)
  IN2 w0.508: v2(254.77,10.89) 255.41,10.89 256.98,12.46 258.33,12.46 259.9,14.04 268.18,14.04 269.71,15.56 279.64,15.56 280.68,16.6 v2(281.19,16.6) ; v2(222.21,33.34) 222.21,32.86 221.1,31.75 214.91,31.75 214.24,31.08 205.99,31.08 205.14,31.93 205.14,32.02 203.41,33.75 202.85,33.75 202.19,33.09 202.19,30.7 199.76,28.26 193.51,28.26 192.95,28.82 190.89,28.82 189.04,26.96 189.04,24.04 187.84,22.85 181.34,22.85 179.11,20.61 179.11,20.28 ; 179.11,20.28 179.05,20.23 176.79,20.23 175.68,21.35 175.68,21.49 174.95,22.22 171.12,22.22 170.36,22.98 170.06,22.98 169.23,23.81 169.23,24.25 v2(169.15,24.32) ; 179.11,20.28 v2(179.11,20.26)
  IN3 w0.508: v2(169.15,24.32) 169.04,24.43 167.63,24.43 167.27,24.07 167.27,24.06 167.21,24 167.21,23.99 166.85,23.63 166.72,23.63 166.14,23.05 165.52,23.05 165.51,23.06 165.41,23.06 164.86,23.61 163.81,23.61 162.6,22.39 160.82,22.39 159.95,21.53 v2(159.93,21.53)
  BOTTOM w0.254: v2(169.15,24.32) 169.12,24.32 UH2.BA22
  BOTTOM w0.508: v2(222.21,33.34) 222.21,33.9 221.94,34.17 RE16.1 221.41,34.13 221.41,32.97 221.67,32.71 222.08,32.71 222.51,32.27 RE31.1 RE52.2 224.42,32.07 225.18,32.83 225.18,34.66 225.94,35.42 230.88,35.42 231.38,34.93 238.81,34.93 240.67,33.06 240.67,31.89 241.94,30.62 241.94,27.71 242.52,27.14 243.02,27.14 243.74,26.42 243.74,24.67 244.36,24.05 244.36,23.71 245.58,22.49 245.58,20.61 245.68,20.51 v2(245.68,20.18) ; v2(159.93,21.53) 159.93,20.92 158.94,19.93 156.09,19.93 154.96,18.8 CC27.1 154.51,19.42 153.75,20.18 DC2.1
+RTCVCC_VBAT: length 4.7
  TOP w0.203: UE1.122 224.25,32.85
  TOP w0.254: v2(223.83,33.39) 223.83,33.27 224.25,32.85
  BOTTOM w0.127: v2(223.83,33.39) v1(224.26,32.96)
  BOTTOM w0.508: RE16.2 223.54,34.46 CE73.1 224.29,34.11 223.83,33.65 v2(223.83,33.39)
+SP_PLLVDD: length 1.2
  BOTTOM w0.305: UV1.AE8 162.21,81.81 v2(162.57,81.45) 162.99,81.03 UV1.AD7
  vias: v1(162.04,81.19)
+V_DAC: length 16.1
  TOP w0.508: v2(294.49,84.95) 294.49,84.05 CL41.1 v1(296.53,84.01) v2(297.46,84.94) 297.95,84.45 299.99,84.45 v2(300.43,84.88) 300.86,84.45 303.03,84.45 303.4,84.81 v2(303.4,84.88)
  BOTTOM w0.508: TL2.10 v2(294.49,84.95) ; TL2.1 v2(303.4,84.88) ; TL2.7 v2(297.46,84.94) ; TL2.4 v2(300.43,84.88)
+V_DDR_REFA: length 62.3
  TOP w0.127: RH206.2 v1(71.77,41.95)
  TOP w0.508: RH206.2 70.88,43.04 RH209.1 ; RH45.2 RH209.1 ; RH209.1 70.83,42.54 70.6,42.31 69.2,42.31 v2(69,42.51) ; CD96.1 114.18,31.92 113.67,31.41 v2(113.62,31.41)
  IN2 w0.508: v2(69,42.51) 68.21,41.72 68.21,35.99 70.95,33.25 98.99,33.25 99.29,32.95 107.01,32.95 107.51,32.45 112.59,32.45 v2(113.62,31.41)
  BOTTOM w0.305: JDIMM1.164 113.4,31.63 v2(113.62,31.41)
+V_DDR_REFA_R: length 56
  TOP w0.508: v2(89.85,82.16) 89.06,82.16 88.3,81.4 87.89,81.4 87.26,80.76 87.26,79.31 87.72,78.86 87.72,74.94 88.63,74.02 88.63,70.51 87.44,69.32 87.44,65.45 76.74,54.75 68.48,54.75 67.45,53.72 67.45,45.91 v3(67.82,45.54) 68.44,44.92 CH101.1 RH45.1
+V_DDR_REFB: length 5.7
  TOP w0.127: v2(113.88,21.26) v1(113.88,20.53)
  TOP w0.508: RH46.2 111.77,20.88 RH207.2 112.43,20.89 RH210.1 113.31,21.72 CD29.1 113.42,21.72 v2(113.88,21.26)
  BOTTOM w0.305: v2(113.88,21.26) 113.74,21.26 113.41,20.93 JDIMM2.164
+V_DDR_REFB_R: length 131.8
  TOP w0.508: CH100.1 111.58,23.88 111.58,22.04 RH46.1 111.13,22.01 110.88,21.76 v2(110.88,21.45) ; v2(68.46,27.68) 69.16,27.68 70.11,28.63 70.11,33.26 70.94,34.09 70.94,37 70.93,37.06 70.93,39.64 v3(67.42,43.14) 66.61,43.96 66.61,53.79 67.52,54.7 67.53,54.7 68.22,55.39 76.48,55.39 86.14,65.05 86.14,74.64 83.25,77.54 83.25,80.05 85.35,82.16 v2(87.92,82.16)
  VCC w0.508: v2(110.88,21.45) 110.88,21.1 110.22,20.44 68.82,20.44 68.29,19.9 67.52,19.9 66.63,20.79 66.63,24.25 68.46,26.08 v2(68.46,27.68)
+VDISPLAY_VCC: length 3.2
  TOP w0.127: v2(297.67,64.13) 297.18,64.62 v3(296.48,64.62)
  TOP w0.508: RM1.2 v2(300.36,64.09) ; RM2.2 v2(297.67,64.13)
+VGA_B+: length 5.6
  TOP w0.508: PR1010.1 180.96,54.78 180.96,55.97 181.67,56.68 181.67,59.73
  vias: v2(151.27,52.31) v2(151.39,54.37) v2(153.04,50.92) v2(153.17,52.31) v2(153.43,54.35) v2(169.17,54.47) v2(169.17,53.84) v2(169.81,54.47) v2(169.81,53.84) v2(170.39,54.47) v2(196.73,62.35) v2(197.11,61.84) v2(197.49,62.35) v2(197.88,61.84) v2(198.26,62.35) v2(201.08,61.97) v2(201.08,61.33) v2(201.71,61.97) v2(201.71,61.33) v2(202.3,61.97) v3(172.35,61.08)
-DC_IN: length 0.7
  TOP w0.102: v2(12.75,31.27) v3(12.02,31.27)
AC_PRESENT: length 9.8
  BOTTOM w0.076: RH125.1 172.41,19.69 172.41,20.4 172.41,20.4 172.41,20.87 172.23,21.05 172.23,21.63 172.27,21.67 172.27,22.11 172.39,22.23 172.39,23.04 172.05,23.38 UH2.BB15
  BOTTOM w0.102: RH125.1 171.92,19.19 171.92,17.62 171.47,17.18 170.82,17.18 170.23,16.58 169.73,16.58 169.46,16.31 DV1.2
ACAV_IN: length 244.3
  TOP w0.102: UE1.128 221.85,30.54 v2(221.8,30.5) 220.43,31.87 217.98,31.87 212.04,25.92 211.65,25.92 211.03,25.31 211.03,20.28 v2(211.16,20.16)
  IN1 w0.114: v2(211.16,20.16) 210.74,19.73 205.88,19.73 205.34,19.2 199.19,19.2 197.83,17.84 197.81,17.84 197.21,17.84 197.21,17.84 188.74,17.84 187.35,16.46 181.14,16.46 178.96,14.28 173.19,14.28 171.22,16.24 169.37,16.24 168.43,17.18 168.14,17.18 v2(167.7,16.74) 167.7,16.88 165.82,18.76 161.73,18.76 160.88,17.91 156.99,17.91 156.19,17.11 154.61,17.11 153.04,15.55 146.69,15.55 145.17,17.07 136.53,17.07 135.45,18.16 122.4,18.16 121.93,17.68 115.59,17.68 114.41,16.5 111.88,16.5 110.39,17.99 103.72,17.99 102.6,16.87 100.28,16.87 99.65,17.5 71.93,17.5 71.09,16.66 66.59,16.66 61.53,21.72 61.53,23.41 60.39,24.55 60.39,25.07 58.93,26.52 58.93,27.1 57.31,28.72 54.93,28.72 v2(54.85,28.8)
  IN3 w0.127: v2(54.85,28.8) 53.94,28.8 50.11,32.63 43.63,32.63 37.91,38.34 34.93,38.34 34.12,39.16 26.65,39.16 v2(26.58,39.08)
  BOTTOM w0.102: v2(167.7,16.74) 167.81,16.63 167.81,15.89 168.79,14.91 DV1.1 ; v2(54.85,28.8) 53.88,28.8 50.87,31.8 50.87,36.88 49.79,37.96 PR212.1 ; v2(221.8,30.5) 221.8,30.6 221.62,30.77 CE84.2
  BOTTOM w0.203: PR316.2 26.48,39.18 v2(26.58,39.08) ; 26.48,38.29 26.76,38.29 27.31,37.74 PU300.5
  BOTTOM w0.254: PR316.2 PR318.1 26.48,38.29
ACDET_CHG: length 6.8
  BOTTOM w0.102: v1(28.31,43.37) 27.72,43.37 26.9,42.55 PR323.1
  BOTTOM w0.203: PU300.6 27.42,38.14 27.35,38.21 27.34,38.21 27.15,38.4 27.15,38.41 27.09,38.47
  BOTTOM w0.254: 27.09,38.47 27.09,40.5 PC323.1 PR317.2 PR323.1
ACDRV_CHG:
  vias: v2(26.36,37.72) v2(26.88,37.46) v3(25.88,37.15)
ALL_GPWRGD: length 13.5
  TOP w0.102: v2(147.12,82.74) 147.83,82.03 RV56.2
  IN1 w0.114: v2(146.61,75.31) 146.61,75.31 146.61,75.91 146.68,75.98 146.68,80.93 147.12,81.37 v2(147.12,82.74)
  BOTTOM w0.102: RV572.1 145.22,74.15 v1(145.57,74.5) 146.38,75.31 v2(146.61,75.31) ; UV11.4 146.45,83.41 v2(147.12,82.74) 147.38,82.48 RV579.1
ALL_SYS_PWRGD: length 206.4
  TOP w0.102: RH105.2 RH106.1 192.1,26.35 v2(192.1,27.57)
  IN2 w0.127: v2(197.04,26.3) 194.24,26.3 192.97,27.57 v2(192.1,27.57) 192.1,26.53 189.9,24.32 189.9,24.09 188.07,22.27 181.38,22.27 179.69,20.58 179.69,20.03 179.45,19.78 174.63,19.78 174.22,20.18 173.8,20.18 173.25,20.73 173.25,21.34 172.82,21.77 170.84,21.77 170.19,22.42 169.6,22.42 166.41,22.42 165.03,23.8 165.03,27.02 164.84,27.21 163.94,28.11 163.94,29.53 163.59,29.89 163.59,30.81 163.24,31.16 163.04,31.16 161.19,33.01 157.61,33.01 157.24,33.39 156.09,33.39 153.46,30.76 153.46,29.96 152.4,28.9 150.98,28.9 150.33,28.25 150.33,28.25 150.08,28 148.32,28 147.57,27.26 145.56,27.26 144.4,26.1 138.67,26.1 137.62,27.15 117.67,27.15 117.28,26.76 109.55,26.76 108.06,28.26 68.26,28.26 67.76,27.75 61.43,27.75 v2(61.22,27.55)
  BOTTOM w0.102: PQ403.2 54.73,29.81 55.67,28.87 56.8,28.87 57.74,29.81 60.39,29.81 61.17,29.02 61.17,27.6 v2(61.22,27.55) ; v2(197.04,26.3) 197.19,26.3 197.9,25.59 204.12,25.59 205.47,24.25 205.47,23.1 207.73,20.84 209.31,20.84 209.58,20.58 209.58,18.81 210.48,17.91 210.48,17.16 211.12,16.52 211.12,14.82 212.63,13.31 213.05,13.31 215.35,11.01 215.35,10.58 215.53,10.4 222.21,10.4 225.49,13.68 RE62.1
ALW_PWRGD_3V_5V: length 222.8
  IN2 w0.127: v2(254.95,17.14) 254.98,17.16 254.98,18.89 254.62,19.24 252.71,19.24 250.93,21.03 244.95,21.03 244.41,20.49 239.95,20.49 238.18,18.71 235.72,18.71 235.37,19.07 233.89,19.07 v2(233.82,19.14)
  IN3 w0.127: v2(60.21,17.69) 60.23,17.67 60.9,17.67 61.21,17.97 100.43,17.97 100.45,17.99 109.02,17.99 110.67,16.35 114.88,16.35 116.47,17.94 136.9,17.94 138.13,19.17 150.06,19.17 150.89,18.34 155.52,18.34 155.92,17.95 158.58,17.95 159.39,17.14 159.39,15.81 160.61,14.59 166.81,14.59 169.88,11.52 172,11.52 172.55,10.97 173.54,10.97 175.16,9.34 178.94,9.34 180.02,10.42 180.02,11.53 180.52,12.02 180.52,12.89 183.94,16.31 187.23,16.31 188.91,17.98 198.08,17.98 199.8,19.7 205.06,19.7 205.92,20.56 207.08,20.56 207.44,20.92 210.88,20.92 211.54,21.58 212.04,21.58 212.42,21.2 212.94,21.2 214.71,19.43 215.51,19.43 216.49,18.46 219.96,18.46 220.9,17.52 225.69,17.52 226.02,17.85 230.87,17.85 232.09,19.07 233.74,19.07 v2(233.82,19.14)
  BOTTOM w0.102: v2(254.95,17.14) 255.43,17.14 255.74,16.83 255.74,13.83 255.08,13.17 PR603.1 ; PR408.1 57.67,17.69 v1(58.81,17.69) v2(60.21,17.69)
ALWON: length 204.3
  TOP w0.102: v2(223.43,18.28) 223.25,18.28 222.95,18.58 222.95,22.27 224.24,23.56 224.24,25.62 224.34,25.72 224.34,30.44 224.65,30.75 UE1.121
  IN3 w0.127: v2(60.97,18.33) 61.09,18.21 61.1,18.23 100.33,18.23 100.34,18.24 109.13,18.24 110.77,16.6 114.77,16.6 116.36,18.19 136.7,18.19 137.93,19.42 150.19,19.42 151.01,18.6 155.65,18.6 156.04,18.2 159.01,18.2 159.65,17.57 159.65,15.92 160.69,14.87 166.89,14.87 169.95,11.81 172.08,11.81 172.68,11.22 173.64,11.22 174.58,10.28 179.53,10.28 179.77,10.52 179.77,11.63 180.26,12.12 180.26,13.01 183.81,16.56 187.13,16.56 188.8,18.24 197.98,18.24 199.69,19.95 204.96,19.95 205.81,20.81 206.97,20.81 207.34,21.17 210.78,21.17 211.44,21.83 212.15,21.83 212.53,21.45 213.04,21.45 214.81,19.69 215.62,19.69 216.6,18.71 220.07,18.71 221.01,17.77 222.92,17.77 v2(223.43,18.28)
  BOTTOM w0.102: PR418.1 57.05,26.48 59.12,26.48 60.39,25.21 60.39,24.51 62.41,22.49 62.41,20.8 60.94,19.34 60.94,18.35 v2(60.97,18.33)
AUD_AGND: length 155.6
  TOP w0.127: v3(298.38,17.82) v2(298.38,16.98) ; v2(290.87,21.35) v3(290.87,20.69)
  TOP w0.203: v2(283.82,29.56) 283.82,29.26 283.11,28.56 HDA1.38
  TOP w0.254: HDA1.25 284.36,22.27 284.44,22.19 284.44,21.86 v2(284.46,21.83) ; v2(283,18.3) 282.62,17.92 282.62,16.7 279.87,13.94 279.87,12.94 277.71,10.79 257.01,10.79 256.42,11.37 256.42,18.86 256.09,19.19 256.09,20.14 256.75,20.8 256.75,20.84 256.96,21.04 256.96,21.28 256.68,21.55 256.19,21.55 v2(256.14,21.61) 256.09,21.55 256.04,21.55 255.31,20.82 255.31,18.84 255.64,18.51 255.64,10.81 256.42,10.02 278.22,10.02 280.71,12.51 280.71,13.7 282.9,15.89 285.03,16.93 285.38,17.29 v2(285.38,18.3)
  TOP w0.457: RA54.2 291.35,17.16 290.89,17.62 v2(290.89,17.8) 291.14,18.05 CA40.2
  TOP w0.508: CA18.2 287.97,20.82 v2(288.33,20.82) ; CA24.2 v2(276.93,20.06) ; CA17.2 RA71.2 284.57,18.3 v2(285.38,18.3) ; RA55.2 CA41.2 297.39,16.88 298.28,16.88 v2(298.38,16.98) ; v2(297.7,10.66) 297.51,10.66 296.62,11.55 295.67,11.55 295.41,11.8 RA15.1 ; v2(288.33,25.29) 288.62,25 v3(288.62,24.69) 288.62,24.29 CA16.1 ; CA2.2 v2(289.33,29.31) ; v2(290.87,21.35) 291.3,21.35 RA13.1 ; RA11.1 288.25,21.71 288.25,22.52 CA19.1 v2(287.61,22.57) ; CA1.2 v2(289.57,26.66) ; CA63.1 284.4,29.56 v2(283.82,29.56)
  GND1 w0.203: JHP1.7 304.47,9.12 ; JHP1.7 302.41,9.12 ; JHP1.7 302.41,8.45 ; JHP1.7 303.44,8.45 ; JHP1.7 304.47,8.45 ; JHP1.5 301.27,8.45 ; JHP1.5 301.27,9.12 ; JHP1.5 299.31,8.45 ; JHP1.5 299.31,9.12 ; JHP1.5 300.29,8.45
  VCC w0.203: 299.31,9.12 JHP1.5 ; JHP1.5 300.29,8.45 ; JHP1.5 299.31,8.45 ; JHP1.5 301.27,8.45 ; JHP1.5 301.27,9.12 ; JHP1.7 304.47,8.45 ; JHP1.7 302.41,9.12 ; JHP1.7 304.47,9.12 ; JHP1.7 302.41,8.45 ; JHP1.7 303.44,8.45
  GND2 w0.203: JHP1.7 304.47,9.12 ; JHP1.7 304.47,8.45 ; JHP1.7 302.41,8.45 ; JHP1.7 302.41,9.12 ; JHP1.7 303.44,8.45 ; JHP1.5 301.27,8.45 ; JHP1.5 299.31,9.12 ; JHP1.5 300.29,8.45 ; JHP1.5 299.31,8.45 ; JHP1.5 301.27,9.12
  BOTTOM w0.254: RA73.2 257.82,22.62 257.64,22.62 256.63,21.61 v2(256.14,21.61)
  BOTTOM w0.508: v2(297.82,11.42) 297.82,11.98 CA42.2 ; RA9.1 279.01,21.35 v2(279.54,20.82) 279.54,20.92 280.2,21.58 CA23.2 ; CA43.2 293.23,17.34 291.3,17.34 290.89,17.74 v2(290.89,17.8) ; v2(284.46,21.83) 284.46,23.52 RA14.1 ; v2(283.82,29.56) 283.82,29.57 283.91,29.66 283.92,29.64 CA63.1 ; RA12.1 291.47,14.72 v2(290.69,15.51) ; v2(276.93,19.36) 277.4,19.36 278.1,18.66 RA16.1
AUD_AZA_CPU_SCLK: length 114.3
  TOP w0.102: v2(181.87,47.87) 182.42,48.43 190.69,48.43 192.14,46.98 192.14,40.86 190.05,38.78 189.37,38.78 188.56,37.97 188.56,37.38 188.53,37.35 v2(188.53,36.82)
  IN3 w0.127: v2(124.6,93.4) 124.19,93 124.19,92.37 124.5,92.07 129.42,92.07 130.95,93.59 132.34,93.59 143.06,82.87 143.06,80.59 144.71,78.94 144.71,75.2 145.26,74.65 145.26,73.56 147.33,71.49 159.14,71.49 159.6,71.95 165.95,71.95 166.18,71.72 166.99,71.72 168.85,69.86 168.85,67.87 169.23,67.49 169.23,63.45 169.68,63 169.67,62.99 173.44,59.22 175.44,59.22 176.18,58.48 176.18,57.88 177.81,56.25 177.81,55.24 181.47,51.58 181.47,48.28 v2(181.87,47.87)
  BOTTOM w0.076: v2(124.6,93.4) 124.32,93.12 124.32,93.02 UH1.G27
  BOTTOM w0.102: RH147.1 188.22,36.37 188.53,36.68 v2(188.53,36.82)
AUD_AZA_CPU_SCLK_R: length 13.3
  BOTTOM w0.076: UH2.AM2 178.33,28.35 178.69,27.99 178.96,27.99 179.22,28.25 181.17,28.25 182.1,29.18 182.1,29.28 182.83,30
  BOTTOM w0.102: RH147.2 188.22,34.64 186.98,33.39 186.36,33.39 v1(184.87,31.89) 184.72,31.89 182.83,30
AUD_AZA_CPU_SDI_R: length 118
  TOP w0.102: v2(142.05,99.02) 140.8,99.02 v1(139.49,97.72) 136.71,94.94 135.7,94.94 135.14,95.49 RH145.2
  IN3 w0.127: v2(191.68,37.76) 192.12,38.2 192.12,46.96 185.81,53.27 185.81,56.78 183.91,58.69 183.91,59.25 183.02,60.14 180.84,60.14 173.87,67.1 173.87,69.33 172.94,70.26 172.94,72.09 171.98,73.06 171.36,73.06 167.82,76.6 159.8,76.6 159.14,77.26 156.8,77.26 155.69,78.37 155.69,81.08 153.17,83.6 153.17,88.86 143.01,99.02 v2(142.05,99.02)
  BOTTOM w0.076: 182.59,29.15 182.31,29.15 181.24,28.08 179.29,28.08 178.97,27.76 178.67,27.76 178.56,27.87 UH2.AN2
  BOTTOM w0.102: 182.59,29.15 182.83,29.39 183.08,29.39 184.97,31.28 185.15,31.28 185.93,32.06 186.51,32.06 188.83,34.38 188.83,36.18 189.78,37.12 190.49,37.12 190.77,37.4 191.32,37.4 191.68,37.76 v2(191.68,37.76)
AUD_AZA_CPU_SDO: length 119
  IN1 w0.114: v2(124.01,91.84) 124.43,91.84 124.8,91.46 129.9,91.46 130.31,91.87 130.31,92.87 130.93,93.49 133.84,93.49 135.99,91.34 136.4,91.34 136.4,91.34 141.82,91.34 149.83,83.33 149.83,78.13 152.63,75.33 153.99,75.33 154.67,74.65 157.84,74.65 157.85,74.65 158.08,74.65 158.59,74.14 166.1,74.14 167.8,72.43 167.8,71.34 169.18,69.96 169.18,63.57 173.72,59.03 175.73,59.03 176.53,58.23 176.53,57.51 178.02,56.02 178.02,54.24 180.8,51.47 188.47,51.47 188.67,51.47 190.49,49.64 194.53,49.64 195.11,49.06 v2(195.29,49.06)
  BOTTOM w0.076: v2(124.01,91.84) 124.01,91.76 124.31,91.46 UH1.G25
  BOTTOM w0.102: RH146.1 187.33,36.3 188.39,37.35 190.39,37.35 190.67,37.63 190.92,37.63 192.49,39.21 193.28,39.21 193.86,39.79 193.86,47.84 195.08,49.06 v2(195.29,49.06)
AUD_AZA_CPU_SDO_R: length 12.3
  BOTTOM w0.076: UH2.AM1 178.81,28.3 178.93,28.41 181.08,28.41 181.78,29.12
  BOTTOM w0.102: RH146.2 187.33,34.64 186.71,34.01 v1(185.91,34.01) 185.37,34.01 184.59,33.23 184.59,32.63 183.65,31.68 183.65,31.29 182.28,29.92 181.78,29.42 181.78,29.12
AUD_HP1_JACK_L: length 18.1
  TOP w0.203: 286.1,25.36 HDA1.32
  TOP w0.508: RA44.1 v2(295.67,13.2)
  IN1 w1.016: 294.9,13.63 294.47,14.06 292.9,14.06 291.81,15.15 291.81,18.13 290.97,18.96 290.97,19.62 289.75,20.84 289.75,22.01 287.26,24.5
  BOTTOM w0.102: v2(287.21,25.64) v1(287.21,25.06)
  vias: v2(286.57,25.66)
AUD_HP1_JACK_L1: length 1
  TOP w0.102: RA46.2 v1(298.36,12.31)
AUD_HP1_JACK_R: length 16.4
  TOP w0.102: v2(287.03,26.41) 287.54,26.41 v1(287.86,26.09)
  TOP w0.203: v2(286.39,26.41) 285.74,25.76 HDA1.33
  TOP w0.508: RA49.1 293.13,15.36 v2(293.25,15.48)
  IN1 w1.016: 293.28,16.42 293.28,18.63 292.34,19.57 292.34,20.46 291.83,20.97 291.83,21.78 289.49,24.12 289.49,25.36 288.45,26.41 288.05,26.41
AUD_HP1_JACK_R1: length 1.2
  TOP w0.102: v1(289.25,16.94) 289.93,16.27 RA53.2
AUD_PC_BEEP: length 1
  TOP w0.254: CA29.2 279.83,18.8 RA19.2
AUD_PC_BEEP_C: length 9.6
  TOP w0.254: v2(278.98,14.95) 279.61,15.59 RA30.1
  BOTTOM w0.254: D1.1 274.71,19.9 274.71,17.26 v1(275.49,16.49) 275.63,16.49 277.16,14.95 v2(278.98,14.95)
AUD_PORTA_L_R_B: length 13.4
  BOTTOM w1.016: v2(296.3,18.15) 296.3,18.07 295.84,17.62 295.84,16.55 294.98,15.69 DA5.3 296.35,14.24 297.39,15.28 297.39,17.31 298.51,18.43 300.53,18.43 JHP1.1
  vias: v3(295.77,17.82)
AUD_PORTA_R_R_B: length 12.5
  TOP w1.016: 294.82,20.21 304.81,20.21 305.84,19.18 JHP1.2
  vias: v2(293.27,20.44) v2(293.3,19.85) v3(292.64,19.62)
AUD_SENSE: length 14.5
  TOP w0.254: v2(279.19,18.58) 278.88,18.27 RA22.2
  BOTTOM w0.254: v2(279.19,18.58) 279.5,18.28 281.06,18.28 281.57,18.79 v1(287.92,18.79) 290,16.7 RA56.2
AUD_SENSE_A: length 7.1
  TOP w0.102: v1(276.67,20.54) 276.43,20.31 276.43,19.25 276.82,18.86 RA24.2
  TOP w0.203: HDA1.13 279.11,21.06 278.47,20.41 CA24.1 278.47,19.19 RA22.1
  TOP w0.254: RA24.2 277.5,18.41 278.28,19.18 RA22.1
AUD_SPK_L+: length 12.2
  TOP w0.203: v2(281.52,29.59) v2(281.52,30.17)
  IN3 w1.016: 275.6,18.91 275.6,20.69 278.62,23.71 279.66,23.71 280.4,24.45 280.4,27.07 280.98,27.65
  vias: v1(281.49,29.05) v2(275.6,17.52) v2(276.23,17.52)
AUD_SPK_L+_C: length 32.5
  TOP w0.127: JSPK1.3 302.41,7.31 v3(302.63,7.53)
  IN3 w1.016: 301.43,3.42 298.61,3.42 287.54,14.49 284.36,14.49 281.29,11.42 278.14,11.42 277.02,12.54
  vias: v2(276.62,14.09) v2(276.62,13.5) v2(302.17,4.26) v2(302.57,4.69)
AUD_SPK_L-: length 19.7
  TOP w0.203: HDA1.43 281.11,28.31 280.93,28.49 280.93,29.4 280.78,29.56 v2(280.78,29.61) 280.76,29.63 280.76,30.19 v2(280.78,30.22)
  IN3 w1.016: 276.28,16.47 275.19,16.47 274.33,17.34 274.33,21.66 275.85,23.18 275.85,24.45 275.83,24.47 275.83,25.19 275.85,25.21 275.85,25.8 278.58,28.52 279.81,28.52
  BOTTOM w0.102: v1(280.95,29.06) 280.78,29.23 v2(280.78,29.61)
  vias: v2(277,17.43) v2(277.01,16.8)
AUD_SPK_L-_C: length 31.6
  TOP w0.127: v2(278.75,14.21) v1(279.47,14.21)
  IN3 w1.016: 303.59,4.51 303.59,5.32 302.98,5.93 298,5.93 287.97,15.97 283.78,15.97 280.58,12.77 279.23,12.77
  vias: v2(278.77,13.58) v2(303.31,4.16) v2(303.69,4.66)
AUD_SPK_R+: length 16.6
  TOP w0.203: HDA1.45 280.31,28.52 279.59,29.25 v2(279.59,29.53) 279.56,29.56 v2(279.56,30.14)
  IN1 w1.016: 278.42,29.07 276.84,27.5 276.84,26.84 275.83,25.82 275.83,23.21 273.92,21.3 273.06,21.3 271.28,19.52 270.88,19.52
  BOTTOM w0.102: v2(279.59,29.53) v1(279.59,29.02)
  vias: v2(271.01,17.78) v2(271.42,17.34)
AUD_SPK_R+_C: length 33.2
  IN1 w1.016: 271.79,12.03 272.88,10.94 280.98,10.94 284.58,14.53 287.55,14.53 297.67,4.41 298.89,4.41
  vias: v2(271.82,13.35) v2(271.92,13.96) v2(299.73,4.56) v2(300.31,4.61) v3(269.4,14.8)
AUD_SPK_R-: length 16.2
  TOP w0.203: v2(280.17,30.22) v2(280.17,29.58) 280.17,29.4 280.63,28.95 280.63,28.27 280.71,28.18 HDA1.44
  IN1 w1.016: 279.54,27.87 279.14,27.87 278.27,26.99 278.27,23.36 274.2,19.29 272.88,19.29 272.5,18.91
  BOTTOM w0.102: v1(279.92,30.8) 280.17,30.55 v2(280.17,30.22)
  vias: v2(272.42,18.15) v2(272.42,17.52)
AUD_SPK_R-_C: length 34.6
  TOP w0.127: JSPK1.2 301.41,6.91 v3(300.78,7.53)
  IN1 w1.016: 301.13,5.5 300.77,5.86 298.05,5.86 288.07,15.84 284.03,15.84 280.48,12.28 274.2,12.28
  vias: v2(273.82,13.96) v2(273.75,13.17) v2(301.05,4.28) v2(301.48,4.69)
B+: length 31.1
  TOP w2.032: 237.12,44.67 240.4,41.39 243.19,41.39 244.23,42.43 246.19,42.43 249.56,39.06 249.56,36.92 249.46,36.82 249.46,34.43 248.73,33.7 248.73,29.99 250.53,28.18
  BOTTOM w0.381: 207.25,60.09 207.25,61.66 207.69,62.11 PC113.1 207.69,62.99 PR106.1
  vias: v2(29.22,30.09) v2(29.22,29.45) v2(29.22,28.82) v2(29.85,30.09) v2(29.85,29.45) v2(29.85,28.82) v2(30.49,30.09) v2(30.49,29.45) v2(30.49,28.82) v2(31.12,30.09) v2(31.12,29.45) v2(31.12,28.82) v2(31.76,29.45) v2(31.76,28.82) v2(41.41,27.42) v2(41.41,26.79) v2(41.41,26.15) v2(41.41,25.52) v2(41.41,24.88) v2(41.92,24.25) v2(42.05,27.42) v2(42.05,26.79) v2(42.05,26.15) v2(42.05,25.52) v2(42.05,24.88) v2(42.55,24.25) v2(42.68,27.42) v2(42.68,26.79) v2(42.68,26.15) v2(42.68,25.52) v2(42.68,24.88) v2(43.19,24.25) v2(43.19,23.61) v2(43.57,22.98) v2(43.57,22.34) v2(43.57,21.71) v2(43.57,21.07) v2(43.57,20.44) v2(43.82,24.25) v2(43.82,23.61) v2(64.91,123.05) v2(64.91,122.42) v2(64.91,121.78) v2(64.91,121.15) v2(65.03,22.57) v2(65.24,23.71) v2(65.21,23.13) v2(65.54,123.05) v2(65.54,122.42) v2(65.54,121.78) v2(65.62,121.15) v2(66.18,123.05) v2(66.18,122.42) v2(66.18,121.78) v2(66.81,123.05) v2(66.81,122.42) v2(67.45,123.05) v2(67.45,122.42) v2(67.73,21.81) v2(67.88,21.19) v2(67.91,20.61) v2(68.08,123.05) v2(72.03,76.16) v2(72.59,76.43) v2(72.58,75.68) v2(72.55,73.93) v2(72.78,74.54) v2(73.23,76.43) v2(73.24,75.66) v2(73.16,73.95) v2(73.54,74.54) v2(73.75,73.95) v2(74.3,77.08) v2(74.3,76.44) v2(74.3,75.81) v2(74.3,75.17) v2(74.33,74.59) v2(74.33,73.95) v2(74.94,77.08) v2(74.94,76.44) v2(74.94,75.81) v2(74.94,75.17) v2(74.94,74.54) v2(75.57,77.08) v2(75.57,76.44) v2(75.57,75.81) v2(81.97,12.47) v2(82.23,13.07) v2(82.23,11.8) v2(82.61,12.44) v2(82.86,13.07) v2(82.86,11.8) v2(83.25,12.44) v2(83.5,13.07) v2(83.5,11.8) v2(83.88,12.44) v2(94.4,8.5) v2(94.35,6.72) v2(95.06,8.45) v2(95.08,6.7) v2(114.97,133.47) v2(115.3,132.93) v2(115.55,133.47) v2(115.88,132.93) v2(116.14,133.47) v2(116.47,132.93) v2(116.72,133.47) v2(118.48,133.47) v2(118.48,132.73) v2(119.29,133.47) v2(119.29,132.73) v2(121,133.37) v2(121,132.78) v2(121.59,132.87) v2(121.68,133.47) v2(122.31,133.47) v2(135.09,133.29) v2(135.82,133.29) v2(136.46,133.29) v2(136.88,116.61) v2(137.04,133.29) v2(137.45,117.61) v2(137.46,116.92) v2(137.46,116.31) v2(137.63,133.29) v2(138.06,116.91) v2(138.05,116.31) v2(138.21,133.29) v2(138.65,116.91) v2(138.66,116.32) v2(138.85,133.31) v2(140.15,14.47) v2(140.15,13.83) v2(140.15,13.2) v2(140.79,14.47) v2(140.79,13.83) v2(140.79,13.2) v2(141.36,14.21) v2(141.87,14.85) v2(142,14.21) v2(142.5,14.85) v2(142.63,14.21) v2(143.14,14.85) v2(143.27,14.21) v2(143.77,14.6) v2(149.06,40.29) v2(149.07,39.22) v2(149.38,40.81) v2(149.36,39.77) v2(149.68,40.27) v2(149.67,39.23) v2(150.02,40.76) v2(150,39.73) v2(150.33,40.25) v2(150.31,39.17) v2(150.63,39.73) v2(150.68,40.79) v2(150.95,40.24) v2(150.95,39.17) v2(151.33,39.61) v2(153.43,39.23) v2(153.93,39.55) v2(154.44,39.87) v2(154.44,39.23) v2(155.08,39.87) v2(155.08,39.23) v2(155.84,57.78) v2(156.16,58.35) v2(156.47,57.84) v2(156.85,58.92) v2(156.85,58.28) v2(169.94,53.2) v2(169.94,52.57) v2(169.94,51.93) v2(170.57,53.2) v2(170.57,52.57) v2(192.16,56.38) v2(192.26,55.72) v2(192.26,55.11) v2(192.75,56.35) v2(192.85,55.69) v2(192.85,55.11) v2(193.35,56.38) v2(193.46,55.72) v2(193.48,55.06) v2(218.58,49.77) v2(218.58,49.14) v2(218.6,48.53) v2(219.21,50) v2(219.21,49.39) v2(219.21,48.76) v2(219.47,48.2) v2(219.82,49.95) v2(233.41,44.8) v2(233.79,45.33) v2(234.12,44.8) v2(234.45,45.3) v2(234.94,44.87) v2(235.26,45.37) v2(250.08,26.11) v2(250.19,25.44) v2(250.65,25.95) v2(250.91,25.42) v2(251.27,25.95) v2(251.55,25.42) v3(90.92,16.53)
B++:
  vias: v3(47.6,17.74)
B+_AMP:
  vias: v2(253.88,27.02) v2(253.96,27.62) v2(256.04,27.65) v2(256.09,27.07) v2(267.52,21.25) v2(267.5,20.67) v2(267.5,20.08) v3(259.52,23.23)
B+_CAM: length 21.4
  TOP w0.102: v2(210.65,58.18) v3(210.65,58.94)
  IN3 w1.016: 211.69,58.18 215.53,58.18 218.27,55.44 218.27,52.82 221.78,49.32 222.84,49.32 225.89,46.27
  vias: v2(210.07,58.23) v2(227.14,45.79) v2(227.16,45.2)
BAT1_LED#: length 238.6
  TOP w0.102: UE1.1 218.35,30.14 217.9,29.7 217.7,29.7 RE39.1 216.88,28.87 215.31,28.87 212.11,25.67 211.72,25.67 211.26,25.21 211.26,20.63 211.57,20.33 211.57,19.99 211.39,19.81 211.39,17.33 v2(211.3,17.24)
  IN2 w0.127: v2(61.38,18.79) 61.76,18.41 62.69,18.41 63.19,18.9 68.46,18.9 69,19.43 92.9,19.43 93.3,19.02 93.3,18.16 94.33,17.14 109.69,17.14 110.9,15.93 115.29,15.93 116.73,17.36 136.55,17.36 137.76,18.57 147.61,18.57 149.36,16.82 150.38,16.82 155.04,12.16 157.95,12.16 159.5,13.71 166.34,13.71 167.45,13.71 170.19,10.96 172.35,10.96 174.18,9.13 180.1,9.13 180.87,9.91 180.87,11.35 182.92,13.4 185.46,13.4 186.88,14.82 187.92,14.82 189.63,16.54 192.38,16.54 192.88,17.03 197.91,17.03 199.53,18.66 206.45,18.66 206.64,18.85 207.78,18.85 208.29,18.34 210.26,18.34 211.3,17.3 v2(211.3,17.24)
  IN3 w0.127: v2(61.38,18.79) 61.31,18.85 60.76,18.85 57.83,15.92 55.03,15.92 49.8,10.69 49.8,10.69 48.25,9.13 24.98,9.13 21.68,12.44 18.55,12.44 16.14,14.85 14.01,14.85 v2(13.6,15.26)
  BOTTOM w0.102: QE20.5 v2(13.6,15.26)
BAT2_LED#: length 265.5
  TOP w0.102: v2(233.92,21.63) 233.91,21.63 232.88,22.67 232.88,24.53 232.34,25.06 232.34,28.84 232.06,29.12 232.06,29.61 231.73,29.94 230.78,29.94 230.54,30.17 230.54,30.51 230.65,30.62 UE1.106 230.65,32.67 230.51,32.81 230.51,34.33 RE113.1
  IN2 w0.127: v2(233.92,21.63) 233.87,21.68 233.59,21.68 232.52,20.61 232.52,19.26 230.25,17 229.11,17 227.97,15.86 227.97,14.44 227.57,14.04 225.05,14.04 222.29,16.8 216.34,16.8 215.06,15.52 210.19,15.52 208.81,16.91 199.22,16.91 198.26,15.95 193.34,15.95 192.86,15.47 190,15.47 188.34,13.81 187.46,13.81 183.38,9.73 182.34,9.73 180.43,7.81 171.89,7.81 167.01,12.69 160.77,12.69 158.79,10.71 154.71,10.71 150.85,14.57 148.49,14.57 145.6,17.45 143.71,17.45 143.1,16.84 119.91,16.84 119.41,16.34 118.33,16.34 116.98,14.99 111.48,14.99 109.59,16.88 94.23,16.88 93.05,18.06 93.05,18.92 92.83,19.14 69.07,19.14 68.49,18.56 63.21,18.56 61.73,17.08 v2(60.83,17.08)
  IN3 w0.127: v2(15.15,14.11) 16.23,13.03 16.88,13.03 18.23,11.67 21.36,11.67 24.66,8.37 48.56,8.37 50.11,9.92 50.12,9.92 55.35,15.16 58.14,15.16 59.38,16.4 60.15,16.4 v2(60.83,17.08)
  BOTTOM w0.102: QE23.2 15.5,18.65 15.12,18.27 15.12,16.88 14.89,16.65 14.89,15.28 15.15,15.03 v2(15.15,14.11)
BATDRV_CHG: length 26.7
  TOP w0.102: v2(40.4,15.48) v1(40.9,14.98)
  TOP w0.635: PR306.2 v2(39.63,15.48)
  IN1 w0.635: 33.28,36.95 33.28,29.1 39.43,22.96 39.43,17.95 40.4,16.98 v2(40.4,15.48) v2(39.63,15.48)
  vias: v2(33.79,37.46) v2(34.43,37.46)
BATSRC_CHG: length 28.9
  TOP w0.102: v2(37.86,15.48) 37.4,15.48 v1(37.14,15.74)
  TOP w0.635: PR307.2 v2(38.62,15.48)
  IN3 w0.635: v2(37.86,15.48) v2(38.62,15.48) 38.62,22.04 33.41,27.24 33.41,31.94 32.62,32.73 32.62,37.71 33.26,38.34 v2(33.41,38.34) v2(34.12,38.34)
BATT++: length 2
  TOP w0.127: v2(46.62,13.68) v3(47.33,13.68) ; v2(46.59,16.12) 46.59,15.81 v3(46.36,15.59) ; v2(44.46,13.68) v3(43.77,13.68)
BATT_PRS#: length 18.1
  TOP w0.102: v2(37.32,13.88) 37.07,13.88 v3(36.65,14.3)
  IN1 w0.114: v2(37.32,13.88) 37.25,13.88 36.05,12.69 30.03,12.69 29.11,13.62 29.11,14.23 v2(28.94,14.39)
  BOTTOM w0.102: PR111.1 26.48,13.33 26.81,13.66 26.81,14.47 27.39,15.05 28.28,15.05 v2(28.94,14.39) ; v2(37.32,13.88) 37.69,13.52 JBAT10.6
BBS_BIT0: length 3.7
  TOP w0.102: v1(162.95,28.95) 163.22,28.95 164.14,28.03 RH130.2 164.35,27.86 164.35,26.96 v2(164.42,26.89)
  BOTTOM w0.102: UH2.AT29 165.05,26.27 v2(164.42,26.89)
BEEP: length 57.7
  TOP w0.102: v2(226.32,14.77) 226.32,14.82 226.65,15.15 UE1.45
  IN1 w0.114: v2(226.32,14.77) 226.32,14.85 226.91,15.43 227.92,15.43 228.98,16.5 230.64,16.5 231.96,17.81 231.96,18.83 233.23,20.1 238.12,20.1 238.7,20.68 242.35,20.68 243.81,22.14 244.89,22.14 246.21,23.46 260.14,23.46 260.33,23.27 262.04,23.27 262.79,24.02 266.68,24.02 267.17,24.5 v2(267.17,24.55)
  BOTTOM w0.102: v2(267.17,24.55) 267.29,24.68 270.04,24.68 270.29,24.42 270.29,24.17 270.19,24.07 v1(270.19,23.74) 270.19,23.41 270.77,22.82 271.31,22.82 271.61,22.52 271.98,22.52 272.27,22.23 272.27,21.81 272.09,21.63 272.09,20.03 272.65,19.47 D1.2
BIA_PWM_PCH: length 105.2
  TOP w0.102: v1(68.09,29.4) v2(67.7,29.78) 67.3,30.18 DV2.2 ; RH20.2 161.05,35.04 v2(160.92,35.04)
  IN2 w0.127: v2(160.92,35.04) 160.48,35.48 159.04,35.48 157.49,37.03 156.25,37.03 154.87,35.65 154.87,33.91 152.12,31.16 149.21,31.16 147.32,29.26 141.78,29.26 140.7,28.19 116.93,28.19 116.79,28.05 112.33,28.05 112.13,28.25 111,28.25 111,28.26 109.59,28.26 106.92,30.93 99.6,30.93 98.49,32.04 71.46,32.04 70.01,30.6 67.95,30.6 67.7,30.34 v2(67.7,29.78)
  BOTTOM w0.089: UH2.W36 161.35,34.61 v2(160.92,35.04)
BOARD_ID: length 7.4
  TOP w0.102: v1(228.46,35.04) 228.46,34.71 228.76,34.41 228.76,32.93 228.65,32.82 UE1.111 228.65,30.38 v2(228.61,30.34)
  BOTTOM w0.102: v2(228.61,30.34) 228.61,29.85 CE98.1 RE14.2 RE13.2
BOARD_ID_14_15: length 9
  TOP w0.102: v2(161.65,28.22) 161.23,27.8 161.21,27.8 v1(161.16,27.76) 160.1,27.76 159.95,27.9 159.27,27.9 159.12,27.75 156.6,27.75 156.07,28.29 156.07,28.9 RH495.1 155.64,28.82 RH494.2
  BOTTOM w0.102: UH2.AL35 v2(161.65,28.22)
BREATH_LED: length 102.6
  TOP w0.102: JPW.2 202.1,34.58 202.94,33.75 204.51,33.75 204.89,34.13 204.91,34.13 204.99,34.2 205.75,34.2 206,34.2 206.18,34.03 208.05,34.03 LED4.1 208.99,34.14 209.77,33.37 211.11,33.37 211.57,33.82 211.57,34.83 211.39,35 211.39,36.04 212.28,36.93 212.28,37.56 212.51,37.79 212.51,38.21 213.92,39.61 217.22,39.61 218.66,41.06 235.8,41.06 237.42,39.44 v3(241.13,39.44) 242.28,39.44 v2(243.01,38.7)
  IN2 w0.127: v2(288.33,56.76) 288.25,56.84 283.17,56.84 274.51,48.17 272,48.17 269.9,47.04 266.31,45.29 265.86,45.29 261.15,43.54 259.61,43.54 257.21,41.84 253.26,41.84 250.38,38.95 243.27,38.95 v2(243.01,38.7)
  BOTTOM w0.102: QE24.3 288.56,58.22 LED3.1 288.33,57.93 v2(288.33,56.76)
BREATH_LED#_EC: length 88.4
  TOP w0.102: UE1.70 237.49,19.74 237.68,19.55 v2(237.68,19.17)
  IN2 w0.127: v2(290.74,59.86) 291.83,58.77 291.83,49.75 293.05,48.53 293.05,43.55 291.45,41.95 290.99,41.95 289.53,40.49 288.39,40.49 287.46,39.56 280.3,39.56 278.17,37.43 278.17,37.1 277.57,36.5 273.25,36.5 267.48,30.72 260.31,30.72 259.62,30.04 255.99,30.04 254.57,28.62 250.53,28.62 246.16,24.25 244.82,24.25 243.19,22.63 241.82,22.63 241.58,22.38 241.58,22.14 241,21.57 240.67,21.57 238.43,19.32 237.83,19.32 v2(237.68,19.17)
  BOTTOM w0.102: QE24.2 v2(290.74,59.86) ; RE119.1 238.05,19.55 v2(237.68,19.17)
