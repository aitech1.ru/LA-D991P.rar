# Allegro board Dell Inspiron 15 Gaming 7566 Compal LA-D991P BCV00 Rev1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BST1_3V: length 1.3
  BOTTOM w0.508: PC411.2 52.09,16.82 PR412.1
BST1_5V: length 1.1
  BOTTOM w0.102: PR413.2 v1(50.68,27.32)
BST_1VALWP: length 2.7
  BOTTOM w0.102: v1(249.37,20.77) 249.37,18.82 249.01,18.46 PR601.1
BST_1VALWP_R: length 1.1
  BOTTOM w0.102: PC605.1 v1(246.86,18.95)
BST_5V: length 3.8
  BOTTOM w0.102: PR413.1 50.04,24.82 v1(49.46,24.25)
  BOTTOM w0.203: PU400.17 51.94,23.6 50.72,24.82 PR413.1
BST_+0.95VSP: length 4.5
  TOP w0.102: v1(71.33,71.03) 71.25,70.95 69.32,70.95 69.15,70.78 PR701.1
  TOP w0.254: PU700.1 68.4,69.87
  TOP w0.508: PR701.1 68.88,70.35 68.4,69.87
BST_+0.95VSP_R: length 1.1
  TOP w0.102: v1(71.61,69.66) 71.02,70.26 PC701.1
BST_+1.05VSP_R: length 3.7
  BOTTOM w0.102: PC803.1 220.86,48.35 221.17,48.66 v1(221.17,50.41)
  BOTTOM w0.508: PC803.1 221.41,47.91 PR803.2
BST_+1.35VS_VGAP: length 0.7
  TOP w0.102: v2(142.45,114.53) v3(142.45,113.85)
BT_RADIO_DIS#: length 44.8
  IN3 w0.127: v2(196.05,33.87) 188.12,33.87 185.84,31.59 184.64,31.59 184.29,31.23 183.07,31.23 181.88,30.04 180.34,30.04 180.13,29.84 177.61,29.84 177.33,29.56 170.97,29.56 170.93,29.52 165.58,29.52 162.24,26.18 162.24,26 161.76,25.52 159.6,25.52 v2(159.5,25.41)
  BOTTOM w0.102: DN2.1 196.55,36.05 196.55,35.98 196.79,35.75 196.79,34.34 v1(196.55,34.1) 196.55,34 196.45,33.9 196.07,33.9 v2(196.05,33.87) ; UH2.AV43 v2(159.5,25.41)
BT_RADIO_DIS#_R: length 7.2
  BOTTOM w0.102: DN2.2 196.22,34.97 195.44,34.18 195.44,33.01 195.74,32.71 196.43,32.71 v1(196.62,32.51) 197.56,31.57 JNGFF1.46
BTST_CHG:
  vias: v1(29.87,34.1)
CAM_CBL_DET#: length 99.1
  TOP w0.102: v2(155.16,37.86) 155.21,37.91 156.17,37.91 v3(156.25,37.99)
  IN2 w0.127: v2(232.57,42.42) 232.9,42.09 232.9,41.44 230.9,39.44 220.56,39.44 220.29,39.17 218.66,39.17 217.61,38.12 217.61,36.02 216.6,35.01 211.75,35.01 211.14,35.61 208.89,35.61 206.74,37.76 201.84,37.76 200.75,38.85 188.68,38.85 v2(188,38.17)
  IN3 w0.127: v2(155.16,37.86) 155.53,37.86 157.67,40 157.67,42.03 158.99,43.35 162.01,43.35 162.37,43.7 176.22,43.7 178.24,41.68 178.24,41.22 180.68,38.77 183.49,38.77 184.09,38.17 v2(188,38.17)
  BOTTOM w0.089: 156.13,36.97 156.13,36.12 156.34,35.91 156.69,35.91 156.73,35.87 156.84,35.87 157.02,35.7 157.93,35.7 UH2.U43
  BOTTOM w0.102: JCAM1.10 232.02,42.97 v2(232.57,42.42) ; 156.13,36.97 155.78,37.33 RH79.1 154.52,37.66 154.72,37.86 v2(155.16,37.86)
CAP_LED: length 30.7
  TOP w0.102: JKB1.4 199.5,54.51 203.96,50.05 v3(205.52,50.05) 207.53,50.05 207.86,49.72 207.86,40.02 209.13,38.75 211.77,38.75 212.29,38.23 212.29,37.89 212.05,37.65 212.05,37.03 211.21,36.19 RE2.2
CAPS_LED#: length 34
  TOP w0.102: v2(220.32,33.63) 219.65,32.96 v1(218.09,32.96) RE120.1 215.53,32.96 QE3.3 ; v2(237.26,33.64) 237.26,31.96 236.34,31.03 235.21,31.03 234.81,30.62 234.81,29.05 234.91,28.94 UE1.93
  IN2 w0.127: v2(237.26,33.64) 235.68,35.23 233.91,35.23 231.46,37.68 229.07,37.68 228.81,37.42 227.49,37.42 227.05,36.98 226.86,36.79 226.86,35.72 226.12,34.99 221,34.99 220.4,34.39 220.4,33.71 v2(220.32,33.63)
CFG0: length 2.5
  TOP w0.102: RH183.1 89.16,90.91 v2(89.86,91.6) 90.28,91.18 90.28,91.13 v1(90.51,90.9)
  BOTTOM w0.076: v2(89.86,91.6) 89.53,91.28 UH1.BN25
CFG2: length 2.7
  TOP w0.102: v1(89.93,92.14) 89.75,92.14 v2(89.21,91.6) 89.08,91.6 88.35,90.87 RH184.1
  BOTTOM w0.076: UH1.BN26 89.53,91.93 v2(89.21,91.6)
CFG4: length 5.7
  BOTTOM w0.102: v1(83.35,85.46) 84.82,85.46 85.3,85.94 RH185.1 86.27,86.93 87.84,86.93 88.18,87.27 UH1.BR20
CFG5: length 6.5
  BOTTOM w0.102: RH186.1 85.73,84.95 85.97,85.19 85.97,85.24 v1(86.22,85.49) 86.22,85.87 86.45,86.1 89.67,86.1 89.85,86.28 89.85,86.94 UH1.BM20
CFG6: length 2.5
  BOTTOM w0.102: UH1.BT20 v1(86.19,87.27) 86,87.27 85.58,86.86 RH187.1
CFG7: length 3.8
  BOTTOM w0.102: RH188.1 85.73,87.75 85.84,87.65 88.51,87.65 UH1.BP20
CFG_RCOMP: length 3.1
  BOTTOM w0.254: RH59.1 85.3,89.55 85.81,90.06 v1(86.22,90.06) 86.51,90.35 86.51,90.5 87.21,91.21 UH1.BT25
CHG_B+:
  vias: v2(17.54,23.74) v2(17.54,23.1) v2(17.54,22.47) v2(17.54,21.83) v2(18.17,23.74) v2(18.17,23.1) v2(18.17,22.47) v2(18.17,21.83) v2(18.81,23.74) v2(18.81,23.1) v3(17.56,18.76)
CHG_SMBCLK: length 4.2
  BOTTOM w0.102: PR328.1 32.6,40.63 31.63,40.63 31.3,40.3 30.59,40.3 30.27,39.98 PU300.12
CHG_SMBDAT: length 3.6
  BOTTOM w0.102: PR327.1 31.96,40.88 31.51,40.88 31.15,40.53 30.48,40.53 29.87,39.92 PU300.11
CLK_PCI_LPC_MEC: length 79.7
  TOP w0.102: RH168.2 170.7,17.95 CC4.2 170.14,15.77 170.14,14.31 170.62,13.83 171.15,13.83 171.74,13.25 v3(172.09,13.25) 173.06,13.25 173.52,12.79 v2(173.52,12.41) ; UE1.57 231.45,14.9 230.58,14.02 230.58,12.98 230.36,12.77 RE10.2 229.68,11.37 228.76,10.45 222.82,10.45 221.05,12.22 221.05,13.16 220.66,13.55 220.66,15.64 v2(220.28,16.02)
  IN1 w0.114: v2(173.52,12.41) 174,11.93 180.07,11.93 182.71,14.57 183.63,14.57 184.13,15.07 187.93,15.07 189.31,16.45 198.67,16.45 200.01,17.8 205.29,17.8 205.76,17.33 207.26,17.33 208.21,18.27 211.88,18.27 211.96,18.19 212.32,18.19 212.84,18.71 215.45,18.71 216.39,17.77 216.52,17.77 217.05,17.24 219.44,17.24 220.28,16.4 v2(220.28,16.02)
CLK_PCI_LPDEBUG: length 69.9
  TOP w0.102: CC5.2 RH16.2 v1(185.73,26.23) 185.73,26.96 185.73,26.96 v2(185.73,27.37)
  IN3 w0.127: v2(185.73,27.37) 185.89,27.52 187.97,27.52 190.84,30.39 v2(190.84,30.6) 191.22,30.6 192.19,29.63 204.53,29.63 205.57,28.59 207.73,28.59 208.92,29.78 210.98,29.78 211.97,28.79 215.12,28.79 216.44,27.47 217.32,27.47 217.72,27.07 220.23,27.07 220.98,26.32 223.04,26.32 223.33,26.61 229.62,26.61 229.82,26.41 233.15,26.41 233.42,26.67 235.03,26.67 236.49,28.13 240.99,28.13 242.55,29.69 v2(242.55,30.62)
  BOTTOM w0.102: JLPDE1.10 242.52,31.41 242.55,31.38 v2(242.55,30.62) ; v2(190.84,30.6) 191.2,30.6 191.56,30.23 JNGFF1.22
CLK_PCIE_LAN: length 125.6
  IN1 w0.114: v2(289.44,42.15) 289.27,41.98 289.27,41.62 288.91,41.27 287.22,41.27 286.28,40.33 281.48,40.33 277.57,36.42 274.55,36.42 270.65,32.51 270.65,32.4 268.74,30.5 253.8,30.5 252.99,29.69 220.21,29.69 219.2,30.7 211.64,30.7 211.53,30.81 211.29,31.05 211.04,31.3 210.78,31.56 207.8,31.56 205.43,33.92 201.58,33.92 201.08,34.43 191.26,34.43 190.06,35.63 188.68,35.63 186.12,38.19 183.59,38.19 182.93,38.85 181.41,38.85 178.39,41.87 177.93,41.87 177.82,41.76 v2(177.82,41.5)
  BOTTOM w0.102: UH2.F2 v2(177.82,41.5) ; UL1.15 288.92,43.69 289.24,43.37 289.24,42.35 v2(289.44,42.15)
CLK_PCIE_LAN#: length 125.5
  IN1 w0.114: v2(288.68,42.15) 288.8,42.15 289.04,41.91 289.04,41.71 288.82,41.49 287.13,41.49 286.19,40.55 281.39,40.55 277.48,36.64 274.46,36.64 270.42,32.6 270.42,32.5 268.65,30.72 253.71,30.72 252.89,29.91 220.3,29.91 219.3,30.92 211.74,30.92 211.62,31.03 211.45,31.2 210.87,31.79 207.89,31.79 205.53,34.15 201.68,34.15 201.17,34.66 191.35,34.66 190.15,35.85 188.77,35.85 186.21,38.42 183.68,38.42 183.02,39.08 181.5,39.08 178.48,42.09 177.84,42.09 177.72,41.98 v2(177.35,41.98)
  BOTTOM w0.102: v2(177.35,41.98) 177.47,42.09 UH2.D3 ; v2(288.68,42.15) 288.91,42.15 289.04,42.29 289.04,43.29 288.84,43.49 288.65,43.49 288.59,43.43 288.59,43.37 288.52,43.29 UL1.16
CLK_PCIE_SSD: length 51.6
  IN1 w0.114: v2(175.77,37.3) 175.59,37.12 175.59,36.82 176.4,36.01 178.17,36.01 178.37,36.21 181.08,36.21 182.69,34.61 186.3,34.61 189.6,31.31 191.03,31.31 192.02,30.31 196.54,30.31 199.05,32.83 201.64,32.83 202.32,33.51 203.88,33.51 206.26,31.13 210.2,31.13 v2(211.1,30.23)
  BOTTOM w0.089: UH2.R7 176.15,36.92 v2(175.77,37.3)
  BOTTOM w0.102: v2(211.1,30.23) 210.93,30.06 210.93,29.63 211.64,28.92 211.64,26.6 210.73,25.69 210.73,23.83 210.22,23.32 JNGFF2.55
CLK_PCIE_SSD#: length 51.6
  IN1 w0.114: v2(175.01,37.3) 175.18,37.3 175.36,37.12 175.36,36.73 176.31,35.78 178.26,35.78 178.46,35.99 180.99,35.99 182.59,34.38 186.21,34.38 189.5,31.08 190.94,31.08 191.93,30.09 196.63,30.09 199.15,32.6 201.74,32.6 202.41,33.28 203.79,33.28 206.17,30.91 210.1,30.91 210.47,30.55 v2(210.47,30.23)
  BOTTOM w0.089: v2(175.01,37.3) 175.39,36.92 UH2.R8
  BOTTOM w0.102: v2(210.47,30.23) 210.53,30.23 210.73,30.02 210.73,29.55 211.44,28.84 211.44,26.69 210.53,25.77 210.53,23.92 210.13,23.52 209.74,23.52 209.64,23.62 209.64,23.75 209.57,23.82 JNGFF2.53
CLK_PCIE_WLAN: length 42.6
  IN1 w0.114: v2(190.84,33.19) 190.99,33.19 191.1,33.3 191.1,33.57 190.9,33.77 189.6,33.77 185.86,37.51 183.36,37.51 182.66,38.21 181.14,38.21 179.25,40.1 177.48,40.1 176.89,40.68 176.89,40.99 v2(176.77,41.11)
  BOTTOM w0.102: UH2.G4 177.24,40.64 v2(176.77,41.11) ; JNGFF1.39 195.81,22.8 195.96,22.95 195.96,24.9 196.28,25.22 196.28,27.75 196,28.03 193.72,28.03 192.42,26.74 188.9,26.74 187.39,28.25 187.39,30.3 189.33,32.25 190.84,32.25 191.11,32.52 191.11,32.91 v2(190.84,33.19)
CLK_PCIE_WLAN#: length 42.7
  IN1 w0.114: v2(177.35,41.11) 177.12,40.88 177.12,40.78 177.57,40.32 179.34,40.32 181.23,38.43 182.75,38.43 183.45,37.73 185.95,37.73 189.69,34 191,34 191.33,33.67 191.33,33.38 191.52,33.19 v2(191.6,33.19)
  BOTTOM w0.102: v2(191.6,33.19) 191.32,32.9 191.32,32.44 190.92,32.04 189.42,32.04 187.59,30.22 187.59,28.34 188.99,26.94 192.34,26.94 193.63,28.23 196.08,28.23 196.48,27.84 196.48,25.14 196.16,24.82 196.16,22.95 196.31,22.8 JNGFF1.41 ; UH2.E5 177.26,41.57 177.41,41.41 177.41,41.17 v2(177.35,41.11)
CLK_PEG_N16P: length 89.3
  IN3 w0.127: v2(193.25,43.48) 193.42,43.31 193.87,43.31 194.07,43.52 194.07,46.49 187.01,53.56 187.01,59.14 185,61.16 181.24,61.16 174.84,67.55 174.84,72.51 174.18,73.17 173.95,73.17 172.83,74.29 172.45,74.29 171.42,75.31 171.42,75.85 169.07,78.2 157.21,78.2 156.63,78.78 156.63,84.76 157.07,85.2 157.07,85.99 v2(157.51,86.43)
  BOTTOM w0.076: 178.88,36.02 178.87,36.02 178.85,35.99 178.73,35.99 178.65,35.91 178.26,35.91 178.04,35.68 UH2.U3
  BOTTOM w0.102: UV1.AL13 157.14,86.06 v2(157.51,86.43) ; v2(193.25,43.48) 192.93,43.17 192.61,43.17 192.24,42.8 192.24,41.71 190.55,40.02 187.28,40.02 186.92,39.66 186.08,38.82 186.08,38.41 185.25,37.58 184.48,37.58 184.02,37.12 181.82,37.12 180.72,36.02 178.88,36.02
CLK_PEG_N16P#: length 89.3
  IN3 w0.127: v2(157.49,85.66) 157.32,85.49 157.32,85.09 156.88,84.65 156.88,78.88 157.31,78.45 169.18,78.45 171.68,75.95 171.68,75.42 172.55,74.54 172.94,74.54 174.05,73.42 174.28,73.42 175.09,72.61 175.09,67.66 181.34,61.41 185.1,61.41 187.26,59.25 187.26,53.66 194.32,46.6 194.32,43.41 193.97,43.06 193.25,43.06 193.17,42.98 193.17,42.72 v2(193.28,42.61)
  BOTTOM w0.076: UH2.U2 178.37,35.66 178.37,35.48 178.42,35.42 178.62,35.42 178.7,35.5 178.7,35.73 178.8,35.83 178.86,35.83 178.87,35.81 178.88,35.81
  BOTTOM w0.102: v2(193.28,42.61) 193.28,42.64 192.96,42.96 192.69,42.96 192.44,42.71 192.44,41.62 190.64,39.82 187.37,39.82 187.13,39.58 186.28,38.73 186.28,38.32 185.34,37.38 184.57,37.38 184.11,36.92 181.91,36.92 180.8,35.81 178.88,35.81 ; UV1.AK13 v2(157.49,85.66)
CLK_REQ: length 17.4
  TOP w0.102: QV3.4 148.23,76.48 148.5,76.75 148.5,76.98 v1(150.01,78.49) 151.08,79.56 RV57.1 151.67,82.03 152.17,82.54 153.83,82.54 154.16,82.87 154.9,82.87 155.27,83.24 155.27,83.98 155.72,84.43 157.79,84.43 v2(158.29,83.93)
  BOTTOM w0.102: UV1.AK12 157.89,85.05 158.29,84.65 v2(158.29,83.93)
CLK_SMB: length 23.7
  IN1 w0.114: v2(39.74,13.92) 39.39,13.92 37.35,11.88 29.65,11.88 27.62,13.91 v2(27.62,14.34)
  BOTTOM w0.102: v2(39.74,13.92) 40.69,12.97 JBAT10.4 ; v2(27.62,14.34) 27.42,14.14 27.42,13.05 26.65,12.28 24.47,12.28 PR108.1
CLK_TP_SIO: length 123.4
  TOP w0.102: v2(237.14,23.03) 237.06,22.94 UE1.78
  IN3 w0.127: v2(237.14,23.03) 237.09,22.98 233.52,22.98 231.97,21.43 230.97,21.43 229.77,20.23 228.4,20.23 227.81,19.65 222.34,19.65 222.01,19.98 217.46,19.98 216.44,20.99 215.56,20.99 215.1,21.45 215.1,22.08 214.37,22.8 213.6,22.8 213.29,23.1 213.19,23.1 213.01,23.28 207.47,23.28 207.3,23.1 207.29,23.1 206.38,22.19 199.62,22.19 198.7,21.28 192.14,21.28 190.97,20.11 188.41,20.11 186.63,18.33 182.51,18.33 179.89,15.71 179.89,14.98 178.53,13.61 169.77,13.61 169.02,14.36 169.02,17.02 168.57,17.47 166.91,17.47 166.02,18.35 160.42,18.35 160.07,18.71 156.3,18.71 155.39,19.61 154.76,19.61 154,20.37 148.76,20.37 v2(148.3,19.9)
  BOTTOM w0.102: JTP.1 139.76,15.15 139.33,14.72 139.33,11.86 140.15,11.04 144.28,11.04 145.33,12.08 DE4.4 145.33,14.17 CE10.1 v1(146.66,15.5) 146.96,15.5 147.79,16.32 147.79,17.8 148.52,18.53 148.52,18.91 148.37,19.06 148.37,19.83 v2(148.3,19.9) ; v2(237.14,23.03) 237.07,23.1 RE24.2
CLKDET#: length 2.6
  TOP w0.102: v2(169.08,23.05) 169.08,23.12 169.42,23.46 v1(169.59,23.46) 169.86,23.19 RH126.1
  BOTTOM w0.089: v2(169.08,23.05) 169.01,23.13 168.75,23.13 UH2.BB22
CLKOUT_LPC0: length 4.8
  TOP w0.102: v2(170.55,20.64) 170.26,20.64 170.11,20.49 170.11,19.57 170.57,19.12 RH168.1
  BOTTOM w0.076: v2(170.55,20.64) 170.55,20.96 170.82,21.24 170.82,21.99 171.16,22.32 171.16,22.63 UH2.BC17
CLKOUT_LPC1: length 20.6
  TOP w0.102: RH16.1 184.81,26.53 185.15,26.86 v2(185.15,27.37)
  IN3 w0.127: v2(185.15,27.37) 185.15,26.43 184.29,25.57 181.37,25.57 180.45,26.48 178.6,26.48 177.58,25.47 176.7,25.47 176.12,26.05 174.33,26.05 173.77,25.49 172.45,25.49 172.32,25.36 170.7,25.36 v2(170.25,25.81)
  BOTTOM w0.089: v2(170.25,25.81) 170.13,25.81 169.77,25.46 UH2.AV19
CLKREQ_PCIE#0: length 7.4
  BOTTOM w0.076: 168.08,19.45 167.57,19.45 167.35,19.68 167.35,20.59 167.6,20.84 167.6,21.52 167.43,21.69 167.43,22.2 167.36,22.27 167.36,22.56 167.52,22.72 UH2.BC24
  BOTTOM w0.102: v1(166.79,18.52) 167.1,18.2 168.27,18.2 168.42,18.35 RP2.6 168.42,19.11 168.08,19.45
CLKRUN#: length 87.2
  TOP w0.102: RH85.1 168.79,19.43 169.02,19.65 169.02,21.22 168.95,21.3 168.95,21.41 168.95,22.42 168.62,22.75 168.62,24.12 168.01,24.73 v2(168.01,25.14) ; UE1.63 233.85,17.62 234.21,17.98 234.21,19.29 233.94,19.57 233.59,19.57 232.52,20.64 232.52,21.42 231.61,22.33 231.61,23.28 231.3,23.59 231.3,24.37 v2(231.15,24.53)
  IN3 w0.127: v2(168.01,25.14) 168.88,25.14 169.12,24.9 169.21,24.9 169.78,24.32 169.78,23.76 170.24,23.3 170.51,23.3 171.22,22.6 175.06,22.6 175.69,21.96 178.93,21.96 179.08,21.81 179.82,21.81 180.53,22.52 184.79,22.52 186.29,24.02 187.21,24.02 189.04,25.85 198.11,25.85 198.79,26.52 201.63,26.52 202.33,25.82 203.95,25.82 205.14,27.02 214.55,27.02 215.95,25.61 215.96,25.61 216.78,24.8 220.54,24.8 220.91,24.42 223.3,24.42 223.62,24.74 226.55,24.74 226.76,24.53 229.37,24.53 229.45,24.45 231.07,24.45 v2(231.15,24.53)
  BOTTOM w0.089: UH2.AW22 168.49,24.63 168.01,25.11 v2(168.01,25.14)
  BOTTOM w0.102: v2(231.15,24.53) v1(231.66,25.03)
CMP_STRAP0: length 2.8
  TOP w0.102: UE1.118 225.85,30.76 226.07,30.55 v2(226.07,30.39)
  BOTTOM w0.102: RE28.1 v2(226.07,30.39) v1(226.07,30.98)
CMP_VIN0: length 21.1
  TOP w0.102: v2(222.01,18.71) 222.03,18.74 222.03,21.33 221.37,21.99 221.37,22.19 221.02,22.54 UE1.20
  BOTTOM w0.102: RE73.1 233.56,25.72 RE33.1 232.47,24.88 232.17,24.88 230.57,23.28 230.57,21.45 228.18,19.07 v1(225.94,19.07) 223.53,19.07 222.84,18.38 222.34,18.38 v2(222.01,18.71)
CMP_VOUT0: length 283.2
  TOP w0.102: v2(141.74,38.89) 141.75,38.89 143.52,37.12 143.52,36.38 145.11,34.79 145.11,29.58 144.6,29.07 143.96,29.07 143.44,28.55 143.44,24.25 142,22.8 142,19.78 v2(140.37,18.15) ; v2(234.06,25.24) 234.06,25.4 234.4,25.74 UE1.85
  IN1 w0.114: v2(57.44,31.44) 58.05,31.44 59.17,30.31 59.17,26.95 60.81,25.31 61.14,25.31 61.48,25.31 61.49,25.31 61.61,25.31 62.2,24.72 62.2,21.39 66.69,16.9 70.99,16.9 71.83,17.74 99.75,17.74 100.38,17.11 102.5,17.11 103.62,18.23 109.54,18.23 110.43,19.12 139.41,19.12 v2(140.37,18.15) 141.2,17.33 145.3,17.33 146.82,15.8 152.92,15.8 154.51,17.39 156.09,17.39 156.85,18.15 160.69,18.15 161.6,19.07 166,19.07 167.28,17.78 168.27,17.78 169.57,16.48 171.36,16.48 173.33,14.52 178.86,14.52 181.04,16.7 187.25,16.7 188.64,18.08 197.31,18.08 197.73,18.08 199.09,19.44 205.24,19.44 205.78,19.97 210.35,19.97 210.98,20.6 211.49,20.6 211.6,20.49 212.14,20.49 212.42,20.77 213.73,20.77 213.78,20.72 216.72,20.72 217.84,19.6 225.4,19.6 226.87,18.13 228.79,18.13 229.47,18.81 v2(229.47,19.04)
  IN3 w0.127: v2(142.19,75.44) 142,75.25 139.07,75.25 136.59,72.76 136.59,69.64 140.24,65.98 140.24,43.48 142.17,41.55 142.17,39.32 v2(141.74,38.89)
  BOTTOM w0.102: v2(142.19,75.44) 142.71,74.92 145.59,74.92 145.97,75.29 145.97,75.65 146.23,75.92 149.05,75.92 149.21,76.08 149.21,76.62 149.49,76.89 QV88.1 ; v1(56.02,33.16) PR419.1 56.8,32.07 v2(57.44,31.44) ; v2(234.06,25.24) 233.99,25.17 233.99,25.16 233.59,24.76 RE33.2 RE38.2 233.51,22.85 232.7,22.04 231.93,22.04 230.57,20.67 230.57,20.13 v2(229.47,19.04)
CMPIN: length 5.4
  BOTTOM w0.102: PU300.13 30.67,39.77 30.97,40.07 31.46,40.07 31.76,40.38 v1(33,40.38) 33.23,40.38 PR201.1 PR200.2
CMPOUT: length 20
  TOP w0.254: PR207.1 PR206.1 46.23,43.08 PR205.2 45.86,41.79 v2(45.86,41.52)
  IN2 w0.254: v2(45.86,41.52) 45.86,41.01 43.37,38.52 39.69,38.52 38.17,40.05 33.74,40.05 v2(33.66,40.12)
  BOTTOM w0.203: PU300.14 31.07,39.56 31.25,39.74 31.76,39.74 32.01,40 33.54,40 v2(33.66,40.12)
CMSRC_CHG: length 1.2
  TOP w0.102: v2(26.97,36.82) 27.51,37.35 v3(27.51,37.81)
CODEC_BITCLK_R: length 2.9
  TOP w0.102: v2(277.38,24.93) 277.4,24.95 HDA1.6
  BOTTOM w0.102: v2(277.38,24.93) 277.38,24.3 RA31.2 277.2,23.61 v1(277.66,23.15)
CODEC_SDOUT_R: length 4.1
  TOP w0.102: v2(276.87,25.56) 277.07,25.36 HDA1.5
  BOTTOM w0.102: v1(277.86,25.34) 277.09,25.34 v2(276.87,25.56) 276.87,25.62 276.59,25.9 RA29.2
CPU_24MHZ_N: length 110.7
  IN3 w0.127: v2(189.24,44.59) 189.24,47.1 183.78,52.56 183.78,56 181.62,58.16 180.15,58.16 176.59,61.71 173.9,61.71 171.33,64.28 171.33,68.27 170.95,68.65 170.95,70.73 167.04,74.64 158.69,74.64 158.1,75.22 156.04,75.22 155.02,76.25 154.48,76.25 151.17,79.55 151.17,82.63 141.87,91.94 139.35,91.94 137.68,93.61 137.68,94.58 138.19,95.1 138.42,95.1 v2(138.58,95.25)
  BOTTOM w0.076: UH1.D31 126.09,96.16 125.99,96.06 125.99,95.98 126.11,95.86 127.77,95.86 127.97,96.07 128.5,96.07 128.51,96.08 128.53,96.08
  BOTTOM w0.102: v2(189.24,44.59) 189.32,44.59 189.44,44.47 189.44,44.31 189.17,44.03 188.45,44.03 187.51,43.1 187.51,42.99 186.42,41.9 180.67,41.9 180.47,41.81 179.9,41.47 179.05,40.96 178.88,40.96 178.76,41.07 178.76,41.21 UH2.F1 ; 128.53,96.08 128.86,96.08 129.27,95.67 129.27,94.99 130.39,93.87 134.14,93.87 134.35,94.07 134.75,94.07 135.55,94.87 138.43,94.87 138.58,95.02 v2(138.58,95.25)
CPU_24MHZ_P: length 110.7
  IN3 w0.127: v2(138.58,94.49) 138.58,94.73 138.47,94.84 138.3,94.84 137.93,94.48 137.93,93.72 139.46,92.19 141.97,92.19 151.42,82.74 151.42,79.66 154.58,76.5 155.12,76.5 156.15,75.48 158.21,75.48 158.79,74.89 167.14,74.89 171.2,70.83 171.2,68.75 171.58,68.37 171.58,64.38 174,61.97 176.69,61.97 180.25,58.41 181.72,58.41 184.03,56.1 184.03,52.66 189.49,47.2 189.49,44.97 v2(189.87,44.59)
  BOTTOM w0.076: 128.53,95.88 128.51,95.88 128.5,95.9 128.04,95.9 127.84,95.7 126.04,95.7 125.82,95.91 125.82,96.08 125.74,96.16 UH1.E31
  BOTTOM w0.102: v2(138.58,94.49) 138.4,94.67 135.63,94.67 134.83,93.87 134.43,93.87 134.23,93.67 130.3,93.67 129.07,94.9 129.07,95.59 128.77,95.88 128.53,95.88 ; UH2.G1 178.88,40.76 179.1,40.76 179.95,41.26 180.56,41.63 180.72,41.7 186.5,41.7 187.72,42.91 187.72,43.01 188.53,43.83 189.25,43.83 189.65,44.22 189.65,44.36 v2(189.87,44.59)
CPU_TRIGGER: length 118.2
  TOP w0.102: RH192.1 135.65,94.48 v2(135.9,94.22) v1(136.61,94.22)
  IN2 w0.127: v2(135.9,94.22) 136.48,93.64 136.48,82.13 144.04,74.57 144.04,73.29 143.6,72.84 143.6,70.39 143.95,70.03 143.95,61.86 139.63,57.54 139.63,46.68 142.51,43.81 148.04,43.81 150.68,46.45 170.44,46.45 171.25,47.26 177.49,47.26 180.51,44.23 180.51,41.71 183.4,38.83 183.4,35.48 180.99,33.07 180.99,30.51 v2(180.98,30.51)
  BOTTOM w0.076: v2(180.98,30.51) 180.79,30.31 180.79,30.3 179.83,29.33 178.96,29.33 UH2.AK1
CPU_TRIGGER_R: length 13.5
  TOP w0.102: RH192.2 133.79,94.48 133.33,94.02 133.33,93.29 132.72,92.67 132.06,92.67 131.23,91.84 v1(130.16,91.84) 125.51,91.84 124.89,91.21 124.89,91.04 124.09,90.24 v2(123.97,90.24)
  BOTTOM w0.076: UH1.J23 123.34,90.24 v2(123.97,90.24)
CPU_XDP_TCK: length 7.2
  TOP w0.102: v3(83.27,92.32) 85.79,92.32 v2(85.91,92.19)
  BOTTOM w0.076: UH1.BR28 87.91,93.25 87.57,93.25 87.32,93 86.52,93
  BOTTOM w0.102: 86.52,93 85.91,92.4 v2(85.91,92.19) RH38.2 RH61.2
CPU_XDP_TDI: length 7.1
  TOP w0.102: RH118.2 RH56.2 86.07,96.13 v3(88.17,96.13) v2(91.35,96.13)
  BOTTOM w0.076: UH1.BL32 91.03,96.46 v2(91.35,96.13)
CPU_XDP_TDO: length 3.5
  TOP w0.102: RH115.2 RH497.2 85.94,93.34 86.75,93.34 v2(86.81,93.39) v3(87.48,93.39)
  BOTTOM w0.076: v2(86.81,93.39) 86.99,93.57 UH1.BT28
CPU_XDP_TMS: length 187.9
  TOP w0.102: RH492.2 v3(185.07,35.12) 185.25,35.3 v2(185.25,35.73)
  IN2 w0.127: v2(185.25,35.73) 185.43,35.91 185.43,37.51 181.02,41.92 181.02,44.45 177.7,47.77 171.04,47.77 170.23,46.95 150.46,46.95 147.83,44.32 142.72,44.32 140.14,46.89 140.14,57.33 146.19,63.37 146.19,70.96 145.76,71.39 145.76,75.66 141.74,79.67 140.95,79.67 139.33,81.3 139.33,95.73 134.02,101.03 134.02,102.14 131.11,105.04 122.18,105.04 121.37,104.23 116.51,104.23 115.69,105.04 105.98,105.04 105.19,104.26 100.92,104.26 100.33,104.85 90.89,104.85 88.71,102.67 88.71,99.5 88.38,99.17 88.38,98.55 87.54,97.71 87.54,96.42 83.87,92.75 v2(83.73,92.75)
  BOTTOM w0.076: 86.7,93.79 87.39,93.79 87.5,93.9 88.55,93.9 UH1.BP28
  BOTTOM w0.102: RH496.2 83.38,92.4 v2(83.73,92.75) 83.76,92.78 85.61,92.78 86.62,93.79 86.7,93.79
CPU_XDP_TRST#: length 186.8
  TOP w0.102: v2(144.15,81.8) v3(143.37,81.8)
  IN1 w0.114: v2(144.15,81.8) 144.15,80.51 143.32,79.67 143.32,75.16 144.59,73.89 144.59,69.14 142.05,66.6 142.05,65.59 140,63.54 140,46.23 145.29,40.95 145.29,40.08 145.78,39.58 145.78,38.1 147.2,36.68 148.83,36.68 150.05,35.46 150.05,30.06 150.69,29.43 152.68,29.43 154.26,27.85 157.95,27.85 158.05,27.75 164.14,27.75 165.03,26.87 165.99,26.87 166.55,26.31 167.54,26.31 169.1,24.76 169.48,24.76 169.76,24.47 170.46,24.47 171.12,25.12 171.6,25.12 171.97,25.5 173.74,25.5 173.96,25.28 173.96,23.91 174.44,23.42 175.69,23.42 176.26,23.99 v2(176.29,23.99)
  IN2 w0.127: v2(144.15,81.8) 144.18,81.83 144.18,82.46 140.9,85.74 140.9,97.6 131.79,106.72 89.04,106.72 81.92,99.61 81.92,96.89 v2(81.32,96.28)
  BOTTOM w0.076: UH1.BP30 88.66,95.15 88.37,95.44 88.03,95.44 87.84,95.63 87.39,95.63 86.8,95.04 83.47,95.04 RH60.2
  BOTTOM w0.089: UH2.AY5 176.51,24.22 v2(176.29,23.99)
  BOTTOM w0.102: RH60.2 82.97,95.49 82.18,96.28 v2(81.32,96.28)
CSON_1: length 26.7
  TOP w0.102: PC320.1 v1(33.11,37.86)
  TOP w0.254: v2(34.73,36.82) 34.72,36.83 PC319.2 34.03,36.82 PC320.1
  IN3 w0.254: v2(34.73,36.82) 34.53,36.62 33.84,36.62 33.36,36.14 33.36,32.82 34.25,31.93 34.25,29.98 41.44,22.79 41.44,19.45 41.28,19.29 v2(41.34,19.29)
  BOTTOM w0.254: PR314.3 41.67,18.96 v2(41.34,19.29) ; PR324.2 v2(34.73,36.82)
CSOP_1: length 26.4
  TOP w0.102: PC318.2 v1(33.11,34.97)
  TOP w0.254: v2(34.81,36.19) 34.54,35.92 PC319.1 34.03,35.93 PC318.2
  IN3 w0.254: v2(34.81,36.19) 34.75,36.24 34,36.24 33.74,35.98 33.74,32.98 34.63,32.09 34.63,30.14 41.82,22.95 41.82,19.52 v2(42.05,19.29)
  BOTTOM w0.254: v2(42.05,19.29) 41.67,19.68 PR314.2 ; v2(34.81,36.19) 34.55,35.93 PR322.2
CSSN_1: length 5
  BOTTOM w0.254: PR305.1 25.41,32.82 25.41,31.99 26.3,31.11 v1(26.3,30.91) 26.3,29.58 26.43,29.45 PR302.3
CSSN_2: length 4.1
  BOTTOM w0.203: PU300.1 27.49,36.14 27.16,35.82 v1(26.74,35.82) 26.69,35.82 26.49,35.61 PC311.1 25.63,34.79 PC310.2
  BOTTOM w0.254: PR305.2 25.6,34.76 PC310.2
CSSP_1: length 5.1
  BOTTOM w0.254: PR302.2 25.79,29.45 25.92,29.58 25.92,30.77 v1(25.16,31.53) 24.9,31.78 24.9,32.82 PR304.1
CSSP_2: length 5.7
  BOTTOM w0.102: v1(23.77,33.9) PR304.2
  BOTTOM w0.203: 27.09,36.26 27.36,36.54 PU300.2
  BOTTOM w0.254: 27.09,36.26 26.08,36.26 PC309.2 24.7,34.88 PC310.1 24.7,33.91 PR304.2
DAT_SMB: length 22.4
  TOP w0.102: v3(38.03,13.17) 38.03,13.48 v2(38.44,13.88)
  IN1 w0.114: v2(38.44,13.88) 38.29,13.88 36.66,12.26 29.93,12.26 28.31,13.88 v2(28.31,14.39)
  BOTTOM w0.102: v2(38.44,13.88) 39.19,13.13 JBAT10.5 ; v2(28.31,14.39) 27.95,14.75 27.44,14.75 27.06,14.37 27.06,13.1 26.53,12.56 24.83,12.56 24.39,12.99 PR109.1
DAT_TP_SIO: length 126.7
  TOP w0.102: v2(237.73,23.03) 237.35,23.41 237.34,23.41 237.31,23.43 236.98,23.43 236.95,23.41 236.79,23.41 236.72,23.34 UE1.79
  IN3 w0.127: v2(148.9,19.88) 149.14,20.12 153.87,20.12 154.63,19.36 155.27,19.36 156.17,18.46 159.96,18.46 160.32,18.1 165.87,18.1 166.76,17.21 168.47,17.21 168.76,16.91 168.76,14.26 169.68,13.34 178.61,13.34 180.25,14.98 180.25,15.66 182.66,18.07 186.76,18.07 188.49,19.8 191.02,19.8 192.16,20.95 198.79,20.95 199.75,21.91 206.46,21.91 207.58,23.03 212.91,23.03 215.23,20.7 216.38,20.7 217.35,19.73 221.9,19.73 222.23,19.4 227.92,19.4 228.5,19.98 229.88,19.98 231.07,21.17 232.08,21.17 233.45,22.55 237.35,22.55 237.73,22.93 v2(237.73,23.03)
  BOTTOM w0.102: v2(237.73,23.03) 237.32,23.43 236.86,23.43 RE55.2 ; JTP.2 138.76,15.04 139.07,14.72 139.07,11.74 140,10.81 144.38,10.81 145.5,11.93 147.04,11.93 147.23,12.12 DE4.6 147.23,13.52 147.05,13.69 147.05,14.1 CE9.1 146.62,14.82 147.99,16.2 147.99,17.67 148.75,18.43 v3(148.75,19.22) 148.75,19.73 v2(148.9,19.88)
DDC_CLK_HDMI: length 64.6
  TOP w0.102: v2(299.35,64.13) 299.15,63.92 299.15,63.49 RM1.1 299.15,62.88 299.15,62.26 297.61,60.72 296.32,60.72 294.64,59.05 289.37,59.05 v4(281.8,51.47) 277.64,47.31 276.8,47.31 275.57,46.08 275.57,37.79 273.71,35.93 273.71,33.81 270.75,30.85 267.19,30.85 266.38,31.66 266.38,31.96 UM1.E1
  IN1 w0.114: v2(299.35,64.13) 299.15,64.33 299.15,64.81 298.64,65.32 298.64,67.12 299.59,68.07 300.96,68.07 301.23,68.34 301.23,70.54 JHDMI1.15
DDC_DAT_HDMI: length 64.4
  TOP w0.102: UM1.F1 266.61,31.96 266.61,31.75 267.28,31.08 270.65,31.08 273.48,33.9 273.48,36.03 275.34,37.89 275.34,46.18 276.7,47.54 277.54,47.54 289.28,59.27 294.55,59.27 296.22,60.95 297.51,60.95 298.92,62.35 298.92,62.86 RM2.1 298.92,63.52 298.92,63.92 v2(298.71,64.13)
  IN1 w0.114: JHDMI1.16 300.15,70.67 300.05,70.58 300.05,69.21 300.15,69.1 300.86,69.1 300.99,68.98 300.99,68.44 300.86,68.32 299.49,68.32 298.4,67.22 298.4,65.22 298.9,64.71 298.9,64.32 v2(298.71,64.13)
DDI1_CPU_AUXN: length 174.9
  TOP w0.102: CM46.2 260.22,40.68 254.28,40.68 251.65,38.05 251.65,35.86 v2(251.47,35.68)
  IN1 w0.114: v2(125.28,92.6) 125.28,92.57 125.49,92.36 125.49,92.16 125.7,91.95 129.44,91.95 129.8,92.31 129.8,93.06 130.77,94.03 134,94.03 136.19,91.84 142.02,91.84 150.33,83.53 150.33,78.53 152.68,76.17 155.01,76.17 155.61,75.58 157.86,75.58 158.76,74.67 166.41,74.67 168.35,72.73 168.35,71.52 169.71,70.16 169.71,63.77 173.91,59.56 175.91,59.56 177.03,58.44 177.03,57.85 178.53,56.35 178.53,54.44 181,51.96 188.26,51.96 188.46,51.96 188.87,51.96 190.68,50.16 194.8,50.16 205.74,39.21 208.46,39.21 209.1,38.57 217.62,38.57 218.21,39.16 234.66,39.16 235.41,38.42 240.2,38.42 240.97,37.66 246.63,37.66 248.04,36.25 251.54,36.25 251.72,36.06 251.72,35.93 v2(251.47,35.68)
  BOTTOM w0.076: v2(125.28,92.6) 125.28,92.61 125.61,92.94 UH1.E27
DDI1_CPU_AUXN_C: length 4.8
  TOP w0.076: 263.99,38.39 263.99,38.38 264.17,38.2 264.17,37.65 264.27,37.56 264.4,37.56 264.49,37.65 UM1.C8
  TOP w0.102: 263.99,38.39 v4(263.03,39.35) 262.86,39.52 262.86,40.35 262.56,40.66 262.34,40.66 CM21.1
DDI1_CPU_AUXP: length 174.8
  TOP w0.102: CM45.2 260.18,40.48 254.37,40.48 251.86,37.97 251.86,35.81 251.98,35.68 v2(252.23,35.68)
  IN1 w0.114: v2(252.23,35.68) 251.95,35.96 251.95,36.15 251.63,36.47 248.14,36.47 246.73,37.88 241.06,37.88 240.3,38.64 235.5,38.64 234.76,39.39 218.12,39.39 217.53,38.8 209.2,38.8 208.56,39.44 205.84,39.44 194.9,50.38 190.77,50.38 188.97,52.19 188.37,52.19 188.26,52.19 181.1,52.19 178.75,54.53 178.75,56.44 177.25,57.94 177.25,58.54 176,59.79 174.01,59.79 169.93,63.86 169.93,70.26 168.58,71.61 168.58,72.82 166.5,74.9 158.85,74.9 157.95,75.8 155.7,75.8 155.11,76.4 152.77,76.4 150.55,78.62 150.55,83.62 142.11,92.06 136.29,92.06 134.09,94.25 130.68,94.25 129.58,93.15 129.58,92.41 129.35,92.18 125.79,92.18 125.71,92.26 125.71,92.37 v2(125.94,92.6)
  BOTTOM w0.076: v2(125.94,92.6) 125.94,92.69 126.26,93.01 UH1.D27
DDI1_CPU_AUXP_C: length 4.8
  TOP w0.076: UM1.C7 264.49,37.31 264.41,37.39 264.2,37.39 264.01,37.58 264.01,38.13 263.95,38.19 263.91,38.19
  TOP w0.102: 263.91,38.19 263.1,38.99 263.07,38.99 262.65,39.41 262.65,40.28 262.47,40.45 262.33,40.45 CM20.1
DDI1_DDPB_CTRLCLK: length 2.3
  TOP w0.102: RH141.1 176.62,23.74 v2(176.29,23.41)
  BOTTOM w0.089: v2(176.29,23.41) 176.42,23.41 176.72,23.71 UH2.BA5
DDI1_DDPB_CTRLDAT: length 1.3
  TOP w0.102: v2(177.25,22.44) 177.66,22.85 RH142.1
  BOTTOM w0.089: UH2.BC4 177.29,22.48 v2(177.25,22.44)
DDI1_HTX_TBRX_N0: length 178.5
  TOP w0.102: v2(259.75,37.12) 260.04,37.42 260.49,37.42 CM7.2
  IN1 w0.114: v2(122,101.37) 122.2,101.56 122.56,101.56 124.93,99.2 128.14,99.2 128.41,99.48 138.08,99.48 151.63,85.94 151.63,79.04 153.21,77.46 155.55,77.46 156.11,76.89 158.36,76.89 159.29,75.96 167.26,75.96 169.95,73.27 169.95,71.82 170.99,70.78 170.99,64.56 173.88,61.67 176.04,61.67 179.67,58.03 180.79,58.03 181.94,56.89 182.89,56.89 186.53,53.25 187.73,53.25 187.73,53.25 187.93,53.25 187.93,53.25 189.41,53.25 191.17,51.48 195.4,51.48 206.28,40.6 210.53,40.6 211.23,39.9 217.12,39.9 217.7,40.48 235.6,40.48 236.26,39.82 251.07,39.82 253.5,37.39 259.48,37.39 v2(259.75,37.12)
  BOTTOM w0.076: UH1.K37 122.41,99.67 122.41,99.48 122.56,99.33 122.69,99.33 122.79,99.43 122.79,101.13 122.32,101.6 122.11,101.6 122,101.5 v2(122,101.37)
DDI1_HTX_TBRX_N0_C: length 1.9
  TOP w0.102: CM7.1 261.52,37.43 262.13,37.43 262.22,37.34 262.6,37.34 UM1.A7
DDI1_HTX_TBRX_N1: length 174.5
  TOP w0.102: v2(259.72,35.42) 260.07,35.77 260.49,35.77 CM15.2
  IN1 w0.114: v2(259.72,35.42) 259.46,35.69 254.19,35.69 250.72,39.16 236.01,39.16 235.34,39.82 217.96,39.82 217.37,39.24 210.48,39.24 209.85,39.87 206.1,39.87 195.13,50.84 190.9,50.84 189.14,52.61 188.2,52.61 188,52.61 186.23,52.61 182.63,56.21 180.09,56.21 179.43,56.87 179.43,57.37 175.8,61 173.43,61 170.35,64.08 170.35,70.48 169.77,71.06 169.48,71.35 169.26,71.57 169.19,71.64 169.19,72.86 166.73,75.32 159.02,75.32 158.11,76.23 155.87,76.23 155.28,76.81 152.95,76.81 150.98,78.78 150.98,85.02 138.23,97.78 135.72,97.78 134.38,96.43 127.8,96.43 126.58,97.65 123.07,97.65 v2(122.86,97.45)
  BOTTOM w0.076: UH1.J34 123.18,97.76 v2(122.86,97.45)
DDI1_HTX_TBRX_N1_C: length 1.8
  TOP w0.102: UM1.A5 262.6,35.74 261.48,35.74 CM15.1
DDI1_HTX_TBRX_N2: length 179.3
  TOP w0.102: CM17.2 260.49,34.11 259.22,34.11 258.38,34.96 258.38,38.55 258.2,38.73 257.95,38.73 v2(257.69,38.47)
  IN1 w0.114: v2(124.75,102.07) 124.98,102.3 136.19,102.3 152.29,86.21 152.29,79.29 153.48,78.1 155.81,78.1 156.35,77.56 158.6,77.56 159.56,76.6 167.53,76.6 170.64,73.49 170.64,72.04 172.07,70.61 172.07,66.56 179.94,58.69 181.08,58.69 182.21,57.56 183.14,57.56 183.15,57.55 183.16,57.55 186.8,53.92 189.66,53.92 191.45,52.13 195.67,52.13 206.47,41.32 210.79,41.32 211.55,40.56 216.87,40.56 217.45,41.14 236.01,41.14 236.67,40.48 251.37,40.48 253.73,38.12 256.13,38.12 256.74,38.73 257.44,38.73 v2(257.69,38.47)
  BOTTOM w0.076: v2(124.75,102.07) 124.49,102.32 124.17,102.32 124.09,102.25 124.09,101.36 124.24,101.21 124.24,100.17 124.5,99.91 124.5,99.53 UH1.H36
DDI1_HTX_TBRX_N2_C: length 1.8
  TOP w0.102: UM1.A3 262.6,34.14 261.5,34.14 261.29,33.92 CM17.1
DDI1_HTX_TBRX_N3: length 184.1
  TOP w0.102: CM19.2 260.49,32.46 259.86,32.46 256.35,35.97 256.35,39 256.09,39.26 255.69,39.26 v2(255.41,38.98)
  IN1 w0.114: v2(123.43,102.18) 123.7,102.45 123.92,102.45 124.17,102.69 124.17,103.03 124.41,103.27 136.14,103.27 136.47,102.94 144.72,94.69 152.97,86.44 152.97,79.52 153.65,78.84 154.34,78.84 154.77,79.26 155.56,79.26 156.57,78.25 159.19,78.25 159.72,77.71 168.62,77.71 170.09,76.24 170.09,75.91 171.41,74.59 171.41,72.89 172.23,72.07 172.23,71.46 172.73,70.96 172.73,66.82 180.21,59.34 181.34,59.34 182.47,58.21 183.51,58.21 187.09,54.63 190.18,54.63 192.05,52.77 195.93,52.77 204.61,44.09 210.32,44.09 210.76,43.65 210.76,42.32 211.85,41.22 216.61,41.22 217.86,42.46 225.71,42.46 226.67,43.43 235.1,43.43 237.38,41.14 251.72,41.14 253.6,39.26 255.12,39.26 v2(255.41,38.98)
  BOTTOM w0.076: UH1.J38 123.68,100.36 123.78,100.46 123.78,100.59 123.68,100.69 123.48,100.69 123.38,100.79 123.38,101.54 122.98,101.94 122.98,102.41 123.13,102.56 123.27,102.56 123.27,102.55 123.46,102.55 123.57,102.44 123.57,102.31 123.44,102.18 v2(123.43,102.18)
DDI1_HTX_TBRX_N3_C: length 1.9
  TOP w0.102: CM19.1 261.5,32.46 262.07,32.46 262.15,32.54 262.6,32.54 UM1.A1
DDI1_HTX_TBRX_P0: length 178.6
  TOP w0.102: v2(259.75,37.89) 260.02,37.62 260.49,37.62 CM6.2
  IN1 w0.114: v2(259.75,37.89) 259.48,37.62 253.59,37.62 251.17,40.05 236.36,40.05 235.7,40.71 217.61,40.71 217.03,40.12 211.32,40.12 210.62,40.83 206.37,40.83 195.49,51.71 191.26,51.71 189.5,53.47 187.84,53.47 187.64,53.47 186.62,53.47 182.98,57.11 182.8,57.11 182.8,57.11 182.03,57.11 180.88,58.26 179.77,58.26 176.13,61.89 173.97,61.89 171.22,64.65 171.22,70.87 170.17,71.91 170.17,73.37 167.35,76.18 159.38,76.18 158.45,77.12 156.2,77.12 155.64,77.68 153.31,77.68 151.85,79.14 151.85,86.03 138.18,99.71 137.99,99.71 128.32,99.71 128.04,99.43 125.02,99.43 122.66,101.79 122.17,101.79 v2(122,101.95)
  BOTTOM w0.076: v2(122,101.95) 122.19,101.77 122.39,101.77 122.96,101.2 122.96,99.36 122.76,99.17 122.56,99.17 UH1.K36
DDI1_HTX_TBRX_P0_C: length 1.9
  TOP w0.102: CM6.1 261.49,37.63 262.21,37.63 262.3,37.54 262.6,37.54 UM1.A8
DDI1_HTX_TBRX_P1: length 174.4
  TOP w0.102: CM14.2 260.49,35.97 259.94,35.97 v2(259.72,36.19)
  IN1 w0.114: v2(122.86,98.1) 123.08,97.88 126.67,97.88 127.89,96.66 134.28,96.66 135.63,98 138.32,98 151.21,85.11 151.21,78.87 153.04,77.04 155.37,77.04 155.96,76.45 158.2,76.45 159.12,75.54 166.83,75.54 169.42,72.95 169.42,71.73 169.92,71.22 170.57,70.57 170.57,64.17 173.52,61.22 175.89,61.22 179.5,57.62 179.56,57.62 179.65,57.52 179.65,56.96 180.18,56.43 182.72,56.43 186.32,52.83 187.9,52.83 188.1,52.83 189.23,52.83 191,51.06 195.23,51.06 206.19,40.1 209.94,40.1 210.58,39.46 217.28,39.46 217.87,40.05 235.44,40.05 236.1,39.38 250.81,39.38 254.28,35.92 259.46,35.92 v2(259.72,36.19)
  BOTTOM w0.076: v2(122.86,98.1) 123.18,98.41 UH1.J35
DDI1_HTX_TBRX_P1_C: length 1.8
  TOP w0.102: CM14.1 261.53,35.94 262.6,35.94 UM1.A6
DDI1_HTX_TBRX_P2: length 179.4
  TOP w0.102: v2(257.69,39.23) 258,38.93 258.29,38.93 258.58,38.63 258.58,35.04 259.31,34.32 260.49,34.32 CM16.2
  IN1 w0.114: v2(124.75,102.83) 125.05,102.52 136.29,102.52 152.51,86.3 152.51,79.39 153.57,78.32 155.91,78.32 156.45,77.78 158.69,77.78 159.65,76.83 167.62,76.83 170.87,73.58 170.87,72.13 172.29,70.7 172.29,66.66 180.03,58.92 181.17,58.92 182.3,57.79 183.23,57.79 183.25,57.78 183.26,57.78 186.89,54.14 189.75,54.14 191.54,52.35 195.76,52.35 206.56,41.54 210.88,41.54 211.64,40.78 216.77,40.78 217.36,41.37 236.1,41.37 236.76,40.7 251.46,40.7 253.82,38.34 256.04,38.34 256.65,38.95 257.41,38.95 v2(257.69,39.23)
  BOTTOM w0.076: UH1.H37 124.03,99.62 124.14,99.51 124.25,99.51 124.33,99.59 124.33,99.85 124.08,100.1 124.08,101.14 123.92,101.29 123.92,102.31 124.1,102.49 124.41,102.49 v2(124.75,102.83)
DDI1_HTX_TBRX_P2_C: length 1.8
  TOP w0.102: CM16.1 261.48,34.34 262.6,34.34 UM1.A4
DDI1_HTX_TBRX_P3: length 184.1
  TOP w0.102: CM18.2 260.49,32.67 259.94,32.67 256.55,36.06 256.55,39.09 256.18,39.46 255.69,39.46 v2(255.41,39.74)
  IN1 w0.114: v2(123.43,102.94) 123.7,102.67 123.83,102.67 123.94,102.79 123.94,103.12 124.32,103.5 136.23,103.5 136.63,103.1 153.2,86.53 153.2,79.61 153.75,79.06 154.25,79.06 154.68,79.49 155.65,79.49 156.66,78.47 159.28,78.47 159.82,77.94 168.71,77.94 170.31,76.33 170.31,76 171.63,74.69 171.63,72.98 172.45,72.16 172.45,71.55 172.95,71.05 172.95,66.91 180.3,59.56 181.44,59.56 182.57,58.43 183.61,58.43 187.18,54.85 190.28,54.85 192.14,52.99 196.02,52.99 204.7,44.31 210.41,44.31 210.98,43.74 210.98,42.41 211.95,41.44 216.52,41.44 217.76,42.69 225.61,42.69 226.58,43.65 235.19,43.65 237.47,41.37 251.81,41.37 253.69,39.49 255.15,39.49 v2(255.41,39.74)
  BOTTOM w0.076: UH1.J37 123.24,100.2 123.21,100.24 123.21,101.48 122.82,101.87 122.82,102.48 123.07,102.73 123.22,102.73 v2(123.43,102.94)
DDI1_HTX_TBRX_P3_C: length 1.9
  TOP w0.102: UM1.A2 262.6,32.74 262.06,32.74 261.99,32.67 261.5,32.67 CM18.1
DDI1_PCH_HPD: length 96
  TOP w0.102: RM3.2 262.47,28.69 262.21,28.69 261.64,28.12 261.17,28.12 261.06,28.01 261.06,27.36 v2(261.25,27.17)
  IN1 w0.114: v2(261.25,27.17) 261.1,27.17 260.79,26.86 257.31,26.86 257.16,26.71 256.33,26.71 255.19,25.57 253.25,25.57 251.77,27.04 248.17,27.04 246.76,25.64 244.15,25.64 243.55,26.25 241.66,26.25 241.24,25.83 236.25,25.83 235.19,24.78 233.46,24.78 233.17,25.07 231.01,25.07 229.51,23.57 221.42,23.57 219.84,25.15 213.05,25.15 212.43,25.77 211.49,25.77 210.94,25.22 202.58,25.22 202.02,25.78 199.16,25.78 197.74,24.36 193.23,24.36 192.3,23.43 187.31,23.43 186.7,24.04 184.24,24.04 183.38,23.18 180.98,23.18 180.43,23.74 177.96,23.74 176.98,24.72 v2(176.98,24.77)
  BOTTOM w0.089: v2(176.98,24.77) 176.95,24.77 176.98,24.81 177.22,24.81 UH2.AW4
  BOTTOM w0.102: v2(261.25,27.17) v1(261.86,27.17)
DDI1_PCH_HPD_R: length 2.4
  TOP w0.102: RM3.1 263.03,30.85 263.69,31.52 UM1.B1
DDR4_DRAMRST#: length 18
  TOP w0.102: v2(98.32,30.88) 97.87,30.88 95.62,28.63 v1(95.62,27.37) v2(95.62,26.55)
  BOTTOM w0.102: JDIMM2.108 97.41,20.8 95.62,22.58 v2(95.62,26.55) ; v2(98.32,30.88) 97.4,31.8 JDIMM1.108
  BOTTOM w0.114: JDIMM2.108 97.41,17.94 RD31.1
DDR_A_ACT#: length 49.5
  IN3 w0.178: v2(99.52,71.53) 98.65,71.53 97.72,70.59 97.72,69.23 96.96,68.47 96.96,61.23 93.92,58.2 93.92,44.38 94.19,44.11 94.19,39.97 94.14,39.92 94.14,35.7 94.57,35.27 v2(97.14,35.27)
  BOTTOM w0.076: v2(99.52,71.53) 99.6,71.53 100.14,72.07 100.14,72.96 100.6,73.42 100.6,74.76 UH1.AU3
  BOTTOM w0.17: JDIMM1.114 98.9,33.91 97.55,35.27 v2(97.14,35.27)
DDR_A_ALERT#: length 45.2
  IN3 w0.178: v2(99.1,34.58) 98.56,35.13 98.56,57.59 100.58,59.61 100.58,67.24 100.8,67.46 100.8,70.78 101.25,71.24 v2(101.25,76.01)
  BOTTOM w0.076: UH1.AU5 v2(101.25,76.01)
  BOTTOM w0.17: v2(99.1,34.58) 99.4,34.28 JDIMM1.116
DDR_A_BG0: length 49.5
  IN3 w0.178: v2(97.14,37.63) 97.06,37.63 96.56,37.12 96.56,36.09 96.22,35.75 94.93,35.75 94.62,36.06 94.62,39.64 94.87,39.89 94.87,41.42 94.68,41.62 94.68,43.04 94.87,43.24 94.87,44.16 94.44,44.59 94.44,58.03 97.44,61.03 97.44,68.22 98.24,69.02 98.24,70.12 99.03,70.92 v2(99.53,70.92)
  BOTTOM w0.102: v2(99.53,70.92) 99.91,70.92 100.39,71.4 100.39,72.91 100.88,73.41 UH1.AU1
  BOTTOM w0.17: v2(97.14,37.63) 97.22,37.63 99.15,39.57 JDIMM1.115
DDR_A_BG1: length 49.3
  IN3 w0.178: v2(97.15,38.95) 97.06,39.04 97.06,44.35 97.5,44.79 97.5,45.87 97.29,46.08 96.88,46.08 96.67,46.29 96.67,46.72 96.88,46.93 97.29,46.93 97.5,47.15 97.5,47.57 97.29,47.79 96.88,47.79 96.67,48 96.67,48.43 96.88,48.64 97.29,48.64 97.5,48.85 97.5,49.28 97.29,49.49 96.88,49.49 96.67,49.71 96.67,50.14 96.88,50.35 97.29,50.35 97.5,50.56 97.5,50.99 97.29,51.2 96.88,51.2 96.67,51.42 96.67,51.84 96.88,52.06 97.29,52.06 97.5,52.27 97.5,52.7 97.29,52.91 96.88,52.91 96.67,53.12 96.67,53.55 96.88,53.76 97.29,53.76 97.5,53.98 97.5,54.4 97.29,54.62 96.88,54.62 96.67,54.83 96.67,55.26 96.88,55.47 97.29,55.47 97.5,55.68 97.5,56.11 97.29,56.32 96.88,56.32 96.67,56.54 96.67,56.96 96.88,57.18 97.29,57.18 97.5,57.39 97.5,58 99.55,60.04 v2(99.55,67.05)
  BOTTOM w0.076: 99.21,69.82 99.64,69.82 100.63,70.82 100.63,72.87 101.16,73.39 101.16,74.11 UH1.AU2
  BOTTOM w0.17: 99.21,69.82 98.9,69.51 98.9,67.7 v2(99.55,67.05) ; JDIMM1.113 98.65,39.86 97.75,38.95 v2(97.15,38.95)
DDR_A_BS0: length 54.3
  IN3 w0.178: v2(107.09,73.45) 107.43,73.45 107.64,73.66 107.64,75.5 107.82,75.68 108.82,75.68 109,75.5 109,71.26 109.64,70.62 109.64,68.66 110.51,67.78 110.51,56.61 111.34,55.78 111.34,48.54 109.68,46.87 109.68,36.55 109.88,36.35 110.61,36.35 v2(110.8,36.55)
  BOTTOM w0.076: UH1.AH5 108.39,76.34 107.93,75.88 107.93,73.72 107.66,73.45 v2(107.09,73.45)
  BOTTOM w0.17: JDIMM1.150 109.9,36.38 110.08,36.55 v2(110.8,36.55)
DDR_A_BS1: length 52.5
  IN3 w0.178: v2(108.3,38.14) 107.93,38.5 107.93,38.88 108.67,39.62 108.67,47.27 109.55,48.14 109.55,48.81 109.72,48.99 110.2,48.99 110.38,49.17 110.38,49.52 110.2,49.7 109.72,49.7 109.55,49.88 109.55,50.23 109.72,50.41 110.2,50.41 110.38,50.59 110.38,50.94 110.2,51.12 109.72,51.12 109.55,51.3 109.55,51.66 109.72,51.83 110.2,51.83 110.38,52.01 110.38,52.37 110.2,52.54 109.72,52.54 109.55,52.72 109.55,53.08 109.72,53.26 110.2,53.26 110.38,53.43 110.38,53.79 110.2,53.97 109.72,53.97 109.55,54.14 109.55,54.5 109.72,54.68 110.2,54.68 110.38,54.86 110.38,55.38 109.55,56.21 109.55,67.38 108.67,68.26 108.67,68.72 108.33,69.06 107.87,69.06 107.68,69.25 107.68,69.59 107.88,69.79 108.42,69.79 108.62,69.99 108.62,70.25 108.32,70.55 108.01,70.55 107.83,70.73 107.83,71.41 108.04,71.62 108.04,72.15 107.86,72.33 107.23,72.33 v2(107.11,72.2)
  BOTTOM w0.076: UH1.AH1 108.43,73.35 107.27,72.2 v2(107.11,72.2)
  BOTTOM w0.17: v2(108.3,38.14) 108.43,38.14 108.6,38.31 108.6,38.72 108.43,38.89 107.02,38.89 106.85,39.06 106.85,39.4 107.02,39.57 108.48,39.57 108.65,39.74 JDIMM1.145
DDR_A_CAS#: length 53.4
  IN3 w0.178: v2(111.35,69.81) 111.09,69.55 111.09,69.26 111.99,68.35 111.99,57.17 112.79,56.38 112.79,47.94 111.29,46.43 111.29,46.03 111.47,45.85 111.76,45.85 111.93,45.67 111.93,45.32 111.76,45.14 111.47,45.14 111.29,44.96 111.29,35.7 112.15,34.84 112.15,33.42 112.02,33.29 110.27,33.29 109.94,33.62 109.94,33.94 109.71,34.17 109.71,34.75 109.84,34.88 v2(110.87,34.88)
  BOTTOM w0.076: v2(111.35,69.81) 111.68,70.14 UH1.AD1
  BOTTOM w0.17: JDIMM1.156 111.4,33.94 112.63,35.16 112.63,35.42 112.28,35.76 112.04,35.76 111.16,34.88 v2(110.87,34.88)
DDR_A_D0: length 57.9
  IN3 w0.117: v2(83.08,75.51) 82.63,75.96 79.49,75.96 76.3,72.77 76.3,66.9 70.11,60.71 70.11,38.18 70.79,37.51 70.79,36.72 v2(71.6,35.91)
  BOTTOM w0.076: 85.64,76.25 85.64,76.51 86.33,77.2 87.03,77.2 87.2,77.03 88.15,77.03 UH1.BR6
  BOTTOM w0.102: v2(83.08,75.51) 84.9,75.51 85.64,76.25 ; v2(71.6,35.91) 72.4,35.1 JDIMM1.8
DDR_A_D1: length 58.1
  IN3 w0.117: v2(71.54,37.94) 71.41,37.94 70.77,38.57 70.77,60.43 76.96,66.62 76.96,72.5 79.49,75.02 79.76,75.02 79.89,74.89 79.89,74.71 80.01,74.59 80.4,74.59 80.52,74.71 80.52,74.93 80.65,75.05 81.03,75.05 81.16,74.93 81.16,74.71 81.28,74.59 81.75,74.59 82.08,74.26 83.11,74.26 83.24,74.39 83.24,74.91 83.15,75 82.28,75 v2(81.79,75.49)
  BOTTOM w0.076: 85.44,76.48 85.44,76.54 86.26,77.37 87.54,77.37 UH1.BT6
  BOTTOM w0.102: 85.44,76.48 84.95,75.99 82.29,75.99 v2(81.79,75.49) ; v2(71.54,37.94) 71.99,38.39 71.99,39.31 72.15,39.48 JDIMM1.7
DDR_A_D2: length 58.4
  IN3 w0.117: v2(74.93,34.79) 74.1,34.79 73.84,35.05 73.84,35.34 73.73,35.46 73.23,35.46 73.11,35.57 73.11,35.96 73.23,36.08 73.73,36.08 73.84,36.2 73.84,40.14 73.84,40.15 73.84,40.8 73.72,40.91 73.47,40.91 73.35,41.03 73.35,41.38 73.47,41.5 73.72,41.5 73.84,41.61 73.84,41.96 73.72,42.08 73.47,42.08 73.35,42.2 73.35,42.55 73.47,42.66 73.72,42.66 73.84,42.78 73.84,43.13 73.72,43.25 73.47,43.25 73.35,43.37 73.35,43.72 73.47,43.83 73.72,43.83 73.84,43.95 73.84,44.3 73.72,44.42 73.47,44.42 73.35,44.53 73.35,44.88 73.47,45 73.72,45 73.84,45.12 73.84,45.47 73.72,45.59 73.47,45.59 73.35,45.7 73.35,46.05 73.47,46.17 73.72,46.17 73.84,46.29 73.84,58.39 78.03,62.59 78.03,63.75 79.06,64.78 v2(80.41,64.78)
  BOTTOM w0.076: 87.12,74.09 87.26,73.95 87.7,73.95 87.95,74.2 87.95,74.58 88.16,74.79 88.45,74.79 UH1.BP3
  BOTTOM w0.102: v2(80.41,64.78) 80.93,64.25 82.6,64.25 85.79,67.45 v1(85.79,70.74) 85.79,73.51 86.37,74.09 87.12,74.09 ; JDIMM1.20 75.4,34.32 74.94,34.79 v2(74.93,34.79)
DDR_A_D3: length 58.8
  IN3 w0.117: v2(79.57,63.92) 79.66,63.83 79.66,63.31 78.22,61.87 78.22,61.87 75.25,58.9 75.25,51.01 75.14,50.9 74.61,50.9 74.49,50.78 74.49,50.43 74.61,50.31 75.14,50.31 75.25,50.19 75.25,49.84 75.14,49.73 74.61,49.73 74.49,49.61 74.49,49.26 74.61,49.14 75.14,49.14 75.25,49.03 75.25,48.68 75.14,48.56 74.61,48.56 74.49,48.44 74.49,48.09 74.61,47.97 75.14,47.97 75.25,47.86 75.25,47.51 75.14,47.39 74.61,47.39 74.49,47.27 74.49,46.92 74.61,46.81 75.14,46.81 75.25,46.69 75.25,46.34 75.14,46.22 74.61,46.22 74.49,46.11 74.49,45.75 74.61,45.64 75.14,45.64 75.25,45.52 75.25,45.17 75.14,45.05 74.61,45.05 74.49,44.94 74.49,44.59 74.61,44.47 75.12,44.47 75.24,44.35 75.24,43.91 75.1,43.77 74.68,43.77 74.5,43.6 74.5,41.9 74.62,41.78 75.03,41.78 75.14,41.66 75.14,41.31 75.03,41.19 74.62,41.19 74.5,41.08 74.5,40.73 74.62,40.61 74.98,40.61 75.09,40.49 75.09,40.14 74.98,40.03 74.62,40.03 74.5,39.91 74.5,38.89 74.62,38.77 v2(74.95,38.77)
  BOTTOM w0.076: 87.19,73.78 87.58,73.39 88.31,73.39 88.52,73.61 88.52,73.88 88.61,73.98 88.61,74.68 88.81,74.88 89.35,74.88 UH1.BN3
  BOTTOM w0.102: 87.19,73.78 86.49,73.78 86.12,73.41 86.12,67.35 82.7,63.92 v2(79.57,63.92) ; JDIMM1.21 75.65,39.48 v2(74.95,38.77)
DDR_A_D4: length 58.7
  IN3 w0.117: v2(71.57,36.62) 71.12,37.08 71.12,37.74 70.44,38.41 70.44,60.57 76.63,66.76 76.63,72.63 79.47,75.47 v2(80.59,75.47)
  BOTTOM w0.076: UH1.BN5 89.42,76.95 89.01,77.36 88.24,77.36 87.96,77.64 87.43,77.64 87.38,77.59 86.25,77.59 85.41,76.75 85.25,76.75
  BOTTOM w0.102: 85.25,76.75 84.88,76.38 v1(81.5,76.38) v2(80.59,75.47) ; v2(71.57,36.62) 71.19,36.24 71.19,34.33 71.4,34.11 JDIMM1.4
DDR_A_D5: length 57.7
  IN3 w0.117: v2(86.06,76.3) 85.24,76.3 85.11,76.17 85.11,74.31 84.99,74.19 84.51,74.19 84.38,74.31 84.38,76.23 84.26,76.36 83.88,76.36 83.75,76.23 83.75,74.03 83.62,73.9 81.84,73.9 81.54,74.2 79.13,74.2 77.29,72.36 77.29,66.49 71.1,60.3 71.1,39.54 v2(71.54,39.11)
  BOTTOM w0.076: v2(86.06,76.3) 86.06,76.7 86.4,77.04 86.94,77.04 87.11,76.86 87.86,76.86 88.09,76.63 88.53,76.63 88.92,77.02 UH1.BP6
  BOTTOM w0.102: v2(71.54,39.11) 71.15,39.49 JDIMM1.3
DDR_A_D6: length 59.2
  IN3 w0.117: v2(74.93,36.06) 74.17,36.82 74.17,51.11 74.29,51.23 74.79,51.23 74.91,51.34 74.91,51.69 74.79,51.81 74.29,51.81 74.17,51.93 74.17,52.28 74.29,52.39 74.79,52.39 74.91,52.51 74.91,52.86 74.79,52.98 74.29,52.98 74.17,53.09 74.17,53.45 74.29,53.56 74.79,53.56 74.91,53.68 74.91,54.03 74.79,54.15 74.29,54.15 74.17,54.26 74.17,54.61 74.29,54.73 74.79,54.73 74.91,54.85 74.91,55.2 74.79,55.31 74.29,55.31 74.17,55.43 74.17,55.78 74.29,55.9 74.79,55.9 74.91,56.02 74.91,56.37 74.79,56.48 74.29,56.48 74.17,56.6 74.17,56.95 74.29,57.07 74.79,57.07 74.93,57.21 74.93,57.59 74.57,57.96 74.57,58.31 74.93,58.67 74.93,59.04 78.74,62.84 v2(78.74,63.04)
  BOTTOM w0.076: 87.4,73.17 88.83,73.17 89.23,73.57 89.23,74.26 UH1.BP2
  BOTTOM w0.102: JDIMM1.16 74.4,35.68 74.79,36.06 v2(74.93,36.06) ; 87.4,73.17 87.14,73.43 86.66,73.43 86.46,73.24 v1(86.46,69.43) 86.46,66.94 82.56,63.04 v2(78.74,63.04)
DDR_A_D7: length 58.7
  IN3 w0.117: v2(72.83,37.1) 73.03,36.9 73.28,36.9 73.52,37.14 73.52,39.92 73.03,40.4 73.03,46.5 73.52,46.98 73.52,49.68 73.4,49.8 73.15,49.8 73.03,49.91 73.03,50.26 73.15,50.38 73.4,50.38 73.52,50.5 73.52,50.85 73.4,50.96 73.15,50.96 73.03,51.08 73.03,51.43 73.15,51.55 73.4,51.55 73.52,51.67 73.52,52.02 73.4,52.13 73.15,52.13 73.03,52.25 73.03,52.6 73.15,52.72 73.4,52.72 73.52,52.83 73.52,53.18 73.4,53.3 73.15,53.3 73.03,53.42 73.03,53.77 73.15,53.89 73.4,53.89 73.52,54 73.52,54.35 73.4,54.47 73.15,54.47 73.03,54.59 73.03,54.94 73.15,55.05 73.4,55.05 73.52,55.17 73.52,55.52 73.4,55.64 73.15,55.64 73.03,55.76 73.03,56.32 73.15,56.43 73.27,56.43 73.5,56.66 73.5,57.25 73.38,57.37 73.2,57.37 73.08,57.49 73.08,57.84 73.2,57.95 73.4,57.95 73.52,58.07 73.52,58.53 77.71,62.72 77.71,63.88 79.06,65.23 v2(80.85,65.23)
  BOTTOM w0.076: UH1.BR3 88.13,75.12 87.7,74.69 87.42,74.69
  BOTTOM w0.102: 87.42,74.69 86.54,74.69 85.46,73.61 v1(85.46,68.35) 85.46,67.71 82.35,64.6 81.48,64.6 v2(80.85,65.23) ; JDIMM1.17 74.65,40.1 74.43,39.88 74.43,37.75 73.78,37.1 v2(72.83,37.1)
DDR_A_D8: length 54.1
  IN3 w0.117: v2(76.11,37.02) 75.63,37.51 75.63,40.83 75.78,40.98 75.78,58.62 83.68,66.53 83.68,71.85 88.27,76.44 91.58,76.44 v2(92,76.01)
  BOTTOM w0.076: UH1.BK5 v2(92,76.01)
  BOTTOM w0.102: JDIMM1.28 77.44,32.8 77.44,35.7 v2(76.11,37.02)
DDR_A_D9: length 54
  IN3 w0.117: v2(76.11,38.22) 76.39,38.22 76.53,38.35 76.53,50.22 76.7,50.39 76.88,50.39 77,50.51 77,50.86 76.88,50.97 76.53,50.97 76.42,51.09 76.42,51.7 76.53,51.81 77.26,51.81 77.38,51.93 77.38,52.28 77.26,52.4 76.53,52.4 76.42,52.51 76.42,52.86 76.53,52.98 77.26,52.98 77.38,53.1 77.38,53.45 77.26,53.57 76.53,53.57 76.42,53.68 76.42,54.03 76.53,54.15 77.26,54.15 77.38,54.27 77.38,59.29 84.34,66.25 84.34,71.57 86.52,73.75 88.28,73.75 89.43,74.91 90.77,74.91 v2(91.22,75.36)
  BOTTOM w0.076: v2(91.22,75.36) 90.89,75.69 UH1.BL4
  BOTTOM w0.102: v2(76.11,38.22) 76.39,38.22 77.65,39.48 JDIMM1.29
DDR_A_D10: length 53.8
  IN3 w0.117: v2(90.07,74.14) 89.6,74.14 88.36,72.9 87.89,72.9 87.56,72.57 87.56,70.64 86.79,69.86 86.79,64.97 81.26,59.45 81.26,53.27 81.14,53.15 79.9,53.15 79.78,53.04 79.78,52.69 79.9,52.57 81.14,52.57 81.26,52.45 81.26,52.1 81.14,51.99 79.9,51.99 79.78,51.87 79.78,51.52 79.9,51.4 81.14,51.4 81.26,51.28 81.26,50.93 81.14,50.82 79.9,50.82 79.78,50.7 79.78,50.35 79.9,50.23 81.14,50.23 81.26,50.12 81.26,49.54 79.78,48.06 79.78,41.41 79.11,40.74 79.11,38.89 v2(78.54,38.32)
  BOTTOM w0.076: 90.23,74.17 90.44,74.38 UH1.BL2
  BOTTOM w0.102: v2(78.54,38.32) 79.05,38.32 80.65,39.92 JDIMM1.41 ; 90.23,74.17 90.2,74.14 v2(90.07,74.14)
DDR_A_D11: length 53.4
  IN3 w0.117: v2(90.02,73.35) 90.02,73.35 89.54,73.35 88.46,72.27 88.46,70.63 87.43,69.59 87.43,64.71 82.69,59.97 82.69,59.81 82.91,59.59 82.91,59.43 82.67,59.18 82.5,59.18 82.28,59.4 82.12,59.4 81.9,59.18 81.9,58.56 82.02,58.44 82.85,58.44 82.97,58.32 82.97,57.97 82.85,57.86 82.02,57.86 81.9,57.74 81.9,57.39 82.02,57.27 82.85,57.27 82.97,57.15 82.97,56.8 82.85,56.69 82.02,56.69 81.9,56.57 81.9,44.02 81.78,43.9 81.54,43.9 81.42,43.79 81.42,43.44 81.54,43.32 81.78,43.32 81.9,43.2 81.9,42.62 81.49,42.21 81.33,42.21 81,42.54 80.84,42.54 80.59,42.29 80.59,42.12 80.91,41.8 80.91,41.63 79.89,40.61 79.89,35.07 80.76,34.2 v2(81.47,34.2)
  BOTTOM w0.102: v2(81.47,34.2) 81.45,34.18 81.11,34.18 80.9,33.97 JDIMM1.42 ; UH1.BM1 90.4,73.69 90.09,73.38 90.07,73.38 90.04,73.35 v2(90.02,73.35)
DDR_A_D12: length 53.9
  IN3 w0.117: v2(92,75.36) 91.22,74.58 89.57,74.58 88.41,73.42 86.65,73.42 84.69,71.46 84.69,66.13 77.7,59.14 77.7,50.6 76.86,49.75 76.86,49.37 76.97,49.25 77.21,49.25 77.33,49.13 77.33,48.78 77.21,48.66 76.97,48.66 76.86,48.55 76.86,35.44 76.66,35.25 76.31,35.25 76.09,35.47 v2(76.09,35.83)
  BOTTOM w0.076: UH1.BK4 v2(92,75.36)
  BOTTOM w0.102: JDIMM1.24 76.4,35.51 v2(76.09,35.83)
