# Allegro board Dell Inspiron 15 Gaming 7566 Compal LA-D991P BCV00 Rev1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_PRX_LANTX_P3_C: length 2.4
  BOTTOM w0.102: CL30.2 288.12,41.14 288.12,41.38 287.41,42.08 UL1.17
PCIE_PRX_LANTX_P5: length 132.8
  IN1 w0.114: v2(288.43,38.65) 288.33,38.55 288.33,38.36 287.83,37.86 286.8,37.86 286.57,38.1 283.94,38.1 282.67,36.83 279.06,36.83 277.99,35.75 275.45,35.75 270.74,31.04 270.3,31.04 269.1,29.84 255.3,29.84 254.35,28.9 234.49,28.9 234.22,28.62 221.84,28.62 221.51,28.95 214.19,28.95 213.73,28.49 211.76,28.49 210.69,29.56 208.48,29.56 207.79,30.25 205.91,30.25 204.21,31.94 199.53,31.94 196.94,29.36 190.32,29.36 185.96,33.72 182.35,33.72 180.72,35.35 179.08,35.35 178.85,35.12 174.62,35.12 173.39,36.35 173.39,37.85 172.2,39.04 171.31,39.04 171.04,39.31 170.42,39.31 v2(170.32,39.21)
  BOTTOM w0.102: UH2.L19 169.77,38.71 170.27,39.21 v2(170.32,39.21) ; v2(288.43,38.65) 288.19,38.89 288.19,39.42 CL30.1
PCIE_PRX_SSDTX_N10: length 59.8
  IN1 w0.114: v2(210.61,28.81) 210.42,28.62 210.42,28.31 209.94,27.83 206.44,27.83 204.68,29.58 198.79,29.58 196.1,26.89 189.95,26.89 185.55,31.29 181.37,31.29 181.02,31.65 181.02,32.03 180.77,32.27 178.95,32.27 178.29,32.93 178.1,33.13 177.91,33.32 174.08,33.32 171.97,35.43 171.97,35.71 169.74,37.94 166.5,37.94 166.07,37.51 165.47,37.51 165.05,37.94 165.05,40.43 164.87,40.61 v2(164.49,40.61)
  BOTTOM w0.102: v2(164.49,40.61) 164.49,40.7 164.76,40.98 UH2.G29 ; v2(210.61,28.81) 210.53,28.81 210.41,28.93 210.41,29.29 210.03,29.66 209.59,29.66 209.43,29.82 JNGFF2.29
PCIE_PRX_SSDTX_N11: length 54.3
  IN3 w0.076: v2(163.4,38.41) 163.17,38.65 162.99,38.65 162.82,38.82 162.82,40.88 162.78,40.92 162.78,40.93
  IN3 w0.127: 162.78,40.93 162.78,41.45 163.41,42.08 172.1,42.08 175.27,38.91 175.27,38.78 176.42,37.63 178.35,37.63 178.98,36.99 180.36,36.99 182.08,35.27 186.73,35.27 186.96,35.5 202.55,35.5 205.17,32.88 v2(205.88,32.88)
  BOTTOM w0.089: v2(163.4,38.41) 163.65,38.66 UH2.L31
  BOTTOM w0.102: JNGFF2.17 207.7,32.82 207.55,32.68 206.08,32.68 v2(205.88,32.88)
PCIE_PRX_SSDTX_N12: length 57.6
  IN3 w0.127: v2(162.4,40.55) 162.4,40.29 162.3,40.19 162.07,40.19 161.81,40.45 161.81,41.57 162.09,41.85 162.54,41.85 163.71,43.02 171.82,43.02 175.14,39.69 178.8,39.69 180.4,38.09 183.04,38.09 184.24,36.9 187.16,36.9 188.12,35.93 193.43,35.93 195.9,38.4 202.85,38.4 203,38.25 203.7,38.25 204.05,38.6 204.05,38.94 204.34,39.24 v2(204.41,39.24)
  BOTTOM w0.089: UH2.G33 162.65,40.79 v2(162.4,40.55)
  BOTTOM w0.102: JNGFF2.5 207.71,35.82 207.59,35.7 207.59,35.58 207.54,35.52 206.82,35.52 205.9,36.44 205.9,37.03 204.12,38.8 204.12,39.15 204.21,39.24 v2(204.41,39.24)
PCIE_PRX_SSDTX_P10: length 59.8
  IN1 w0.114: v2(164.47,41.27) 164.47,41.22 164.86,40.84 164.96,40.84 165.27,40.53 165.27,38.03 165.57,37.73 165.97,37.73 166.41,38.17 169.83,38.17 172.2,35.8 172.2,35.52 174.18,33.54 178,33.54 179.05,32.5 180.86,32.5 181.24,32.12 181.24,31.74 181.47,31.51 185.64,31.51 190.04,27.12 196.01,27.12 198.7,29.8 204.78,29.8 206.53,28.05 209.85,28.05 210.19,28.4 210.19,28.57 209.97,28.79 v2(209.82,28.79)
  BOTTOM w0.102: UH2.E29 164.95,41.74 v2(164.47,41.27) ; v2(209.82,28.79) 209.91,28.7 210.08,28.7 210.21,28.83 210.21,29.21 209.95,29.46 209.55,29.46 209.41,29.32 JNGFF2.31
PCIE_PRX_SSDTX_P11: length 54.3
  IN3 w0.076: 163.03,40.93 163.03,40.91 162.98,40.87 162.98,38.89 163.06,38.81 163.52,38.81 163.6,38.89 163.6,39.03 163.41,39.21 v2(163.4,39.21)
  IN3 w0.127: 163.03,40.93 163.03,41.34 163.51,41.83 171.99,41.83 175.02,38.8 175.02,38.67 176.31,37.38 178.24,37.38 178.88,36.74 180.25,36.74 181.98,35.02 186.83,35.02 187.06,35.25 202.45,35.25 205.06,32.63 205.49,32.63 v2(205.88,32.25)
  BOTTOM w0.089: UH2.K31 163.61,39.43 v2(163.4,39.21)
  BOTTOM w0.102: v2(205.88,32.25) 206.1,32.47 207.56,32.47 207.71,32.32 JNGFF2.19
PCIE_PRX_SSDTX_P12: length 57.7
  IN3 w0.127: v2(203.72,39.23) 203.8,39.15 203.8,38.7 203.59,38.5 203.11,38.5 202.96,38.65 195.79,38.65 193.33,36.18 188.23,36.18 187.26,37.15 184.34,37.15 183.15,38.34 180.51,38.34 178.9,39.94 175.24,39.94 171.92,43.27 163.61,43.27 162.44,42.1 161.98,42.1 161.56,41.67 161.56,40.34 161.96,39.94 162.21,39.94 v2(162.37,39.77)
  BOTTOM w0.089: v2(162.37,39.77) 162.63,40.03 UH2.H33
  BOTTOM w0.102: v2(203.72,39.23) 203.92,39.03 203.92,38.72 205.7,36.94 205.7,36.36 206.73,35.32 JNGFF2.7
PCIE_PRX_WLANTX_N6: length 40.6
  IN1 w0.114: v2(169.02,41.34) 168.72,41.04 168.72,39.74 169.15,39.31 169.61,39.31 170.16,38.75 170.93,38.75 172.93,36.74 172.93,35.97 174.21,34.69 178.2,34.69 178.41,34.48 180.65,34.48 182.51,32.63 185.63,32.63 189.34,28.92 194.47,28.92 195.03,28.36 195.03,27.73 v2(195.21,27.55)
  BOTTOM w0.102: v2(169.02,41.34) 168.95,41.34 168.67,41.06 UH2.G22 ; JNGFF1.35 194.81,22.8 194.66,22.95 194.66,24.33 194.98,24.65 194.98,27.32 v2(195.21,27.55)
PCIE_PRX_WLANTX_P6: length 40.6
  IN1 w0.114: v2(194.57,27.55) 194.81,27.78 194.81,28.27 194.38,28.7 189.25,28.7 185.54,32.41 182.42,32.41 180.56,34.26 178.31,34.26 178.11,34.46 174.12,34.46 172.71,35.88 172.71,36.65 170.83,38.53 170.07,38.53 169.51,39.09 169.06,39.09 168.93,39.21 168.93,39.21 168.49,39.65 168.49,41.18 v2(168.31,41.37)
  BOTTOM w0.102: UH2.E22 168.63,41.74 168.31,41.42 v2(168.31,41.37) ; v2(194.57,27.55) 194.78,27.35 194.78,24.74 194.46,24.42 194.46,22.95 194.31,22.8 JNGFF1.33
PCIE_PTX_LANRX_N5: length 137.7
  IN1 w0.114: v2(169.38,44.14) 169.58,44.34 169.73,44.34 170.04,44.64 170.62,44.64 170.82,44.44 170.82,44.06 171.12,43.76 173.27,43.76 173.96,43.07 178.97,43.07 182.52,39.51 183.21,39.51 183.74,38.98 186.24,38.98 187.74,37.49 188.47,37.49 188.93,37.03 190.26,37.03 192.17,35.12 201.36,35.12 201.9,34.58 205.7,34.58 208.06,32.22 211.03,32.22 211.91,31.34 222.83,31.34 223.11,31.06 252.73,31.06 253.34,31.66 261.78,31.66 262.19,31.26 268.59,31.26 270,32.67 270,32.78 274.79,37.56 277.6,37.56 282.86,42.82 287.39,42.82 288.67,44.1 291.37,44.1 v2(291.49,43.97)
  BOTTOM w0.076: v2(169.38,44.14) 169.3,44.21 169.07,44.21 168.98,44.12 168.98,43.99 168.81,43.81 168.81,42.89 168.55,42.24 UH2.D22
  BOTTOM w0.102: CL48.1 290.84,44.11 291.35,44.11 v2(291.49,43.97)
PCIE_PTX_LANRX_N5_C: length 1.7
  BOTTOM w0.102: CL48.2 289.28,44.14 288.64,44.14 288.59,44.09 UL1.14
PCIE_PTX_LANRX_P5: length 137.7
  IN1 w0.114: v2(169.38,44.72) 169.53,44.56 169.64,44.56 169.95,44.87 170.71,44.87 171.05,44.53 171.05,44.15 171.22,43.98 173.36,43.98 174.06,43.29 179.06,43.29 182.62,39.74 183.3,39.74 183.83,39.21 186.33,39.21 187.83,37.71 188.57,37.71 189.02,37.25 190.36,37.25 192.26,35.35 201.45,35.35 201.99,34.81 205.79,34.81 208.15,32.45 211.12,32.45 212,31.56 222.92,31.56 223.2,31.28 252.64,31.28 253.24,31.89 261.88,31.89 262.28,31.48 268.5,31.48 269.78,32.76 269.78,32.87 274.69,37.78 277.5,37.78 282.76,43.04 287.3,43.04 288.58,44.32 291.18,44.32 v2(291.48,44.62)
  BOTTOM w0.076: v2(169.38,44.72) 169.38,44.64 169.11,44.38 169,44.38 168.82,44.19 168.82,44.06 168.64,43.88 168.64,42.92 168.61,42.83 UH2.C22
  BOTTOM w0.102: CL47.1 290.92,44.31 291.17,44.31 v2(291.48,44.62)
PCIE_PTX_LANRX_P5_C: length 1.8
  BOTTOM w0.102: CL47.2 289.27,44.35 288.72,44.35 288.58,44.49 UL1.13
PCIE_PTX_SSDRX_N10: length 52.4
  IN1 w0.114: v2(198.83,40.23) 198.62,40.45 198.62,41.14 197.09,42.66 197.09,43.56 192.99,47.66 189.72,47.66 187.86,49.52 181.43,49.52 180.24,48.33 176.87,48.33 176.71,48.48 171.34,48.48 170.12,47.27 168.39,47.27 167.91,46.8 163.56,46.8 162.25,45.5 162.25,45.02 162.33,44.94 162.33,44.74 162.66,44.41 v2(162.72,44.41)
  BOTTOM w0.076: UH2.C32 163.13,42.76 163.13,43.33 162.94,43.52 162.94,44.33 162.85,44.41 v2(162.72,44.41)
  BOTTOM w0.102: CD45.1 200.96,36.26 200.96,36.99 200.18,37.78 200.18,37.81 199.76,38.23 199.72,38.23 198.45,39.5 198.45,39.85 v2(198.83,40.23)
PCIE_PTX_SSDRX_N10_C: length 12.6
  BOTTOM w0.102: CD45.2 201.3,34.67 201.4,34.58 201.4,34.43 201.28,34.32 200.95,34.32 200.88,34.24 200.88,34.12 201.11,33.88 201.62,33.88 203.3,32.21 203.94,32.21 203.97,32.18 204.22,32.18 205.52,30.88 205.52,29.08 v4(205.8,28.8) 206.43,28.18 207.62,28.18 207.77,28.32 JNGFF2.35
PCIE_PTX_SSDRX_N11: length 56.2
  IN1 w0.114: v2(200.71,40.22) 200.47,40.47 200.47,40.81 199.97,41.32 199.38,41.32 197.77,42.92 197.77,44.03 193.49,48.32 189.97,48.32 188.13,50.17 181.06,50.17 179.86,48.97 177.13,48.97 176.97,49.13 171.07,49.13 169.88,47.94 168.09,47.94 167.61,47.46 163.11,47.46 161.18,45.52 161.18,44.49 161.43,44.24 161.71,44.24 v2(161.86,44.08)
  BOTTOM w0.076: UH2.C33 162.84,42.82 162.48,43.19 162.48,43.92 162.31,44.08 v2(161.86,44.08)
  BOTTOM w0.102: CD43.1 202.87,36.26 202.87,36.69 201.85,37.71 201.85,37.94 200.33,39.46 200.33,39.84 v2(200.71,40.22)
PCIE_PTX_SSDRX_N11_C: length 8.5
  BOTTOM w0.102: JNGFF2.23 207.77,31.32 207.47,31.02 206.91,31.02 206.89,31.05 206.22,31.05 203.59,33.68 v4(203.29,33.68) 203.03,33.68 202.8,33.91 202.8,34.07 202.91,34.18 202.91,34.34 202.8,34.45 202.8,34.58 CD43.2
PCIE_PTX_SSDRX_N12: length 60.5
  IN1 w0.114: v2(160.74,43.87) 160.63,43.98 160.29,43.98 160.06,44.22 160.06,46.11 162.07,48.12 167.25,48.12 167.71,48.58 169.61,48.58 170.8,49.77 177.24,49.77 177.4,49.61 179.49,49.61 180.69,50.81 188.39,50.81 190.22,48.98 193.78,48.98 198.43,44.32 198.43,43.35 199.72,42.05 201.64,42.05 202.73,40.96 202.73,40.52 v2(202.98,40.26)
  BOTTOM w0.076: v2(160.74,43.87) 160.96,44.1 161.09,44.1 161.92,43.27 162.16,43.27 162.23,43.2 UH2.B35
  BOTTOM w0.102: CD37.1 204.77,36.26 204.77,36.52 202.6,38.69 202.6,39.88 v2(202.98,40.26)
PCIE_PTX_SSDRX_N12_C: length 5.2
  BOTTOM w0.102: JNGFF2.11 207.79,34.32 207.7,34.23 207.7,34.11 207.61,34.02 207.36,34.02 207.28,34.1 v4(206.59,34.1) 205.57,34.1 205.55,34.13 204.81,34.13 204.61,34.33 204.61,34.52 205.09,35 CD37.2
PCIE_PTX_SSDRX_P10: length 52.3
  IN1 w0.114: v2(162.75,45) 162.59,45 162.48,45.11 162.48,45.4 163.65,46.57 168.01,46.57 168.48,47.05 170.22,47.05 171.43,48.26 176.62,48.26 176.77,48.1 180.33,48.1 181.53,49.3 187.77,49.3 189.63,47.44 192.9,47.44 196.86,43.47 196.86,42.57 198.39,41.04 198.39,39.81 198.29,39.71 197.97,39.71 197.87,39.81 v2(197.87,40.23)
  BOTTOM w0.076: UH2.B32 163.29,43.1 163.29,43.4 163.1,43.58 163.1,44.64 v2(162.75,45)
  BOTTOM w0.102: CD46.1 200.76,36.26 200.76,36.91 v4(199.81,37.86) 198.25,39.42 198.25,39.85 v2(197.87,40.23)
PCIE_PTX_SSDRX_P10_C: length 12.7
  BOTTOM w0.102: JNGFF2.37 207.82,27.82 207.66,27.97 206.34,27.97 205.89,28.43 205.85,28.43 205.43,28.85 205.43,28.88 205.32,29 205.32,30.79 204.13,31.98 v4(203.64,31.98) 203.24,31.98 201.54,33.68 201.03,33.68 200.67,34.03 200.67,34.74 CD46.2
PCIE_PTX_SSDRX_P11: length 56.2
  IN1 w0.114: v2(199.75,40.22) 199.75,39.94 199.88,39.81 200.12,39.81 200.25,39.94 200.25,40.72 199.88,41.09 199.29,41.09 197.55,42.83 197.55,43.94 193.39,48.1 189.88,48.1 188.03,49.94 181.15,49.94 179.96,48.75 177.04,48.75 176.88,48.9 171.16,48.9 169.97,47.71 168.18,47.71 167.7,47.23 163.2,47.23 161.4,45.43 161.4,44.58 161.52,44.46 161.65,44.46 v2(161.86,44.67)
  BOTTOM w0.076: UH2.B33 162.7,43.2 162.64,43.25 162.64,43.99 162.38,44.25 162.2,44.25 161.86,44.59 v2(161.86,44.67)
  BOTTOM w0.102: CD44.1 202.66,36.26 202.66,36.6 201.64,37.63 201.64,37.86 200.13,39.37 200.13,39.84 v2(199.75,40.22)
PCIE_PTX_SSDRX_P11_C: length 8.6
  BOTTOM w0.102: CD44.2 202.59,34.73 202.59,33.83 202.97,33.45 203.53,33.45 205.95,31.04 205.95,31.03 206.16,30.82 v4(206.59,30.82) 207.47,30.82 JNGFF2.25
PCIE_PTX_SSDRX_P12: length 60.5
  IN1 w0.114: v2(202.02,40.26) 202.02,39.98 202.12,39.88 202.4,39.88 202.5,39.98 202.5,40.87 201.54,41.83 199.63,41.83 198.21,43.25 198.21,44.23 193.68,48.76 190.13,48.76 188.3,50.58 180.78,50.58 179.58,49.39 177.31,49.39 177.15,49.55 170.9,49.55 169.71,48.35 167.8,48.35 167.35,47.89 162.16,47.89 160.28,46.01 160.28,44.31 160.39,44.21 160.49,44.21 160.76,44.47 v2(160.77,44.47)
  BOTTOM w0.076: UH2.A35 162.23,43.51 162.15,43.43 161.99,43.43 161.16,44.26 160.98,44.26 v2(160.77,44.47)
  BOTTOM w0.102: v2(202.02,40.26) 202.4,39.88 202.4,38.6 204.57,36.43 204.57,36.26 CD42.1
PCIE_PTX_SSDRX_P12_C: length 5.2
  BOTTOM w0.102: CD42.2 204.4,34.82 204.4,34.25 204.73,33.92 204.88,33.92 204.91,33.9 v4(205.22,33.9) 206.26,33.9 206.29,33.87 206.89,33.87 206.91,33.9 207.2,33.9 207.28,33.82 JNGFF2.13
PCIE_PTX_WLANRX_N6: length 45.1
  IN1 w0.114: v2(168.41,44.29) 168.87,44.74 168.87,44.81 169.17,45.11 169.17,45.51 169.43,45.76 170.75,45.76 171.96,46.98 176.08,46.98 176.24,46.82 181.74,46.82 182.87,47.95 187.18,47.95 188.16,46.97 188.16,44.43 188.71,43.87 192.36,43.87 193.04,44.55 193.37,44.55 193.94,43.98 193.94,41.62 194.7,40.86 194.98,40.86 v2(195.14,40.7)
  BOTTOM w0.076: v2(168.41,44.29) 168.3,44.29 168.17,44.16 168.17,43.82 168.26,43.73 168.26,43.53 168.21,43.47 168.21,43.29 168.26,43.23 UH2.B22
  BOTTOM w0.102: CN20.1 191,35.88 190.72,36.16 190.72,36.5 191.02,36.79 191.58,36.79 192.26,37.48 192.95,37.48 v4(193.7,38.23) 194.52,39.06 194.52,40.95 194.66,41.09 194.88,41.09 195.14,40.83 v2(195.14,40.7)
PCIE_PTX_WLANRX_P6: length 45.1
  IN1 w0.114: v2(168.41,44.9) 168.64,44.9 168.95,45.21 168.95,45.6 169.34,45.98 170.66,45.98 171.87,47.2 176.18,47.2 176.33,47.04 181.64,47.04 182.78,48.17 187.27,48.17 188.39,47.06 188.39,44.52 188.81,44.1 192.26,44.1 192.94,44.78 193.46,44.78 194.16,44.08 194.16,41.71 194.79,41.08 194.97,41.08 195.13,41.24 v2(195.13,41.42)
  BOTTOM w0.076: UH2.A23 168.01,44.39 168.41,44.8 v2(168.41,44.9)
  BOTTOM w0.102: v2(195.13,41.42) 195.01,41.29 194.58,41.29 194.32,41.03 194.32,39.14 193.78,38.6 193.75,38.6 193.33,38.18 193.33,38.14 192.86,37.68 192.18,37.68 191.49,37 190.93,37 190.52,36.58 190.52,36.14 CN21.1
PCIE_PTX_WLANRX_RE_N6: length 20.1
  BOTTOM w0.102: JNGFF1.29 193.31,22.8 193.16,22.95 193.16,23.53 190.82,25.87 187.24,25.87 186.34,26.77 186.34,29.83 v4(187.31,30.8) 189.11,32.6 189.11,32.71 189.96,33.56 190,33.56 190.42,33.98 190.42,34.01 190.8,34.39 190.8,34.62 CN20.2
PCIE_PTX_WLANRX_RE_P6: length 20.1
  BOTTOM w0.102: JNGFF1.27 192.81,22.8 192.96,22.95 192.96,23.45 190.74,25.67 187.16,25.67 186.14,26.69 186.14,29.92 186.94,30.71 186.94,30.75 187.36,31.17 187.4,31.17 188.91,32.69 188.91,32.79 v4(190.05,33.93) 190.6,34.48 190.6,34.62 CN21.2
PCIE_RCOMPN: length 4.2
  BOTTOM w0.089: UH2.B18 170.66,43.37 170.72,43.43 170.72,44.64 170.82,44.74
  BOTTOM w0.127: RH108.1 171,46.52 v1(171.51,47.03)
  BOTTOM w0.305: RH108.1 170.82,45.71 170.82,44.74
PCIE_RCOMPP: length 4.7
  BOTTOM w0.089: 170.27,44.8 170.54,44.52 170.54,43.51 170.43,43.4 170.43,43.08 170.76,42.75 UH2.C17
  BOTTOM w0.127: RH108.2 v1(170.08,47.02)
  BOTTOM w0.305: RH108.2 170.22,45.75 170.22,44.85 170.27,44.8
PCIE_WAKE#: length 147.6
  TOP w0.102: UE1.4 218.87,28.94 218.64,29.17 218.07,29.17 217.54,28.64 215.66,28.64 214.06,27.04 214.06,24.96 212.84,23.74 212.84,22.16 v2(212.81,22.14)
  IN3 w0.127: v2(175.6,12.56) 176.03,12.13 178.2,12.13 178.48,12.41 178.48,12.49 180.76,14.77 180.76,15.43 182.89,17.57 186.97,17.57 188.49,19.09 194.24,19.09 194.7,19.55 196.45,19.55 v2(197.01,18.99) 197.65,18.99 199.98,21.32 206.66,21.32 207.68,22.34 212.61,22.34 v2(212.81,22.14) 213.08,22.14 215.02,20.19 215.9,20.19 216.88,19.22 220.28,19.22 221.22,18.28 222.46,18.28 223.3,19.12 228,19.12 228.61,19.73 230.99,19.73 233.54,22.27 237.61,22.27 238.67,23.34 243.11,23.34 244.03,24.26 251.79,24.26 252.31,24.78 259.83,24.78 260.77,23.84 261.68,23.84 263.87,26.03 272.88,26.03 274.81,27.96 274.81,30.67 279.08,34.94 279.08,36.46 279.31,36.69 282.15,36.69 v2(284.54,39.08)
  BOTTOM w0.102: v2(197.01,18.99) 196.86,19.14 196.86,20.51 197.3,20.95 197.68,20.95 197.81,21.08 JNGFF1.47 ; v2(175.6,12.56) 174.84,13.33 RH114.2 ; v2(284.54,39.08) 284.95,38.67 285.46,38.67 285.86,39.08 285.86,39.51 RL2.1
PECI: length 11.5
  BOTTOM w0.076: 181.62,30.41 181.55,30.34 181.55,30.22 181.29,29.96 180.92,29.96 179.93,28.97 178.7,28.97 178.57,29.1 178.25,29.1 178.01,28.86 UH2.AL3
  BOTTOM w0.102: RH138.1 185.15,34.94 183.78,33.57 183.78,32.98 182.99,32.18 v1(182.99,31.77) 181.63,30.41 181.62,30.41
PECI_EC: length 227.7
  TOP w0.127: RE17.2 239.35,30.27 238.4,31.22 DE8.1 238.26,31.5 v2(238.26,33.37)
  IN2 w0.127: v2(189.67,38.34) 190.74,37.28 191.83,37.28 192.29,37.73 200.52,37.73 201.64,36.62 206.77,36.62 209.33,34.05 218.05,34.05 219.56,35.57 225.88,35.57 226.28,35.97 226.28,37.16 227.13,38.01 228.57,38.01 228.83,38.26 234.23,38.26 238.26,34.23 v2(238.26,33.37)
  IN3 w0.127: v2(79.21,96.38) 79.21,98.51 87.55,106.85 130.66,106.85 152.01,85.5 152.01,79.91 154.44,77.49 154.96,77.49 156.39,76.06 158.71,76.06 159.3,75.48 167.4,75.48 171.79,71.09 171.79,69.64 172.07,69.36 172.07,68.7 172.24,68.52 172.24,67.24 180.47,59.02 181.97,59.02 184.72,56.27 184.72,52.82 191.02,46.51 191.02,39.44 189.93,38.34 v2(189.67,38.34)
  BOTTOM w0.127: RH190.1 81.06,98.24 v2(79.21,96.38) ; v2(189.67,38.34) 189.38,38.64 v1(188.53,38.64) 187.86,38.64 187.46,38.24 187.46,37.81 186.09,36.44 RH138.2
PECI_EC_R: length 4.9
  BOTTOM w0.102: UH1.BT34 86.37,97.43 85.56,98.24 v1(84.13,98.24) RH190.2
PECI_MEC1404: length 2.6
  TOP w0.102: UE1.94 v1(237.42,29.34) 238.33,29.34 RE17.1
PEG_GTX_C_HRX_N0: length 28.8
  TOP w0.076: 127.65,78.59 127.64,78.6 127.64,78.63 127.37,78.9 126.54,78.9 126.39,79.05 126.27,79.05 126.02,78.81 125.8,78.81 125.71,78.89 125.71,79.01 v2(125.93,79.24)
  TOP w0.102: CV532.2 150.88,82.82 150.51,83.19 v4(149.64,83.19) 146.71,83.19 146.57,83.04 143.37,83.04 139.36,79.03 130.52,79.03 129.81,78.32 127.92,78.32 127.65,78.59
  BOTTOM w0.076: UH1.E10 125.94,79.3 125.94,79.24 v2(125.93,79.24)
PEG_GTX_C_HRX_N1: length 30.3
  TOP w0.076: v2(125.93,80.02) 126.13,79.83 126.13,79.78 126.53,79.37 127.82,79.37 127.84,79.36 127.85,79.36
  TOP w0.102: 127.85,79.36 127.95,79.36 128.32,78.98 129.58,78.98 130.27,79.67 139.13,79.67 144.09,84.62 v4(146.49,84.62) 148.52,84.62 149.32,83.82 150.11,83.82 150.12,83.81 150.64,83.81 150.72,83.89 152.49,83.89 CV534.2
  BOTTOM w0.076: v2(125.93,80.02) 125.61,80.35 UH1.E11
PEG_GTX_C_HRX_N2: length 29
  TOP w0.076: 126.35,80.64 126.33,80.64 126.31,80.62 126.1,80.62 125.93,80.78 v2(125.93,80.81)
  TOP w0.102: 126.35,80.64 127.48,80.64 127.73,80.39 128.15,80.39 128.36,80.18 129.47,80.18 129.8,80.51 138.8,80.51 143.88,85.59 148.98,85.59 149.51,85.06 v4(149.82,85.06) 150.36,85.06 150.43,85.13 150.43,85.59 150.53,85.69 150.73,85.69 150.89,85.53 CV536.2
  BOTTOM w0.076: v2(125.93,80.81) 125.75,80.81 125.61,80.95 UH1.E12
PEG_GTX_C_HRX_N3: length 30.1
  TOP w0.076: v2(125.93,81.6) 126.12,81.42 126.12,81.23 126.31,81.04 127.01,81.04 127.03,81.02 127.04,81.02
  TOP w0.102: 127.04,81.02 127.76,81.02 127.96,80.81 128.3,80.81 128.53,80.58 129.28,80.58 129.63,80.94 138.6,80.94 143.88,86.22 v4(147.25,86.22) 151.5,86.22 151.69,86.04 152.38,86.04 CV538.2
  BOTTOM w0.076: UH1.E13 125.61,81.92 v2(125.93,81.6)
PEG_GTX_C_HRX_N4: length 29.8
  TOP w0.102: CV540.2 150.59,87.22 149.9,87.22 149.87,87.25 149.24,87.25 149.22,87.22 143.62,87.22 138.18,81.78 128.18,81.78 127.75,82.21 125.69,82.21 125.46,81.97 125.43,81.97 125.42,81.96 125.09,81.96 124.95,82.1 124.95,82.19 124.97,82.22 124.97,82.29 125.07,82.38 125.3,82.38 125.3,82.38 v2(125.29,82.38)
  BOTTOM w0.076: v2(125.29,82.38) 125.29,82.51 125.55,82.78 UH1.E14
PEG_GTX_C_HRX_N5: length 30
  TOP w0.102: CV542.2 v4(146.31,87.9) 143.63,87.9 137.91,82.18 128.32,82.18 127.94,82.57 126.84,82.57 126.84,82.56 126.33,82.56 126.33,82.57 126.31,82.57 126.09,82.79 126.09,83.02 v2(125.93,83.17)
  BOTTOM w0.076: UH1.E15 125.61,83.5 v2(125.93,83.17)
PEG_GTX_C_HRX_N6: length 28.8
  TOP w0.102: CV544.2 150.66,89.78 150.56,89.78 150.48,89.7 150.48,89.22 150.38,89.12 v4(149.67,89.12) 143.67,89.12 137.96,83.4 128.31,83.4 127.93,83.78 126.11,83.78 v2(125.93,83.96)
  BOTTOM w0.076: UH1.E16 125.61,84.14 125.79,83.96 v2(125.93,83.96)
PEG_GTX_C_HRX_N7: length 30.5
  TOP w0.102: CV546.2 152.47,90.01 151.57,90.01 151.3,90.28 v4(146.64,90.28) 144.22,90.28 138.54,84.6 134.8,84.6 134.77,84.57 134.21,84.57 134.18,84.6 132.42,84.6 131.63,83.81 128.53,83.81 128.22,84.11 126.3,84.11 126.09,84.33 126.08,84.33 126.07,84.34 126.07,84.61 v2(125.93,84.75)
  BOTTOM w0.076: UH1.E17 125.61,85.07 v2(125.93,84.75)
PEG_GTX_C_HRX_N8: length 29.1
  TOP w0.102: CV548.2 150.52,90.95 150.52,90.95 149.76,90.95 149.74,90.92 149.14,90.92 149.11,90.95 144.01,90.95 138.37,85.31 132.14,85.31 131.58,84.75 127.81,84.75 127.41,85.15 126.42,85.15 126.39,85.13 125.69,85.13 v2(125.28,85.53)
  BOTTOM w0.102: UH1.F18 124.96,85.86 v2(125.28,85.53)
PEG_GTX_C_HRX_N9: length 31
  TOP w0.102: v2(125.93,86.32) 126.05,86.32 126.45,85.92 127.88,85.92 128.17,85.63 129.15,85.63 129.23,85.71 131.34,85.71 131.81,86.17 136.52,86.17 136.54,86.2 137.11,86.2 137.14,86.17 138.06,86.17 144.23,92.35 v4(148.14,92.35) 151.19,92.35 151.32,92.21 151.97,92.21 152.05,92.29 152.05,92.78 152.18,92.9 152.28,92.9 152.54,92.65 CV551.2
  BOTTOM w0.076: v2(125.93,86.32) 125.93,86.44 126.21,86.71 UH1.D19
PEG_GTX_C_HRX_N10: length 29.2
  TOP w0.102: v2(125.28,87.11) 125.36,87.11 125.77,86.71 126.8,86.71 127.13,86.38 130.92,86.38 131.37,86.83 138.12,86.83 144.28,93 149.34,93 149.37,92.97 149.96,92.97 149.99,93 150.51,93 150.52,92.98 CV557.2
  BOTTOM w0.076: v2(125.28,87.11) 124.96,87.43 UH1.F20
PEG_GTX_C_HRX_N11: length 30.9
  TOP w0.102: v2(126.58,87.9) 126.4,87.9 126.3,87.8 126.3,87.57 126.4,87.46 128.48,87.46 128.75,87.19 130.49,87.19 131.02,87.72 136.56,87.72 136.58,87.75 137.2,87.75 137.22,87.72 137.86,87.72 144.55,94.42 149.74,94.42 149.9,94.58 151.55,94.58 151.9,94.23 152.11,94.23 152.51,94.63 CV559.2
  BOTTOM w0.076: v2(126.58,87.9) 126.58,87.96 UH1.D21
PEG_GTX_C_HRX_N12: length 29.2
  TOP w0.102: v2(125.28,88.68) 125.66,88.31 127.69,88.31 127.76,88.23 137.78,88.23 144.56,95.02 147.97,95.02 148,94.99 148.59,94.99 148.62,95.02 CV561.2
  BOTTOM w0.076: v2(125.28,88.68) 124.96,89.01 UH1.F22
PEG_GTX_C_HRX_N13: length 30.9
  TOP w0.102: CV563.2 152.25,96.37 151.77,96.37 151.52,96.63 150.24,96.63 150.22,96.65 149.62,96.65 149.6,96.63 145.03,96.63 138.05,89.65 134.34,89.65 v4(134.34,89.65) 134.33,89.65 128.13,89.65 127.51,89.04 126.39,89.04 126.29,89.14 126.29,89.36 126.4,89.47 v2(126.58,89.47)
  BOTTOM w0.076: v2(126.58,89.47) 126.43,89.47 126.26,89.64 UH1.D23
PEG_GTX_C_HRX_N14: length 29.6
  TOP w0.102: v2(125.28,90.26) 125.69,90.67 126.07,90.67 126.38,90.36 126.48,90.26 130.1,90.26 130.28,90.44 137.9,90.44 144.93,97.47 146.14,97.47 146.17,97.49 146.8,97.49 146.82,97.47 150.67,97.47 CV565.2
  BOTTOM w0.076: UH1.F24 125.28,90.33 v2(125.28,90.26)
PEG_GTX_C_HRX_N15: length 30.6
  TOP w0.102: CV567.2 152.17,98.7 151.96,98.48 150.27,98.48 150.24,98.51 149.65,98.51 149.62,98.48 v4(147.91,98.48) 145.05,98.48 137.92,91.35 128.4,91.35 128.27,91.23 127.7,91.23 127.35,90.87 127.08,90.87 126.98,90.97 126.98,91.36 126.88,91.46 126.69,91.46 126.58,91.36 v2(126.58,91.05)
  BOTTOM w0.076: UH1.D25 126.26,91.37 126.58,91.05 v2(126.58,91.05)
PEG_GTX_C_HRX_P0: length 28.8
  TOP w0.076: 127.79,78.74 127.78,78.75 127.75,78.75 127.44,79.06 126.61,79.06 126.07,79.6 125.65,79.6 v2(125.28,79.24)
  TOP w0.102: CV531.2 150.82,83.39 149.96,83.39 149.94,83.42 149.34,83.42 149.32,83.39 146.63,83.39 146.48,83.24 143.28,83.24 139.28,79.24 130.44,79.24 129.73,78.53 128,78.53 127.79,78.74
  BOTTOM w0.076: v2(125.28,79.24) 124.96,79.56 UH1.F10
PEG_GTX_C_HRX_P1: length 30.3
  TOP w0.076: 127.85,79.56 127.84,79.56 127.82,79.54 126.6,79.54 126.35,79.79 126.35,79.94 126.43,80.02 v2(126.58,80.02)
  TOP w0.102: CV533.2 152.16,84.09 150.63,84.09 150.56,84.01 150.2,84.01 150.19,84.03 149.4,84.03 148.6,84.83 146.82,84.83 146.79,84.85 146.19,84.85 146.17,84.83 144,84.83 139.05,79.87 130.18,79.87 129.5,79.19 128.41,79.19 128.04,79.56 127.85,79.56
  BOTTOM w0.076: UH1.D11 126.26,80.35 v2(126.58,80.02)
PEG_GTX_C_HRX_P2: length 29
  TOP w0.076: 126.35,80.43 126.33,80.43 126.31,80.45 125.64,80.45 v2(125.28,80.81)
  TOP w0.102: CV535.2 150.14,84.86 150.12,84.83 149.45,84.83 148.9,85.38 143.96,85.38 138.88,80.3 129.89,80.3 129.56,79.97 128.27,79.97 128.06,80.18 127.64,80.18 127.39,80.43 126.35,80.43
  BOTTOM w0.076: UH1.F12 124.96,81.14 v2(125.28,80.81)
PEG_GTX_C_HRX_P3: length 30.2
  TOP w0.076: 127.04,81.22 127.02,81.22 127,81.2 126.38,81.2 126.28,81.3 126.28,81.5 126.38,81.6 v2(126.58,81.6)
  TOP w0.102: 127.04,81.22 127.85,81.22 128.05,81.02 128.38,81.02 128.61,80.79 129.19,80.79 129.55,81.14 138.52,81.14 143.8,86.43 146.93,86.43 146.96,86.45 147.55,86.45 147.58,86.43 151.59,86.43 151.77,86.24 152.27,86.24 CV537.2
  BOTTOM w0.076: UH1.D13 126.26,81.82 126.48,81.6 v2(126.58,81.6)
PEG_GTX_C_HRX_P4: length 29.8
  TOP w0.102: v2(124.6,82.37) 124.74,82.23 124.74,82.02 125.01,81.75 125.5,81.75 125.52,81.77 125.54,81.77 125.78,82.01 127.66,82.01 128.09,81.57 138.26,81.57 143.71,87.02 v4(149.54,87.02) 150.76,87.02 CV539.2
  BOTTOM w0.076: UH1.F14 124.96,82.73 124.6,82.37 124.6,82.37 v2(124.6,82.37)
PEG_GTX_C_HRX_P5: length 30.1
  TOP w0.102: CV541.2 152.11,88.11 146.64,88.11 146.61,88.13 146.02,88.13 145.99,88.11 143.55,88.11 137.83,82.39 128.41,82.39 128.03,82.77 126.76,82.77 126.75,82.77 126.42,82.77 126.41,82.77 126.39,82.77 126.29,82.87 126.29,83.07 126.39,83.17 v2(126.58,83.17)
  BOTTOM w0.076: UH1.D15 126.58,83.24 v2(126.58,83.17)
PEG_GTX_C_HRX_P6: length 28.8
  TOP w0.102: v2(125.28,83.96) 125.66,83.58 127.85,83.58 128.23,83.2 138.04,83.2 143.76,88.92 149.34,88.92 149.36,88.89 149.96,88.89 149.99,88.92 150.52,88.92 150.52,88.92 CV543.2
  BOTTOM w0.076: v2(125.28,83.96) 124.96,84.28 UH1.F16
PEG_GTX_C_HRX_P7: length 30.5
  TOP w0.102: CV545.2 152.18,90.21 151.66,90.21 151.39,90.48 146.97,90.48 146.94,90.51 146.35,90.51 146.32,90.48 144.14,90.48 138.46,84.8 v4(134.49,84.8) 132.34,84.8 131.55,84.01 128.61,84.01 128.31,84.32 126.38,84.32 126.27,84.43 126.27,84.58 126.44,84.75 v2(126.58,84.75)
  BOTTOM w0.076: v2(126.58,84.75) 126.48,84.75 126.26,84.97 UH1.D17
PEG_GTX_C_HRX_P8: length 29
  TOP w0.102: CV547.2 150.89,91.66 150.81,91.73 150.53,91.73 150.45,91.66 150.45,91.23 150.38,91.15 v4(149.44,91.15) 143.93,91.15 138.29,85.51 132.06,85.51 131.5,84.95 127.9,84.95 127.5,85.36 126.33,85.36 126.31,85.33 126.01,85.33 125.93,85.41 v2(125.93,85.53)
  BOTTOM w0.102: UH1.E18 125.61,85.77 125.84,85.53 v2(125.93,85.53)
PEG_GTX_C_HRX_P9: length 31
  TOP w0.102: v2(125.28,86.32) 125.38,86.32 125.78,85.92 126.16,85.92 126.37,85.72 127.8,85.72 128.08,85.43 129.24,85.43 129.31,85.5 131.43,85.5 131.89,85.97 v4(136.83,85.97) 138.14,85.97 144.32,92.14 147.82,92.14 147.84,92.12 148.44,92.12 148.47,92.14 151.1,92.14 151.24,92.01 151.97,92.01 152.01,91.97 CV550.2
  BOTTOM w0.076: UH1.E19 125.61,86.65 v2(125.28,86.32)
PEG_GTX_C_HRX_P10: length 29.2
  TOP w0.102: v2(125.93,87.11) 126.14,86.91 126.88,86.91 127.21,86.58 130.83,86.58 131.29,87.04 138.03,87.04 144.2,93.2 v4(149.67,93.2) 150.32,93.2 150.4,93.28 150.4,93.79 150.53,93.92 150.63,93.92 150.89,93.66 CV552.2
  BOTTOM w0.076: v2(125.93,87.11) 125.61,87.43 UH1.E20
PEG_GTX_C_HRX_P11: length 30.9
  TOP w0.102: v2(125.93,87.9) 126.09,87.74 126.09,87.48 126.31,87.26 128.39,87.26 128.67,86.99 130.57,86.99 131.11,87.52 v4(136.87,87.52) 137.94,87.52 144.64,94.21 149.83,94.21 149.99,94.38 151.46,94.38 151.81,94.02 152.51,94.02 CV558.2
  BOTTOM w0.076: v2(125.93,87.9) 125.61,88.22 UH1.E21
PEG_GTX_C_HRX_P12: length 29.1
  TOP w0.102: v2(125.93,88.68) 126.11,88.51 127.77,88.51 127.85,88.43 137.7,88.43 144.48,95.22 v4(148.3,95.22) 150.4,95.22 150.48,95.29 150.48,95.8 150.58,95.9 150.71,95.9 150.89,95.72 CV560.2
  BOTTOM w0.076: UH1.E22 125.61,89.01 v2(125.93,88.68)
PEG_GTX_C_HRX_P13: length 30.9
  TOP w0.102: v2(125.93,89.47) 126.08,89.32 126.08,89.06 126.3,88.84 127.6,88.84 128.21,89.45 134.02,89.45 134.05,89.42 134.62,89.42 134.65,89.45 138.14,89.45 145.11,96.42 v4(149.92,96.42) 151.44,96.42 151.69,96.17 152.4,96.17 CV562.2
  BOTTOM w0.076: v2(125.93,89.47) 125.61,89.8 UH1.E23
PEG_GTX_C_HRX_P14: length 29.5
  TOP w0.102: CV564.2 150.67,97.26 v4(146.47,97.26) 145.01,97.26 137.98,90.24 130.36,90.24 130.18,90.06 126.34,90.06 126.12,89.84 125.74,89.84 125.69,89.89 125.69,90.21 125.74,90.26 v2(125.93,90.26)
  BOTTOM w0.076: UH1.E24 125.61,90.49 125.84,90.26 v2(125.93,90.26)
PEG_GTX_C_HRX_P15: length 30.6
  TOP w0.102: v2(125.89,91.05) 126.02,91.05 126.4,90.67 127.43,90.67 127.79,91.02 128.36,91.02 128.48,91.15 138.01,91.15 145.14,98.28 147.59,98.28 147.62,98.25 148.21,98.25 148.24,98.28 v4(149.95,98.28) 151.96,98.28 152.17,98.06 CV566.2
  BOTTOM w0.076: v2(125.89,91.05) 125.89,91.15 UH1.E25
PEG_GTX_HRX_N0: length 10.3
  TOP w0.102: CV532.1 151.69,83.04 153.42,83.04 154.59,84.22 154.63,84.22 155.05,84.64 155.05,84.67 155.29,84.91 v4(156.14,84.91) 158.36,84.91 158.8,85.36 158.8,85.86 158.95,86.01 158.95,86.23 v2(159.17,86.45)
  BOTTOM w0.102: v2(159.17,86.45) 158.74,86.87 UV1.AJ14
PEG_GTX_HRX_N1: length 8.9
  TOP w0.076: v2(159.95,86.5) 159.65,86.8 157.72,86.8 157.7,86.82
  TOP w0.102: CV534.1 153.39,84.1 153.62,84.1 v4(155.76,86.25) 156.48,86.97 157.55,86.97 157.7,86.82
  BOTTOM w0.102: UV1.AG14 159.98,86.5 v2(159.95,86.5)
PEG_GTX_HRX_N2: length 8.7
  TOP w0.102: v2(158.31,88.07) 158.31,88.05 158.03,87.77 157.81,87.77 157.74,87.71 157.54,87.71 157.52,87.73 156.92,87.73 156.89,87.71 155.97,87.71 v4(154.31,86.05) 153.58,85.32 152.02,85.32 151.84,85.49 CV536.1
  BOTTOM w0.102: UV1.AJ15 158.67,87.71 v2(158.31,88.07)
PEG_GTX_HRX_N3: length 6.1
  TOP w0.102: CV538.1 153.34,86.09 153.76,86.09 v4(155.31,87.64) 156.06,88.38 156.75,88.38 156.77,88.41 157.25,88.41 v2(157.51,88.15)
  BOTTOM w0.102: v2(157.51,88.15) 157.51,88.18 UV1.AK16
PEG_GTX_HRX_N4: length 9.7
  TOP w0.102: CV540.1 151.72,87.27 153.65,87.27 v4(153.99,87.62) 156,89.63 158.75,89.63 158.97,89.41 158.97,89.18 159.14,89.01 v2(159.14,89.01)
  BOTTOM w0.102: v2(159.14,89.01) UV1.AJ17
PEG_GTX_HRX_N5: length 8.7
  TOP w0.102: CV542.1 153.25,88.03 153.75,88.03 155.68,89.96 v4(156.42,89.96) 158.87,89.96 159.43,89.39 159.63,89.39 v2(160,89.02)
  BOTTOM w0.102: v2(160,89.02) 160,89.02 UV1.AG17
PEG_GTX_HRX_N6: length 8.3
  TOP w0.102: v2(158.34,90.58) 158.34,90.58 158.34,90.58 158.34,90.57 158.06,90.57 157.69,90.95 157.64,90.95 157.64,90.95 157.34,90.95 157.34,90.95 157.25,90.95 157.16,90.85 155.35,90.85 154.55,90.05 154.52,90.05 154.09,89.63 154.09,89.59 153.91,89.41 152.4,89.41 152.25,89.55 CV544.1
  BOTTOM w0.102: v2(158.34,90.58) 158.34,90.58 158.34,90.58 158.71,90.21 UV1.AJ18
PEG_GTX_HRX_N7: length 5.5
  TOP w0.076: v2(157.46,91.42) 157.24,91.42 156.87,91.05 154.9,91.05 154.83,90.97 154.83,90.96 154.81,90.95
  TOP w0.102: CV546.1 153.8,89.94 154.81,90.95
  BOTTOM w0.089: v2(157.46,91.42) 157.5,91.42 157.86,91.06 UV1.AK19
PEG_GTX_HRX_N8: length 9.3
  TOP w0.076: v2(159.22,91.51) 158.96,91.51 158.58,91.13 158.25,91.13 157.89,91.48 157.89,91.65 157.7,91.84 156.36,91.84 156.26,91.73 156.08,91.73 156.06,91.72 156.04,91.72
  TOP w0.102: CV548.1 151.69,91.17 153.76,91.17 154.31,91.72 155.01,91.72 155.03,91.69 155.63,91.69 155.65,91.72 156.04,91.72
  BOTTOM w0.102: v2(159.22,91.51) 158.82,91.91 UV1.AJ20
PEG_GTX_HRX_N9: length 9.1
  TOP w0.076: v2(160.79,91.51) 160.55,91.75 160.55,92.19 160.38,92.37 158.33,92.37 158.28,92.42 157.84,92.42 157.79,92.37 156.26,92.37 156.1,92.53 155.62,92.53 155.6,92.55 155.59,92.55
  TOP w0.102: CV551.1 153.34,92.39 153.82,92.39 153.98,92.55 155.59,92.55
  BOTTOM w0.102: UV1.AG20 v2(160.79,91.51)
PEG_GTX_HRX_N10: length 8.3
  TOP w0.076: 156,93.12 156.01,93.11 156.04,93.11 156.48,92.66 157.9,92.66 158.1,92.86 158.1,93.11 158.2,93.21 v2(158.33,93.21)
  TOP w0.102: CV557.1 151.69,93.2 151.83,93.2 151.94,93.31 152.96,93.31 153.07,93.2 v4(153.98,93.2) 155.06,93.2 155.08,93.17 155.68,93.17 155.71,93.2 155.92,93.2 156,93.12
  BOTTOM w0.102: v2(158.33,93.21) 158.74,92.8 UV1.AJ21
PEG_GTX_HRX_N11: length 5.2
  TOP w0.102: v2(157.45,94) 157.03,94.42 v4(154.52,94.42) 153.34,94.42 CV559.1
  BOTTOM w0.102: v2(157.45,94) 157.89,93.56 UV1.AK22
PEG_GTX_HRX_N12: length 8.1
  TOP w0.076: v2(158.31,93.98) 158.31,94.08 158.07,94.31 157.77,94.31 157.39,94.69 155.8,94.69 155.62,94.87
  TOP w0.102: 155.62,94.87 155.62,94.88 155.26,95.23 151.69,95.23 CV561.1
  BOTTOM w0.102: UV1.AJ23 v2(158.31,93.98)
PEG_GTX_HRX_N13: length 9.4
  TOP w0.076: 156.1,95.56 156.11,95.55 156.11,95.53 156.37,95.27 159.65,95.27 160.55,94.36 160.55,94.25 v2(160.79,94.01)
  TOP w0.102: 156.1,95.56 155.21,96.45 154.59,96.45 154.56,96.48 153.97,96.48 153.94,96.45 153.34,96.45 CV563.1
  BOTTOM w0.089: v2(160.79,94.01) UV1.AG23
PEG_GTX_HRX_N14: length 8.5
  TOP w0.076: 156.31,96.38 156.31,96.37 156.31,96.34 156.49,96.17 157.93,96.17 158.13,95.98 158.13,95.82 158.31,95.64 v2(158.31,95.64)
  TOP w0.102: 156.31,96.38 155.8,96.88 155.8,96.92 155.38,97.34 155.35,97.34 155.15,97.54 153.38,97.54 153.31,97.47 151.69,97.47 CV565.1
  BOTTOM w0.076: UV1.AJ24 v2(158.31,95.64)
PEG_GTX_HRX_N15: length 6.4
  TOP w0.102: CV567.1 153.34,98.48 153.75,98.48 153.99,98.24 155.55,98.24 155.85,97.93 v4(156.31,97.93) 156.98,97.93 157.34,97.57 157.34,96.65 v2(157.47,96.53)
  BOTTOM w0.102: UV1.AK25 157.89,96.11 v2(157.47,96.53)
PEG_GTX_HRX_P0: length 10.3
  TOP w0.102: v2(158.26,86.43) 158.66,86.43 158.75,86.35 158.75,86.09 158.6,85.94 158.6,85.44 158.27,85.12 156.47,85.12 156.44,85.14 155.85,85.14 155.82,85.12 155.21,85.12 v4(154.68,84.59) 153.33,83.24 152.06,83.24 151.84,83.46 CV531.1
  BOTTOM w0.102: UV1.AK14 157.89,86.81 v2(158.26,86.43)
PEG_GTX_HRX_P1: length 8.9
  TOP w0.076: 157.79,87.02 157.85,86.97 159.62,86.97 v2(159.97,87.32)
  TOP w0.102: CV533.1 153.29,84.3 153.53,84.3 155.39,86.16 155.39,86.2 155.81,86.62 155.85,86.62 156.4,87.17 157.64,87.17 157.79,87.02
  BOTTOM w0.102: v2(159.97,87.32) 159.59,86.93 UV1.AH14
PEG_GTX_HRX_P2: length 8.7
  TOP w0.102: CV535.1 151.73,85.11 153.66,85.11 154.23,85.68 154.26,85.68 154.68,86.1 154.68,86.13 156.05,87.51 v4(157.22,87.51) 157.83,87.51 157.89,87.57 158.09,87.57 v2(158.32,87.34)
  BOTTOM w0.102: UV1.AK15 158.21,87.39 158.27,87.39 v2(158.32,87.34)
PEG_GTX_HRX_P3: length 6.1
  TOP w0.102: v2(157.47,88.95) 157.13,88.61 v4(156.45,88.61) 156.02,88.61 155.99,88.59 155.98,88.59 155.4,88.01 155.36,88.01 154.94,87.59 154.94,87.55 153.68,86.29 153.34,86.29 CV537.1
  BOTTOM w0.102: UV1.AL16 157.09,88.57 v2(157.47,88.95)
PEG_GTX_HRX_P4: length 9.7
  TOP w0.102: CV539.1 151.66,87.07 153.73,87.07 153.9,87.24 153.94,87.24 154.36,87.66 154.36,87.7 156.08,89.42 158.67,89.42 158.77,89.32 158.77,89.11 158.67,89.01 v2(158.29,89.01)
  BOTTOM w0.102: UV1.AK17 v2(158.29,89.01)
PEG_GTX_HRX_P5: length 8.7
  TOP w0.102: v2(159.99,89.81) 159.78,89.6 159.52,89.6 158.95,90.16 156.75,90.16 156.72,90.19 156.13,90.19 156.1,90.16 155.59,90.16 153.67,88.23 153.43,88.23 CV541.1
  BOTTOM w0.102: UV1.AH17 v2(159.99,89.81)
PEG_GTX_HRX_P6: length 8.3
  TOP w0.102: v2(157.49,90.58) 157.5,90.57 157.5,90.45 157.4,90.35 157.17,90.35 157.09,90.43 157.09,90.53 156.98,90.65 155.44,90.65 v4(154.47,89.68) 154,89.21 152.31,89.21 152.17,89.35 151.93,89.35 151.85,89.27 151.85,88.81 151.77,88.74 151.6,88.74 151.47,88.86 CV543.1
  BOTTOM w0.102: UV1.AK18 157.89,90.29 157.6,90.58 v2(157.49,90.58)
PEG_GTX_HRX_P7: length 5.5
  TOP w0.076: 154.67,91.09 154.68,91.1 154.71,91.1 154.82,91.21 155.97,91.21 156.04,91.28 156.04,91.48 156.09,91.53 156.22,91.53 156.3,91.46 156.3,91.33 156.41,91.21 156.58,91.21 156.68,91.32 v2(156.68,91.42)
  TOP w0.102: 154.67,91.09 153.72,90.14 153.53,90.14 153.48,90.19 153.48,90.46 153.37,90.57 CV545.1
  BOTTOM w0.089: v2(156.68,91.42) 156.76,91.42 157.09,91.09 UV1.AL19
PEG_GTX_HRX_P8: length 9.3
  TOP w0.076: 156.04,91.92 156.06,91.9 156.19,91.9 156.3,92 157.77,92 157.95,91.82 158.17,91.82 158.35,92 158.69,92 158.79,91.9 158.79,91.61 158.69,91.51 v2(158.37,91.51)
  TOP w0.102: CV547.1 151.69,91.37 153.68,91.37 154.23,91.92 v4(155.33,91.92) 156.04,91.92
  BOTTOM w0.102: UV1.AK20 157.97,91.91 v2(158.37,91.51)
PEG_GTX_HRX_P9: length 9.1
  TOP w0.076: v2(159.99,91.51) 160.31,91.51 160.39,91.58 160.39,92.13 160.31,92.2 v4(158.06,92.2) 156.19,92.2 156.03,92.36 155.62,92.36 155.6,92.34 155.59,92.34
  TOP w0.102: 155.59,92.34 154.06,92.34 153.9,92.18 153.34,92.18 CV550.1
  BOTTOM w0.102: UV1.AH20 v2(159.99,91.51)
PEG_GTX_HRX_P10: length 8.3
  TOP w0.076: v2(157.48,93.21) 157.5,93.22 157.83,93.22 157.93,93.12 157.93,92.93 157.83,92.83 156.55,92.83 156.15,93.22 156.15,93.25 156.15,93.26
  TOP w0.102: CV552.1 151.69,93.4 151.75,93.4 151.86,93.51 153.04,93.51 153.16,93.4 153.66,93.4 153.69,93.43 154.28,93.43 154.31,93.4 v4(155.38,93.4) 156,93.4 156.15,93.26
  BOTTOM w0.102: v2(157.48,93.21) 157.89,92.8 UV1.AK21
PEG_GTX_HRX_P11: length 5.2
  TOP w0.102: CV558.1 153.34,94.21 154.19,94.21 154.22,94.19 154.82,94.19 154.84,94.21 156.12,94.21 156.22,94.11 156.22,93.7 156.37,93.55 156.55,93.55 156.65,93.65 v2(156.65,94)
  BOTTOM w0.102: UV1.AL22 157.09,93.56 v2(156.65,94)
PEG_GTX_HRX_P12: length 8.1
  TOP w0.076: 155.82,94.96 155.92,94.86 157.46,94.86 157.84,94.48 158.12,94.48 158.33,94.68 v2(158.33,94.73)
  TOP w0.102: 155.82,94.96 v4(155.63,95.15) 155.35,95.43 151.69,95.43 CV560.1
  BOTTOM w0.102: UV1.AK23 158.05,94.41 158.33,94.68 v2(158.33,94.73)
PEG_GTX_HRX_P13: length 9.4
  TOP w0.076: v2(159.99,94.01) 160.31,94.01 160.39,94.09 160.39,94.3 159.58,95.1 156.3,95.1 156,95.4 155.97,95.4 155.96,95.42
  TOP w0.102: CV562.1 153.34,96.25 v4(154.26,96.25) 155.13,96.25 155.96,95.42
  BOTTOM w0.076: UV1.AH23 v2(159.99,94.01)
PEG_GTX_HRX_P14: length 8.4
  TOP w0.076: 156.16,96.23 156.18,96.22 156.2,96.22 156.42,96.01 157.86,96.01 157.96,95.91 157.96,95.74 157.86,95.64 v2(157.52,95.64)
  TOP w0.102: CV564.1 151.69,97.26 153.4,97.26 153.47,97.34 155.06,97.34 v4(155.43,96.97) 156.16,96.23
  BOTTOM w0.076: UV1.AK24 157.89,95.27 v2(157.52,95.64)
PEG_GTX_HRX_P15: length 6.5
  TOP w0.102: v2(156.69,96.57) 157,96.57 157.14,96.71 157.14,97.49 156.89,97.74 156.69,97.74 156.65,97.7 156.03,97.7 156,97.73 155.77,97.73 155.46,98.03 153.91,98.03 153.66,98.28 153.34,98.28 CV566.1
  BOTTOM w0.089: v2(156.69,96.57) 156.75,96.57 157.09,96.22 UV1.AL25
PEG_HTX_C_GRX_N0: length 23.4
  BOTTOM w0.102: CH36.2 136.94,77.94 137.09,77.94 137.5,78.35 138.06,78.35 v4(140.45,80.74) 145.86,86.15 148,86.15 148.02,86.17 148.62,86.17 148.64,86.15 153.32,86.15 153.58,85.89 154.9,85.89 155.23,85.56 155.68,85.56 156.03,85.21 UV1.AM12
PEG_HTX_C_GRX_N1: length 24.8
  BOTTOM w0.102: CH34.2 135.34,78.66 136.12,78.66 136.38,78.92 137.94,78.92 v4(142.63,83.61) 145.6,86.58 145.97,86.58 145.99,86.55 146.59,86.55 146.61,86.58 151.34,86.58 151.35,86.57 153.6,86.57 153.87,86.3 155.17,86.3 155.38,86.5 155.65,86.5 156.06,86.91 UV1.AM14
PEG_HTX_C_GRX_N2: length 21.3
  BOTTOM w0.102: CH32.2 136.93,79.99 137.72,79.99 145.14,87.41 v4(151.9,87.41) 154.59,87.41 154.69,87.51 UV1.AP15
PEG_HTX_C_GRX_N3: length 24.8
  BOTTOM w0.102: UV1.AM15 155.94,87.36 155.34,87.36 155.12,87.58 155.12,87.8 154.85,88.07 150.42,88.07 150.4,88.05 149.8,88.05 149.78,88.07 v4(147.84,88.07) 145.17,88.07 137.88,80.77 135.43,80.77 CH30.2
PEG_HTX_C_GRX_N4: length 23.3
  BOTTOM w0.076: 154.43,88.91 154.44,88.91 154.45,88.89 154.9,88.89 155.14,89.14 155.14,89.55 155.34,89.74 155.96,89.74 UV1.AM17
  BOTTOM w0.102: 154.43,88.91 148.39,88.91 148.39,88.91 147.29,88.91 147.28,88.91 146.23,88.91 146.21,88.93 145.61,88.93 145.58,88.91 144.82,88.91 138.07,82.16 138.04,82.16 137.88,81.99 v4(137.68,81.99) 136.95,81.99 CH28.2
PEG_HTX_C_GRX_N5: length 24.2
  BOTTOM w0.076: 153.01,89.7 153.02,89.7 153.04,89.72 153.44,89.72 154.1,90.38 154.26,90.38 154.33,90.31 154.33,90.05 154.09,89.81 154.09,89.66 154.19,89.56 154.34,89.56 154.69,89.91 UV1.AP18
  BOTTOM w0.102: 153.01,89.7 151.77,89.7 151.74,89.68 151.15,89.68 151.12,89.7 v4(148.55,89.7) 144.87,89.7 137.98,82.81 135.43,82.81 CH26.2
PEG_HTX_C_GRX_N6: length 23.1
  BOTTOM w0.076: UV1.AM18 156.21,90.21 156.1,90.32 156.1,90.51 155.89,90.72 155.27,90.72 154.92,91.07 153.99,91.07 153.97,91.09 153.96,91.09
  BOTTOM w0.102: CH24.2 136.95,84.03 v4(137.7,84.03) 138,84.03 141.23,87.26 141.23,87.3 141.66,87.72 141.69,87.72 145.06,91.09 153.96,91.09
PEG_HTX_C_GRX_N7: length 24.4
  BOTTOM w0.076: UV1.AM20 156.23,91.91 156.1,91.78 156.1,91.6 155.89,91.39 155.1,91.39 155.09,91.38 154.25,91.38 154.03,91.6 153.58,91.6 153.56,91.58 153.55,91.58
  BOTTOM w0.102: CH22.2 135.43,84.84 138.11,84.84 143.57,90.31 143.61,90.31 144.03,90.73 144.03,90.77 144.84,91.57 v4(146.57,91.57) 148.79,91.57 148.8,91.58 153.55,91.58
PEG_HTX_C_GRX_N8: length 20.8
  BOTTOM w0.102: UV1.AP21 154.43,92.45 154.06,92.45 154.02,92.41 v4(148.24,92.41) 144.45,92.41 138.13,86.08 137.56,86.08 137.53,86.06 136.95,86.06 CH20.2
PEG_HTX_C_GRX_N9: length 24
  BOTTOM w0.102: UV1.AM21 156.04,92.71 155.67,93.08 155.22,93.08 155.02,93.28 152.33,93.28 152.3,93.31 151.71,93.31 151.68,93.28 v4(145.2,93.28) 144.41,93.28 138.21,87.09 135.42,87.09 CH18.2
PEG_HTX_C_GRX_N10: length 22.5
  BOTTOM w0.102: UV1.AM23 155.93,94.05 155.43,94.05 155.17,93.79 154.28,93.79 154.08,94 v4(150.28,94) 144.54,94 138.33,87.78 138.1,87.78 138.08,87.76 137.46,87.76 137.44,87.78 136.85,87.78 CH16.2
PEG_HTX_C_GRX_N11: length 22.1
  BOTTOM w0.102: CH14.2 135.42,89.12 138.52,89.12 144.31,94.91 147.79,94.91 147.82,94.94 148.42,94.94 148.44,94.91 v4(152.03,94.91) 154.39,94.91 UV1.AP24
PEG_HTX_C_GRX_N12: length 22.7
  BOTTOM w0.102: UV1.AM24 155.95,94.86 155.35,94.86 155.08,95.13 155.08,95.39 154.8,95.68 150.63,95.68 150.6,95.65 150,95.65 149.98,95.68 v4(145.68,95.68) 144.5,95.68 138.75,89.93 136.97,89.93 CH12.2
PEG_HTX_C_GRX_N13: length 24.1
  BOTTOM w0.102: CH10.2 135.44,91.13 137.53,91.13 137.55,91.15 138.15,91.15 138.18,91.13 138.79,91.13 144.27,96.61 v4(148.04,96.61) 154.11,96.61 154.21,96.51 154.82,96.51 155.09,96.78 155.09,97 155.35,97.25 155.95,97.25 UV1.AM26
PEG_HTX_C_GRX_N14: length 20.4
  BOTTOM w0.102: UV1.AP27 154.36,97.37 152.35,97.37 152.33,97.4 151.73,97.4 151.71,97.37 v4(145.73,97.37) 144.17,97.37 138.96,92.16 136.95,92.16 CH8.2
PEG_HTX_C_GRX_N15: length 23.6
  BOTTOM w0.102: UV1.AM27 155.99,97.71 155.64,98.06 155.5,98.06 155.17,98.39 150.12,98.39 150.09,98.42 149.5,98.42 149.47,98.39 144.27,98.39 139.07,93.18 v4(137.63,93.18) 135.42,93.18 CH6.2
PEG_HTX_C_GRX_P0: length 23.4
  BOTTOM w0.102: CH35.2 136.97,77.74 137.18,77.74 137.58,78.15 138.14,78.15 140.36,80.36 140.4,80.36 140.82,80.79 140.82,80.82 145.94,85.94 v4(148.32,85.94) 153.24,85.94 153.49,85.69 154.81,85.69 155.08,85.43 155.08,84.88 155.18,84.78 155.39,84.78 155.49,84.88 155.49,85.21 UV1.AN12
PEG_HTX_C_GRX_P1: length 24.7
  BOTTOM w0.102: CH33.2 135.52,78.86 136.04,78.86 136.3,79.12 137.86,79.12 142.26,83.52 142.26,83.56 142.68,83.98 142.72,83.98 145.52,86.78 v4(146.29,86.78) 151.43,86.78 151.44,86.77 153.69,86.77 153.96,86.5 155.09,86.5 155.15,86.57 155.15,86.73 155.04,86.85 155.04,87.07 155.12,87.15 155.42,87.15 155.49,87.08 UV1.AN14
PEG_HTX_C_GRX_P2: length 21.3
  BOTTOM w0.102: UV1.AP14 154.32,86.91 154.02,87.21 152.23,87.21 152.2,87.18 151.6,87.18 151.58,87.21 145.22,87.21 137.94,79.93 137.94,79.92 137.78,79.76 v4(137.58,79.76) 136.95,79.76 CH31.2
PEG_HTX_C_GRX_P3: length 24.8
  BOTTOM w0.102: CH29.2 135.43,80.98 137.79,80.98 145.09,88.28 147.51,88.28 147.54,88.3 148.14,88.3 148.16,88.28 v4(150.1,88.28) 154.93,88.28 155.16,88.05 155.34,88.05 155.41,88.12 155.85,88.12 155.95,88.02 155.95,87.81 155.85,87.71 UV1.AN15
PEG_HTX_C_GRX_P4: length 23.2
  BOTTOM w0.076: 154.44,88.7 154.45,88.72 154.96,88.72 155.28,89.04 155.84,89.04 155.94,89.14 155.94,89.46 155.84,89.56 155.65,89.56 UV1.AN17
  BOTTOM w0.102: 154.44,88.7 148.31,88.7 148.3,88.71 147.37,88.71 147.37,88.7 v4(145.91,88.7) 144.91,88.7 138.11,81.91 138.11,81.9 137.98,81.77 136.93,81.77 CH27.2
PEG_HTX_C_GRX_P5: length 24.2
  BOTTOM w0.076: UV1.AP17 155.04,89.76 155.04,90.34 154.84,90.54 154.03,90.54 153.37,89.89 153.04,89.89 153.02,89.91
  BOTTOM w0.102: CH25.2 135.43,83.01 137.89,83.01 144.79,89.91 148.23,89.91 148.25,89.93 148.85,89.93 148.87,89.91 v4(151.44,89.91) 153.02,89.91
PEG_HTX_C_GRX_P6: length 23
  BOTTOM w0.076: 153.96,90.89 153.97,90.89 153.99,90.91 154.85,90.91 155.21,90.55 155.82,90.55 155.93,90.44 155.93,90.3 155.84,90.21 UV1.AN18
  BOTTOM w0.102: 153.96,90.89 145.15,90.89 v4(141.61,87.35) 138.05,83.8 136.93,83.8 CH23.2
PEG_HTX_C_GRX_P7: length 24.4
  BOTTOM w0.076: 153.55,91.78 153.57,91.78 153.59,91.76 154.1,91.76 154.32,91.54 155.02,91.54 155.03,91.55 155.82,91.55 155.93,91.66 155.93,91.81 155.83,91.91 UV1.AN20
  BOTTOM w0.102: CH21.2 135.58,85.26 135.8,85.04 138.02,85.04 v4(143.66,90.68) 144.75,91.77 146.24,91.77 146.27,91.8 146.87,91.8 146.89,91.77 148.71,91.77 148.72,91.78 153.55,91.78
PEG_HTX_C_GRX_P8: length 20.8
  BOTTOM w0.102: UV1.AP20 154.32,91.91 154.02,92.21 148.57,92.21 148.54,92.18 147.95,92.18 147.92,92.21 144.54,92.21 138.19,85.85 v4(137.86,85.85) 136.95,85.85 CH19.2
PEG_HTX_C_GRX_P9: length 24
  BOTTOM w0.102: CH17.2 135.44,86.88 138.3,86.88 144.49,93.08 144.87,93.08 144.9,93.06 145.49,93.06 145.52,93.08 v4(152,93.08) 154.93,93.08 155.08,92.93 155.08,92.37 155.18,92.27 155.39,92.27 155.49,92.37 UV1.AN21
PEG_HTX_C_GRX_P10: length 22.5
  BOTTOM w0.102: CH15.2 137.06,87.99 v4(137.78,87.99) 138.25,87.99 144.46,94.2 149.95,94.2 149.98,94.22 150.57,94.22 150.6,94.2 154.16,94.2 154.37,94 155.09,94 155.19,94.09 155.19,94.18 155.03,94.33 155.03,94.57 155.12,94.65 155.4,94.65 155.49,94.56 UV1.AN23
PEG_HTX_C_GRX_P11: length 22.1
  BOTTOM w0.102: UV1.AP23 154.39,94.71 152.35,94.71 152.33,94.68 151.73,94.68 151.71,94.71 v4(148.12,94.71) 144.39,94.71 138.6,88.92 135.44,88.92 CH13.2
PEG_HTX_C_GRX_P12: length 22.7
  BOTTOM w0.102: CH11.2 136.94,90.13 138.67,90.13 144.41,95.88 145.36,95.88 145.38,95.91 145.98,95.91 146,95.88 v4(150.3,95.88) 154.88,95.88 155.17,95.59 155.33,95.59 155.42,95.69 155.84,95.69 155.97,95.56 155.97,95.34 155.84,95.21 UV1.AN24
PEG_HTX_C_GRX_P13: length 24.1
  BOTTOM w0.102: UV1.AN26 155.81,96.91 155.94,96.78 155.94,96.54 155.81,96.41 155.51,96.41 155.38,96.54 155.14,96.54 154.9,96.3 154.13,96.3 154.02,96.4 148.36,96.4 148.34,96.38 147.74,96.38 147.72,96.4 144.35,96.4 138.87,90.92 v4(137.86,90.92) 135.42,90.92 CH9.2
PEG_HTX_C_GRX_P14: length 20.3
  BOTTOM w0.102: UV1.AP26 154.43,97.17 v4(152.03,97.17) 146.05,97.17 146.03,97.15 145.43,97.15 145.41,97.17 144.26,97.17 139.05,91.96 136.96,91.96 CH7.2
PEG_HTX_C_GRX_P15: length 23.6
  BOTTOM w0.102: CH5.2 135.58,92.75 135.81,92.98 137.3,92.98 137.33,92.95 137.93,92.95 137.95,92.98 139.15,92.98 144.36,98.19 v4(149.79,98.19) 155.09,98.19 155.23,98.04 155.23,97.98 155.04,97.8 155.04,97.55 155.13,97.46 155.41,97.46 155.49,97.54 UV1.AN27
PEG_HTX_GRX_N0: length 10.2
  BOTTOM w0.076: 129.18,79.24 129.16,79.24 129.14,79.22 128.6,79.22 128.5,79.33 127.29,79.33 127.2,79.41 127.2,79.54 127.29,79.63 UH1.B10
  BOTTOM w0.102: CH36.1 135.95,77.94 135.02,77.94 134.99,77.91 134.87,77.91 134.77,78.02 133.48,78.02 132.26,79.24 v4(130.34,79.24) 129.18,79.24
PEG_HTX_GRX_N1: length 8
  BOTTOM w0.076: 129.01,79.98 128.99,79.98 128.97,80 128.61,80 128.55,79.94 127.89,79.94 127.69,80.13 127.69,80.29 127.57,80.41 UH1.B11
  BOTTOM w0.102: CH34.1 134.41,78.74 v4(133.79,78.74) 133.54,78.74 132.82,79.46 132.79,79.46 132.27,79.98 129.01,79.98
PEG_HTX_GRX_N2: length 10
  BOTTOM w0.076: UH1.B12 127.29,81.2 127.2,81.11 127.2,80.99 127.29,80.9 128.5,80.9 128.6,80.8 129,80.8 129.02,80.82 129.04,80.82
  BOTTOM w0.102: 129.04,80.82 v4(130.21,80.82) 131.33,80.82 131.36,80.84 131.96,80.84 131.98,80.82 132.77,80.82 133.63,79.96 135.94,79.96 CH32.1
PEG_HTX_GRX_N3: length 7.8
  BOTTOM w0.076: 129.34,81.56 129.32,81.56 129.3,81.57 128.61,81.57 128.54,81.5 127.89,81.5 127.69,81.71 127.69,81.87 127.57,81.99 UH1.B13
  BOTTOM w0.102: CH30.1 134.39,80.8 133.65,80.8 v4(133.47,80.98) 132.91,81.54 132.74,81.54 132.72,81.51 132.1,81.51 132.07,81.54 130.68,81.54 130.67,81.56 129.34,81.56
PEG_HTX_GRX_N4: length 9.8
  BOTTOM w0.076: 129.45,82.38 129.43,82.38 129.41,82.36 128.59,82.36 128.48,82.48 127.29,82.48 127.2,82.56 127.2,82.69 127.29,82.78 UH1.B14
  BOTTOM w0.102: 129.45,82.38 129.6,82.38 129.63,82.4 130.17,82.4 130.2,82.38 v4(131.23,82.38) 133.47,82.38 133.86,81.99 135.94,81.99 CH28.1
PEG_HTX_GRX_N5: length 7.7
  BOTTOM w0.076: UH1.B15 127.57,83.56 127.69,83.44 127.69,83.28 127.9,83.07 128.48,83.07 128.64,83.23 129.12,83.23 129.14,83.21 129.16,83.21
  BOTTOM w0.102: 129.16,83.21 133.52,83.21 v4(133.72,83.01) 133.89,82.84 133.89,82.84 134.38,82.84 CH26.1
PEG_HTX_GRX_N6: length 9.7
  BOTTOM w0.076: 129.11,83.97 129.09,83.97 129.07,83.95 128.6,83.95 128.53,84.03 127.32,84.03 127.2,84.14 127.2,84.26 127.29,84.35 UH1.B16
  BOTTOM w0.102: 129.11,83.97 130.05,83.97 130.15,84.06 130.57,84.06 130.59,84.09 131.21,84.09 131.24,84.06 v4(132.97,84.06) 133.94,84.06 133.98,84.03 135.94,84.03 CH24.1
PEG_HTX_GRX_N7: length 7.6
  BOTTOM w0.076: UH1.B17 127.57,85.14 127.69,85.02 127.69,84.86 127.9,84.65 128.46,84.65 128.56,84.75 129.18,84.75 129.19,84.73 129.21,84.73
  BOTTOM w0.102: CH22.1 134.41,84.84 133.63,84.84 133.52,84.73 130.98,84.73 130.98,84.73 130.39,84.73 130.36,84.71 129.66,84.71 129.63,84.73 129.21,84.73
PEG_HTX_GRX_N8: length 10
  BOTTOM w0.076: 129.42,85.56 129.4,85.56 129.38,85.55 128.69,85.55 128.6,85.63 128.1,85.63 127.89,85.84 127.89,85.99 127.67,86.21 127.19,86.21 UH1.C18
  BOTTOM w0.102: 129.42,85.56 v4(131.53,85.56) 132.82,85.56 133.17,85.92 133.18,85.92 133.32,86.06 135.57,86.06 135.79,86.27 CH20.1
PEG_HTX_GRX_N9: length 7.7
  BOTTOM w0.076: 129.21,86.55 129.19,86.55 129.18,86.53 128.61,86.53 128.49,86.41 127.94,86.41 127.85,86.5 127.85,86.63 127.94,86.71 UH1.A19
  BOTTOM w0.102: CH18.1 134.41,87.07 133.27,87.07 v4(133.06,86.86) 132.74,86.55 130.64,86.55 130.61,86.57 130.01,86.57 129.99,86.55 129.21,86.55
PEG_HTX_GRX_N10: length 10
  BOTTOM w0.076: 129.04,86.99 129.02,86.99 129,87.01 127.25,87.01 127.04,87.22 127.04,87.38 126.92,87.5 UH1.C20
  BOTTOM w0.102: CH16.1 135.94,87.89 v4(133.82,87.89) 133.08,87.89 132.43,87.24 131.85,87.24 131.83,87.21 131.23,87.21 131.21,87.24 130.26,87.24 130.01,86.99 129.04,86.99
PEG_HTX_GRX_N11: length 7.9
  BOTTOM w0.076: UH1.A21 127.94,88.29 127.85,88.2 127.85,88.08 127.97,87.96 128.39,87.96 128.57,88.14 129.68,88.14 129.7,88.16 129.72,88.16
  BOTTOM w0.102: 129.72,88.16 v4(130.31,88.16) 132.03,88.16 132.35,88.48 132.35,88.51 132.86,89.02 132.9,89.02 132.96,89.09 134.4,89.09 CH14.1
PEG_HTX_GRX_N12: length 10.3
  BOTTOM w0.076: UH1.C22 126.92,89.08 127.04,88.95 127.04,88.8 127.22,88.61 128.46,88.61 128.53,88.53 129.28,88.53 129.3,88.51 129.31,88.51
  BOTTOM w0.102: CH12.1 135.94,89.92 133.94,89.92 133.91,89.89 133.32,89.89 133.29,89.92 133.05,89.92 132.07,88.94 v4(131.4,88.94) 129.98,88.94 129.56,88.51 129.31,88.51
