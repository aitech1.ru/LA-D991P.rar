# Allegro board Dell Inspiron 15 Gaming 7566 Compal LA-D991P BCV00 Rev1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D59: length 71.4
  IN1 w0.076: 125.03,77.28 124.9,77.41 124.9,77.64 124.62,77.92 124.27,77.92 124.19,77.84 123.8,77.84 123.3,78.35 122.59,78.35 v2(122.3,78.06)
  IN1 w0.114: v2(134.38,22.72) 134.38,24.64 134.78,25.05 134.78,26.21 136.44,27.87 136.44,31.7 137.8,33.07 137.8,35.02 139.33,36.55 139.33,37.45 137.8,38.99 137.8,40.39 135.92,42.27 135.92,54.32 134.82,55.43 134.82,66.51 134.51,66.81 134.51,70.64 130.13,75.02 130.13,75.24 128.09,77.28 125.03,77.28
  BOTTOM w0.102: v2(122.3,78.06) 122.3,78.06 122.23,77.99 122.16,77.99 UH1.L7 ; JDIMM2.250 134.91,22.19 v2(134.38,22.72)
DDR_B_D60: length 71.4
  IN1 w0.076: 126.03,74.3 125.03,75.3 124.79,75.3 124.21,75.89 123.64,75.89 122.5,77.02 122.02,77.02 122,77 121.26,77 121.03,77.23 121.03,79.36 121.22,79.55 121.22,79.7 v2(121.43,79.92)
  IN1 w0.114: 126.03,74.3 127.13,74.3 127.84,73.59 128.04,73.59 132.21,69.42 132.21,65.85 132.51,65.55 132.51,45.89 133,45.4 133,41.55 134.71,39.83 134.71,33.27 133.94,32.49 133.94,28.74 133.23,28.04 133,28.04 132.81,28.22 132.65,28.22 132.37,27.94 132.37,27.78 132.55,27.6 132.55,27.44 132.27,27.15 132.27,24.25 132.38,24.14 v2(132.7,24.14)
  BOTTOM w0.089: UH1.M10 121.3,79.92 v2(121.43,79.92)
  BOTTOM w0.102: v2(132.7,24.14) 130.59,22.03 130.59,21.12 130.41,20.94 JDIMM2.232
DDR_B_D61: length 71.5
  IN1 w0.076: 125.56,75.81 124.75,75.81 124.34,76.22 123.78,76.22 122.64,77.35 121.96,77.35 121.44,77.88 121.44,77.94 v2(121.41,77.97)
  IN1 w0.114: v2(132.7,25.41) 133.12,25.84 133.12,27.03 134.57,28.48 134.57,32.22 136.14,33.79 136.14,39.69 134.03,41.8 134.03,45.37 134.16,45.49 134.16,49.85 134.04,49.96 133.32,49.96 133.21,50.08 133.21,50.47 133.32,50.59 134.04,50.59 134.16,50.7 134.16,51.09 134.04,51.21 133.32,51.21 133.21,51.32 133.21,51.72 133.32,51.83 134.04,51.83 134.16,51.95 134.16,52.34 134.04,52.45 133.32,52.45 133.21,52.57 133.21,52.96 133.32,53.08 133.84,53.08 133.95,53.19 133.95,53.58 133.84,53.7 133.32,53.7 133.15,53.87 133.15,65.81 132.84,66.12 132.84,69.77 127.06,75.56 125.82,75.56 125.56,75.81
  BOTTOM w0.089: v2(121.41,77.97) 121.31,77.97 UH1.M8
  BOTTOM w0.102: v2(132.7,25.41) 132.7,25.46 131.56,26.6 131.08,26.6 130.66,27.02 JDIMM2.233
DDR_B_D62: length 71.8
  IN1 w0.076: v2(122.32,79.92) 123.4,78.84 126.28,78.84 126.32,78.88
  IN1 w0.114: 126.32,78.88 127.39,78.88 130.78,75.49 130.78,75.27 135.15,70.9 135.15,67.07 135.45,66.78 135.45,55.7 136.56,54.59 136.56,42.54 138.43,40.66 138.43,39.25 139.97,37.71 139.97,36.28 139.28,35.59 139.28,33.49 138.55,32.76 138.55,31.53 137.37,30.35 137.37,27.9 135.42,25.95 135.42,24.64 v2(135.36,24.58)
  BOTTOM w0.089: UH1.L10 122.22,79.92 v2(122.32,79.92)
  BOTTOM w0.102: v2(135.36,24.58) 133.66,26.29 JDIMM2.245
DDR_B_D63: length 71.9
  IN1 w0.076: 126.2,78.02 125.03,78.02 124.9,78.15 124.22,78.15 124.09,78.02 123.86,78.02 123.37,78.51 122.47,78.51 v2(122.34,78.65)
  IN1 w0.114: v2(134.38,21.45) 134.83,21.9 134.83,24.64 135.1,24.92 135.1,26.08 136.75,27.74 136.75,31.57 138.96,33.78 138.96,35.72 139.65,36.41 139.65,37.58 138.11,39.12 138.11,40.53 136.23,42.41 136.23,54.46 135.13,55.56 135.13,66.64 134.83,66.94 134.83,70.77 130.46,75.14 130.46,75.36 127.8,78.02 126.2,78.02
  BOTTOM w0.102: JDIMM2.246 133.91,21.11 134.25,21.45 v2(134.38,21.45) ; v2(122.34,78.65) 122.31,78.62 122.19,78.62 UH1.L8
DDR_B_DQS0: length 73.2
  IN1 w0.076: v2(88.55,79.79) 88.7,79.64 88.7,79.44 88.63,79.37 88.33,79.37 88.32,79.37 88.3,79.37
  IN1 w0.091: 88.3,79.37 88.28,79.37 87.91,79.74 85.99,79.74 83.66,77.41 83.66,69.03 81.46,66.83 80.31,66.83 79.96,67.18 79.68,67.18 79.28,66.78 79.28,66.5 79.84,65.94 79.84,65.81 79.54,65.52 79.41,65.52 78.79,66.14 78.52,66.14 78.11,65.74 78.11,65.46 78.73,64.84 78.73,64.71 74.85,60.83 74.85,56.17 74.24,55.56 74.24,46.03 72.24,44.03 72.24,42.47 72.44,42.28 72.49,42.28 72.58,42.18 72.58,41.77 72.49,41.68 72.44,41.68 72.24,41.48 72.24,40.91 72.44,40.72 72.49,40.72 72.58,40.62 72.58,40.21 72.49,40.12 72.44,40.12 72.24,39.92 72.24,36.16 72.44,35.97 72.47,35.97 72.56,35.88 72.56,35.46 72.47,35.37 72.44,35.37 72.24,35.17 72.24,33.76 72.44,33.56 72.48,33.56 72.57,33.47 72.57,33.05 72.48,32.96 72.44,32.96 72.24,32.76 72.24,30.04 72.44,29.85 72.49,29.85 72.58,29.76 72.58,29.34 72.49,29.25 72.44,29.25 72.24,29.05 72.24,28.49 72.44,28.29 72.49,28.29 72.58,28.2 72.58,27.78 72.49,27.69 72.44,27.69 72.24,27.49 72.24,27.17 72.16,27.08 72.16,26.03 72.35,25.84 72.51,25.84 v2(72.81,25.54)
  BOTTOM w0.089: JDIMM2.13 73.66,27.15 73.61,27.1 73.61,26.02 73.34,25.74 73.02,25.74 v2(72.81,25.54) ; UH1.BR9 v2(88.55,79.79)
DDR_B_DQS1: length 68.3
  IN1 w0.076: v2(91.33,79.27) 91.24,79.36 91.13,79.36 91.03,79.26 91.03,78.75 91.08,78.7 91.08,77.76 89.66,76.34 89.66,75.29 88.58,74.22 88.58,74.12
  IN1 w0.091: v2(78.38,22.96) 78.38,22.95 78.54,22.79 78.54,22.64 78.45,22.55 78.08,22.55 77.92,22.71 77.92,23.29 78.01,23.37 78.01,26.39 77.91,26.48 77.91,26.86 78.62,27.57 78.62,33.89 78.1,34.41 78.1,39.81 78.57,40.28 78.57,44 79.18,44.62 79.18,57.72 87.95,66.49 87.95,69.37 88.58,70 88.58,74.12
  BOTTOM w0.076: v2(91.33,79.27) 91.33,79.03 91.47,78.88 91.65,78.88 UH1.BJ9
  BOTTOM w0.089: JDIMM2.34 78.91,20.76 78.75,20.92 78.75,21.07 78.96,21.28 78.96,22.42 78.72,22.66 78.47,22.66 78.38,22.75 v2(78.38,22.96)
DDR_B_DQS2: length 67.5
  IN1 w0.076: v2(94.89,79.27) 94.6,79.27 94.53,79.19 94.53,77.65 93.37,76.49 93.37,71.87 93.05,71.55 93.05,69.57 92.76,69.28 92.76,69.04 92.77,69.04 92.77,69.02
  IN1 w0.091: v2(84.58,23.78) 84.58,23.5 84.48,23.41 84.28,23.42 84.17,23.52 84.17,24.71 84.59,25.13 84.59,32.62 84.33,32.88 84.33,48.32 84.59,48.58 84.59,56.8 92.77,64.97 92.77,69.02
  BOTTOM w0.076: v2(94.89,79.27) 94.55,79.27 94.46,79.18 UH1.BF9
  BOTTOM w0.089: v2(84.58,23.78) 84.58,23.6 84.4,23.42 84.16,23.42 84.07,23.51 84.07,27.28 84.16,27.37 JDIMM2.55
DDR_B_DQS3: length 65.5
  IN1 w0.076: 96.85,65.96 96.84,65.96 96.84,66.51 96.87,66.53 96.87,75.6 97.58,76.32 97.58,77.49 97.29,77.79 97.29,78.9 v2(97.66,79.27)
  IN1 w0.091: 96.85,65.96 96.85,63.28 90.27,56.7 90.27,46.2 89.6,45.53 89.6,40.29 88.93,39.63 88.93,33 89.27,32.66 89.27,25.07 90.48,23.86 90.48,22.92 90.25,22.68 90.04,22.68 v2(89.84,22.48)
  BOTTOM w0.089: v2(89.84,22.48) 89.68,22.64 89.47,22.64 89.25,22.43 89.25,21.15 89.41,20.99 JDIMM2.76 ; UH1.BB9 97.53,79.27 v2(97.66,79.27)
DDR_B_DQS4: length 65.6
  IN1 w0.076: v2(114.12,79.27) 113.84,79.27 113.74,79.17 113.74,77.79 113.95,77.58 113.95,71.57 120.26,65.26 120.78,65.26 121.08,64.96 121.09,64.96 121.1,64.95
  IN1 w0.091: 121.1,64.95 121.42,64.62 121.42,47.98 118.76,45.31 118.76,39.31 119.03,39.04 119.03,33.87 118.03,32.87 118.03,32.33 118.12,32.24 118.13,32.24 118.33,32.04 118.33,31.66 118.42,31.56 118.69,31.56 118.88,31.37 118.88,30.8 118.69,30.6 118.42,30.6 118.33,30.51 118.33,30.1 118.42,30.01 118.57,30.01 118.76,29.81 118.76,29.24 118.57,29.05 118.42,29.05 118.33,28.95 118.33,28.12 118.01,27.81 118.01,25.86 118.22,25.65 118.41,25.65 118.5,25.74 v2(118.5,26)
  BOTTOM w0.089: UH1.AA9 113.99,79.27 v2(114.12,79.27) ; v2(118.5,26) 118.5,25.74 118.41,25.65 118.2,25.65 116.98,26.87 116.98,27.22 117.16,27.39 JDIMM2.179
DDR_B_DQS5: length 67.9
  IN1 w0.076: 122.29,69.46 122.28,69.46 122.27,69.45 120.73,69.45 118.31,71.86 117.82,71.86 116.55,73.13 116.55,77.18 116.34,77.39 116.34,78.79 116.24,78.89 116.07,78.89 115.94,78.76 v2(115.94,78.68)
  IN1 w0.091: 122.29,69.46 122.37,69.46 125.42,66.41 125.42,62.94 125.69,62.67 125.69,42.3 125.33,41.95 125.33,34.71 124.07,33.45 124.07,30.31 123.57,29.81 123.57,24.96 123.43,24.81 123.43,23.68 123.43,23.67 123.43,23.65 123.57,23.51 123.62,23.46 123.68,23.46 v2(124.03,23.11)
  BOTTOM w0.076: v2(115.94,78.68) 116.21,78.95 UH1.V9
  BOTTOM w0.089: v2(124.03,23.11) 124.03,23.36 123.94,23.45 123.71,23.45 123.45,23.19 123.45,22.57 122.25,21.37 122.25,21.15 122.41,20.99 JDIMM2.200
DDR_B_DQS6: length 68.5
  IN1 w0.076: v2(119.61,79.27) 119.34,79.27 119.26,79.19 119.26,75.25 119.54,74.97 120.38,74.97 120.47,74.88 120.6,74.88 123.2,72.28 123.35,72.28 124.47,71.16 124.85,71.16 125.33,71.64 125.55,71.64 125.55,71.65 125.57,71.65
  IN1 w0.091: 125.57,71.65 126.19,71.65 126.81,71.03 126.97,71.03 129.68,68.33 129.68,64.81 129.95,64.54 129.95,40.97 131.3,39.62 131.3,35.34 130.48,34.52 130.48,31.45 129.66,30.62 129.66,28.96 129.06,28.36 129.06,25.36 129.24,25.17 129.42,25.17 129.57,25.33 v2(129.57,25.49)
  BOTTOM w0.089: v2(119.61,79.27) 119.27,79.27 119.15,79.15 UH1.P9 ; v2(129.57,25.49) 129.57,25.3 129.45,25.18 129.1,25.18 127.5,26.78 127.5,26.99 127.66,27.15 JDIMM2.221
DDR_B_DQS7: length 71.7
  IN1 w0.076: 126.61,76.48 126.59,76.48 126.58,76.47 124.81,76.47 123.75,77.54 122.98,77.54 122.81,77.7 122.1,77.7 121.95,77.86 121.95,78.76 121.73,78.98 121.53,78.98 121.42,79.08 v2(121.42,79.24)
  IN1 w0.091: v2(132.94,22.27) 133.16,22.49 133.39,22.49 133.59,22.69 133.59,24.92 134.05,25.37 134.05,26.56 135.49,28 135.49,31.82 137.06,33.39 137.06,40.09 135.16,41.98 135.16,53.69 134.07,54.79 134.07,66.2 133.76,66.5 133.76,70.3 129.32,74.74 129.32,74.97 127.82,76.48 126.61,76.48
  BOTTOM w0.089: JDIMM2.242 132.91,20.77 132.76,20.92 132.76,21.14 132.51,21.39 132.51,22.37 132.6,22.46 132.76,22.46 v2(132.94,22.27) ; UH1.L9 121.71,78.95 v2(121.42,79.24)
DDR_B_DQS#0: length 73.1
  IN1 w0.076: 88.3,79.19 88.32,79.19 88.33,79.2 88.69,79.2 88.87,79.37 88.87,79.62 89.04,79.79 v2(89.2,79.79)
  IN1 w0.091: 88.3,79.19 88.2,79.19 87.83,79.56 86.07,79.56 83.84,77.33 83.84,68.96 81.53,66.65 80.24,66.65 79.89,67 79.76,67 79.46,66.7 79.46,66.58 80.02,66.02 80.02,65.74 79.62,65.34 79.34,65.34 78.72,65.96 78.59,65.96 78.3,65.66 78.3,65.54 78.92,64.92 78.92,64.64 75.03,60.75 75.03,56.1 74.42,55.49 74.42,45.95 72.43,43.95 72.43,42.55 72.52,42.46 72.57,42.46 72.76,42.26 72.76,41.69 72.57,41.5 72.52,41.5 72.43,41.4 72.43,40.99 72.52,40.9 72.57,40.9 72.76,40.7 72.76,40.13 72.57,39.94 72.52,39.94 72.43,39.84 72.43,36.24 72.52,36.15 72.55,36.15 72.74,35.95 72.74,35.38 72.55,35.19 72.52,35.19 72.43,35.1 72.43,33.83 72.52,33.74 72.55,33.74 72.75,33.54 72.75,32.98 72.55,32.78 72.52,32.78 72.43,32.69 72.43,30.12 72.52,30.03 72.57,30.03 72.76,29.83 72.76,29.27 72.57,29.07 72.52,29.07 72.43,28.98 72.43,28.56 72.52,28.47 72.57,28.47 72.76,28.27 72.76,27.71 72.57,27.51 72.52,27.51 72.43,27.42 72.43,27.09 72.34,27.01 72.34,26.11 72.43,26.02 72.56,26.02 v2(72.81,26.27)
  BOTTOM w0.089: UH1.BP9 89.04,79.41 89.22,79.63 v2(89.2,79.79) ; JDIMM2.11 73.16,27.15 73.43,26.88 73.43,26.09 73.26,25.93 72.92,25.93 72.81,26.03 v2(72.81,26.27)
DDR_B_DQS#1: length 68.2
  IN1 w0.076: v2(91.29,79.92) 91.29,79.75 90.86,79.33 90.86,78.68 90.91,78.63 90.91,77.83 89.49,76.41 89.49,75.36 88.41,74.28 88.41,74.2 88.41,74.19 88.41,74.14 88.4,74.13 88.4,74.12
  IN1 w0.091: 88.4,74.12 88.4,70.08 87.77,69.45 87.77,66.56 79,57.79 79,44.69 78.39,44.08 78.39,40.35 77.92,39.88 77.92,34.34 78.44,33.81 78.44,27.64 77.73,26.93 77.73,26.41 77.83,26.31 77.83,23.45 77.74,23.36 77.74,22.64 78.01,22.37 78.16,22.37 v2(78.36,22.15)
  BOTTOM w0.076: UH1.BL9 v2(91.29,79.92)
  BOTTOM w0.089: v2(78.36,22.15) 78.36,22.34 78.5,22.47 78.64,22.47 78.78,22.34 78.78,21.36 78.57,21.15 78.57,20.89 78.41,20.73 JDIMM2.32
DDR_B_DQS#2: length 67.5
  IN1 w0.076: v2(94,79.27) 94.36,78.91 94.36,77.72 93.2,76.55 93.2,71.94 92.88,71.62 92.88,69.63 92.6,69.35 92.6,69.04 92.59,69.04 92.59,69.02
  IN1 w0.091: v2(84.57,23.01) 84.35,23.24 84.2,23.24 83.99,23.45 83.99,24.79 84.41,25.2 84.41,32.55 84.15,32.8 84.15,48.4 84.41,48.66 84.41,56.87 92.59,65.05 92.59,69.02
  BOTTOM w0.089: JDIMM2.53 83.66,27.34 83.88,27.11 83.88,23.44 84.09,23.23 84.34,23.23 v2(84.57,23.01) ; v2(94,79.27) 93.87,79.27 UH1.BG9
DDR_B_DQS#3: length 65.6
  IN1 w0.076: 96.67,65.96 96.67,65.97 96.68,65.97 96.68,66.58 96.7,66.6 96.7,75.67 97.42,76.39 97.42,77.42 97.12,77.72 97.12,78.9 v2(96.75,79.27)
  IN1 w0.091: v2(89.84,23.07) 90.04,22.86 90.17,22.86 90.3,23 90.3,23.79 89.09,25 89.09,32.58 88.75,32.92 88.75,39.7 89.42,40.37 89.42,45.61 90.09,46.28 90.09,56.77 96.67,63.36 96.67,65.96
  BOTTOM w0.089: UH1.BC9 96.61,79.27 v2(96.75,79.27) ; v2(89.84,23.07) 89.6,22.83 89.39,22.83 89.07,22.5 89.07,21.15 88.91,20.99 JDIMM2.74
DDR_B_DQS#4: length 65.6
  IN1 w0.076: 120.97,64.82 120.96,64.83 120.96,64.84 120.71,65.1 120.19,65.1 113.79,71.5 113.79,77.51 113.57,77.72 113.57,78.99 113.29,79.27 v2(113.21,79.27)
  IN1 w0.091: 120.97,64.82 121.24,64.55 121.24,48.05 118.58,45.38 118.58,39.23 118.85,38.96 118.85,33.95 117.85,32.95 117.85,32.26 118.05,32.06 118.06,32.06 118.15,31.97 118.15,31.58 118.34,31.38 118.61,31.38 118.7,31.29 118.7,30.88 118.61,30.79 118.34,30.79 118.15,30.59 118.15,30.02 118.34,29.82 118.49,29.82 118.58,29.73 118.58,29.32 118.49,29.23 118.34,29.23 118.15,29.03 118.15,28.2 117.83,27.88 117.83,25.79 118.15,25.47 118.28,25.47 v2(118.5,25.25)
  BOTTOM w0.089: UH1.AC9 113.07,79.27 v2(113.21,79.27) ; v2(118.5,25.25) 118.28,25.47 118.13,25.47 116.8,26.8 116.8,27.22 116.66,27.36 JDIMM2.177
DDR_B_DQS#5: length 68
  IN1 w0.076: v2(115.96,79.28) 115.96,79.16 116.06,79.05 116.31,79.05 116.5,78.86 116.5,77.46 116.72,77.25 116.72,73.2 117.89,72.03 118.38,72.03 120.79,69.61 122.2,69.61 122.22,69.64
  IN1 w0.091: v2(124.03,23.86) 123.81,23.64 123.69,23.64 123.61,23.73 123.61,24.74 123.75,24.88 123.75,29.74 124.25,30.24 124.25,33.38 125.51,34.64 125.51,41.87 125.87,42.22 125.87,62.74 125.6,63.01 125.6,66.48 122.44,69.64 122.22,69.64
  BOTTOM w0.089: UH1.W9 115.63,78.95 v2(115.96,79.28) ; JDIMM2.198 121.91,20.99 122.07,21.15 122.07,21.45 123.27,22.65 123.27,23.26 123.63,23.63 123.8,23.63 v2(124.03,23.86)
DDR_B_DQS#6: length 68.6
  IN1 w0.076: 125.57,71.47 125.55,71.47 125.55,71.48 125.4,71.48 124.92,71 124.4,71 123.28,72.11 123.13,72.11 120.53,74.72 120.4,74.72 120.31,74.81 119.47,74.81 119.1,75.18 119.1,78.87 v2(118.69,79.27)
  IN1 w0.091: v2(129.58,24.8) 129.39,24.99 129.17,24.99 128.88,25.28 128.88,28.44 129.48,29.03 129.48,30.7 130.3,31.52 130.3,34.6 131.12,35.41 131.12,39.55 129.77,40.89 129.77,64.46 129.5,64.73 129.5,68.25 126.9,70.85 126.73,70.85 126.11,71.47 125.57,71.47
  BOTTOM w0.089: v2(118.69,79.27) 118.56,79.27 UH1.R9 ; v2(129.58,24.8) 129.38,25 129.02,25 127.32,26.7 127.32,26.99 127.16,27.15 JDIMM2.219
DDR_B_DQS#7: length 71.8
  IN1 w0.076: v2(121.39,78.56) 121.39,78.7 121.49,78.81 121.66,78.81 121.78,78.69 121.78,77.79 122.03,77.54 122.74,77.54 122.91,77.37 123.68,77.37 124.75,76.3 126.59,76.3 126.6,76.3 126.61,76.3
  IN1 w0.091: v2(132.93,22.98) 132.93,22.83 133.09,22.67 133.31,22.67 133.41,22.77 133.41,25 133.86,25.45 133.86,26.63 135.31,28.08 135.31,31.89 136.88,33.46 136.88,40.01 134.98,41.91 134.98,53.62 133.89,54.71 133.89,66.12 133.58,66.42 133.58,70.23 129.14,74.66 129.14,74.89 127.74,76.3 126.61,76.3
  BOTTOM w0.089: UH1.M9 121,78.95 v2(121.39,78.56) ; JDIMM2.240 132.41,20.76 132.57,20.92 132.57,21.07 132.32,21.32 132.32,22.44 132.52,22.64 132.79,22.64 132.93,22.78 v2(132.93,22.98)
DDR_B_MA0: length 70
  IN1 w0.076: 108.81,65.05 108.41,65.45 108.41,73.34 108.02,73.73 108.02,77.08 107.29,77.81 107.29,78.84 v2(107.72,79.27)
  IN1 w0.193: 108.81,65.05 109.69,64.17 109.69,52.96 106.73,49.99 106.73,34.3 106.56,34.14 106.56,28.74 106.69,28.61 106.83,28.48 106.83,27.61 107.5,26.94 107.5,24.69 107.31,24.5 107.15,24.5 106.96,24.3 106.96,23.92 107.15,23.72 107.68,23.72 107.88,23.53 107.88,23.14 107.68,22.95 107.15,22.95 106.96,22.76 106.96,22.37 107.15,22.18 107.31,22.18 107.5,21.99 107.5,21.68 107.75,21.44 108.32,21.44 108.51,21.63 108.51,22.56 108.71,22.75 v2(109,22.75)
  BOTTOM w0.076: v2(107.72,79.27) 107.59,79.27 UH1.AJ9
  BOTTOM w0.17: JDIMM2.144 106.41,20.85 108.3,22.75 v2(109,22.75)
DDR_B_MA1: length 68.4
  IN1 w0.076: 107.13,63.41 105.51,65.03 105.51,73.78 105.66,73.93 105.66,75.41 105.89,75.64 105.89,76.31 v2(106.25,76.68)
  IN1 w0.193: v2(103.87,23.22) 104.4,22.7 104.67,22.7 105.05,23.08 105.05,23.35 104.3,24.1 104.3,27.52 103.1,28.72 103.1,40.02 102.9,40.23 102.9,40.65 103.17,40.92 103.9,40.92 104.1,41.12 104.1,41.56 103.9,41.76 103.33,41.76 103.14,41.95 103.14,42.52 103.33,42.71 103.9,42.71 104.1,42.9 104.1,44.67 103.9,44.86 103.32,44.86 103.13,45.06 103.13,46.02 103.32,46.22 103.9,46.22 104.1,46.41 104.1,53.26 107.13,56.29 107.13,57.09 106.9,57.32 106.9,58.12 107.13,58.35 107.13,63.41
  BOTTOM w0.076: v2(106.25,76.68) 106.39,76.68 UH1.AK6
  BOTTOM w0.17: JDIMM2.133 103.66,25.59 104.43,24.82 104.43,23.78 v2(103.87,23.22)
DDR_B_MA2: length 68.9
  IN1 w0.076: v2(106.28,76.02) 106.29,76 106.29,75.86 106.29,75.85 106.29,75.75 106.03,75.49 106.03,73.66 105.89,73.52 105.89,65.16 107.63,63.43
  IN1 w0.193: 107.63,63.43 107.63,56.09 106.88,55.34 106.88,55.07 107.62,54.33 107.62,54.06 107.35,53.79 107.07,53.79 106.34,54.52 106.06,54.52 105.79,54.25 105.79,53.98 106.73,53.04 106.73,52.77 106.45,52.5 106.18,52.5 105.25,53.43 104.97,53.43 104.59,53.05 104.59,52.28 104.79,52.08 105.17,52.08 105.36,51.89 105.36,51.5 105.17,51.31 104.79,51.31 104.59,51.11 104.59,46.1 104.4,45.91 104.35,45.91 104.15,45.72 104.15,45.33 104.35,45.14 104.4,45.14 104.59,44.94 104.59,40.91 103.61,39.93 103.61,38.99 103.8,38.8 104.05,38.8 104.25,38.61 104.25,34.63 103.68,34.07 103.68,33.57 104.05,33.2 104.05,32.8 103.68,32.43 103.68,28.84 104.8,27.73 104.8,24.31 105.18,23.92 v2(105.63,23.92)
  BOTTOM w0.076: UH1.AK5 106.6,76.34 106.28,76.02 v2(106.28,76.02)
  BOTTOM w0.17: JDIMM2.132 103.41,21.7 v2(105.63,23.92)
DDR_B_MA3: length 68.2
  IN1 w0.076: 106.63,63.44 104.73,65.34 104.73,73.68 105.42,74.37 105.42,75.97 v2(105.5,76.05)
  IN1 w0.193: v2(103.8,24.59) 103.8,27.31 102.61,28.51 102.61,32.03 102.15,32.49 102.15,33.14 102.61,33.6 102.61,39.81 102.18,40.24 102.18,40.64 102.61,41.07 102.61,43.38 102.8,43.57 103.27,43.57 103.46,43.77 103.46,44.15 103.27,44.35 102.8,44.35 102.61,44.54 102.61,46.76 102.8,46.95 103.37,46.95 103.56,47.14 103.56,47.53 103.37,47.72 102.8,47.72 102.61,47.91 102.61,48.3 102.8,48.49 103.34,48.49 103.53,48.69 103.53,49.07 103.34,49.27 102.8,49.27 102.61,49.46 102.61,49.84 102.8,50.04 103.34,50.04 103.53,50.23 103.53,50.62 103.34,50.81 102.8,50.81 102.61,51 102.61,51.39 102.8,51.58 103.34,51.58 103.53,51.78 103.53,52.16 103.34,52.35 102.8,52.35 102.61,52.55 102.61,53.05 102.76,53.2 103.33,53.2 105.4,55.27 105.4,55.54 105.18,55.76 105.18,56.04 105.45,56.31 105.73,56.31 105.95,56.09 106.22,56.09 106.63,56.5 106.63,56.88 106.4,57.11 106.4,58.32 106.63,58.55 106.63,63.44
  BOTTOM w0.076: UH1.AL5 105.84,76.34 105.56,76.05 v2(105.5,76.05)
  BOTTOM w0.17: JDIMM2.131 103.16,25.24 v2(103.8,24.59)
DDR_B_MA4: length 68
  IN1 w0.076: v2(105.4,76.65) 105.14,76.4 105.14,74.69 104.51,74.06 104.51,64.89 106.13,63.26
  IN1 w0.193: v2(102.73,21.49) 102.8,21.43 104.98,21.43 105.17,21.62 105.17,22.01 104.98,22.2 103.5,22.2 103.31,22.39 103.31,27.11 102.11,28.31 102.11,31.82 101.65,32.28 101.65,33.35 102.11,33.81 102.11,39.52 101.65,39.98 101.65,40.82 102.11,41.28 102.11,45.4 101.92,45.59 101.87,45.59 101.68,45.79 101.68,46.17 101.87,46.36 101.92,46.36 102.11,46.56 102.11,46.94 101.92,47.14 101.87,47.14 101.68,47.33 101.68,47.72 101.87,47.91 101.92,47.91 102.11,48.1 102.11,53.47 102.48,53.85 102.75,53.85 102.88,53.72 103.15,53.72 103.42,54 103.42,54.27 103.2,54.49 103.2,54.77 103.47,55.04 103.75,55.04 103.97,54.82 104.24,54.82 104.52,55.09 104.52,55.36 104.29,55.59 104.29,55.86 105.9,57.47 105.9,58.53 106.13,58.76 106.13,63.26
  BOTTOM w0.076: v2(105.4,76.65) 105.53,76.65 UH1.AL6
  BOTTOM w0.17: JDIMM2.128 102.41,21.17 v2(102.73,21.49)
DDR_B_MA5: length 67.2
  IN1 w0.076: 105.64,63.16 104.21,64.58 104.21,74.12 104.61,74.52 v2(104.61,76.7)
  IN1 w0.193: 105.64,63.16 105.64,58.97 105.44,58.77 105,58.77 104.81,58.58 104.81,58.19 105,58 105.07,58 105.27,57.81 105.27,57.54 102.09,54.36 101.81,54.36 101.7,54.47 101.43,54.47 101.15,54.2 101.15,53.92 101.61,53.47 101.61,53.29 101.42,53.1 101.35,53.1 101.15,52.91 101.15,52.52 101.35,52.33 101.42,52.33 101.61,52.14 101.61,51.75 101.42,51.56 101.35,51.56 101.15,51.36 101.15,50.98 101.35,50.78 101.42,50.78 101.61,50.59 101.61,50.21 101.42,50.01 101.35,50.01 101.15,49.82 101.15,49.43 101.35,49.24 101.42,49.24 101.61,49.05 101.61,48.66 101.42,48.47 101.35,48.47 101.15,48.28 101.15,44.8 101.35,44.61 101.42,44.61 101.61,44.41 101.61,41.48 101.42,41.29 100.51,41.29 100.32,41.1 100.32,40.71 100.51,40.52 101,40.52 101.15,40.37 101.15,32.07 101.61,31.61 101.61,28.1 102.81,26.9 102.81,23.83 102.7,23.73 102.14,23.73 101.93,23.52 101.93,23.01 102.14,22.8 v2(102.71,22.8)
  BOTTOM w0.076: UH1.AM6 104.74,76.7 v2(104.61,76.7)
  BOTTOM w0.17: v2(102.71,22.8) 101.91,22 JDIMM2.126
DDR_B_MA6: length 68.6
  IN1 w0.076: v2(104.98,77.48) 104.96,77.48 104.92,77.44 104.82,77.44 104.25,76.88 104.25,75.76 104.35,75.66 104.35,74.69 103.95,74.29 103.95,64.13 105.14,62.95
  IN1 w0.193: 105.14,62.95 105.14,59.67 104.02,58.55 104.02,58.27 104.52,57.77 104.52,57.5 104.25,57.22 103.98,57.22 103.47,57.73 103.2,57.73 102.93,57.45 102.93,57.18 103.43,56.68 103.43,56.4 103.16,56.13 102.88,56.13 102.38,56.64 102.11,56.64 101.83,56.36 101.83,56.09 102.34,55.59 102.34,55.31 102.06,55.04 101.79,55.04 101.29,55.54 101.01,55.54 100.65,55.18 100.65,41.98 100.46,41.79 99.83,41.79 99.63,41.6 99.63,40.67 100.65,39.65 100.65,29.17 101.06,28.76 101.06,27.94 102.24,26.77 102.24,24.54 v2(101.77,24.08)
  BOTTOM w0.076: UH1.AN7 104.82,77.65 v2(104.98,77.48)
  BOTTOM w0.17: v2(101.77,24.08) 102.45,24.76 102.45,26.69 102.16,26.98 JDIMM2.127
DDR_B_MA7: length 70.1
  IN1 w0.076: 104.14,62.69 103.51,63.32 103.51,74.52 103.4,74.63 103.4,76.53 104.32,77.46 104.32,78.08 104.6,78.36 104.6,79.82 104.71,79.92 v2(104.98,79.92)
  IN1 w0.193: 104.14,62.69 104.14,60.08 98.48,54.42 98.48,53.96 98.67,53.77 98.83,53.77 99.02,53.58 99.02,53.19 98.83,53 98.32,53 98.13,52.81 98.13,52.42 98.32,52.23 98.82,52.23 99.01,52.03 99.01,51.65 98.82,51.45 98.32,51.45 98.13,51.26 98.13,50.88 98.32,50.68 98.76,50.68 99.02,50.42 99.02,44.37 98.56,43.91 98.56,40.33 99.66,39.24 99.66,28.76 100.07,28.35 100.07,27.53 101.24,26.36 101.24,23.32 101.43,23.13 101.43,22.42 101.54,22.31 102.06,22.31 102.25,22.12 102.25,21.62 102.06,21.43 101.07,21.43 v2(100.91,21.27)
  BOTTOM w0.076: UH1.AN10 104.84,79.92 v2(104.98,79.92)
  BOTTOM w0.17: v2(100.91,21.27) JDIMM2.122
DDR_B_MA8: length 68.6
  IN1 w0.076: 104.64,62.74 103.75,63.63 103.75,74.39 104.12,74.77 104.12,75.65 104.07,75.7 104.07,76.95 104.5,77.38 104.5,77.69 104.88,78.06 104.98,78.06 v2(104.99,78.07)
  IN1 w0.193: v2(101.72,25.42) 101.74,25.44 101.74,26.56 100.57,27.74 100.57,28.56 100.15,28.97 100.15,39.44 99.11,40.49 99.11,42.11 99.3,42.3 99.96,42.3 100.15,42.49 100.15,42.96 99.96,43.15 99.29,43.15 99.1,43.35 99.1,43.73 99.29,43.93 99.96,43.93 100.15,44.12 100.15,44.5 99.96,44.7 99.72,44.7 99.52,44.89 99.52,45.28 99.72,45.47 99.96,45.47 100.15,45.66 100.15,46.05 99.96,46.24 99.72,46.24 99.53,46.44 99.53,46.82 99.72,47.01 99.96,47.01 100.15,47.21 100.15,47.59 99.96,47.79 99.72,47.79 99.53,47.98 99.53,48.37 99.72,48.56 99.96,48.56 100.15,48.75 100.15,49.14 99.96,49.33 99.71,49.33 99.52,49.52 99.52,49.91 99.71,50.1 99.96,50.1 100.15,50.3 100.15,50.68 99.96,50.87 99.68,50.87 99.49,51.07 99.49,51.45 99.68,51.65 99.96,51.65 100.15,51.84 100.15,52.23 99.96,52.42 99.68,52.42 99.49,52.61 99.49,53 99.68,53.19 99.96,53.19 100.15,53.38 100.15,53.77 99.96,53.96 99.51,53.96 99.31,54.16 99.31,54.54 99.51,54.74 99.96,54.74 100.15,54.93 100.15,55.39 104.24,59.48 104.64,59.87 104.64,62.74
  BOTTOM w0.076: v2(104.99,78.07) 104.76,78.3 UH1.AN8
  BOTTOM w0.17: JDIMM2.125 101.66,25.48 v2(101.72,25.42)
DDR_B_MA9: length 68.6
  IN1 w0.076: 103.15,62.09 103.15,62.81 102.94,63.02 102.94,75.09 103.04,75.2 103.04,76.77 103.69,77.41 103.69,79.32 v2(103.14,79.87)
  IN1 w0.193: 103.15,62.09 103.15,60.49 97.1,54.44 97.1,41.96 97.29,41.77 97.31,41.77 97.5,41.58 97.5,41.19 97.31,41 97.29,41 97.1,40.8 97.1,40.38 98.12,39.37 98.12,34.59 97.92,34.4 97.62,34.4 97.43,34.21 97.43,33.82 97.62,33.63 98.45,33.63 98.65,33.44 98.65,33.05 98.45,32.86 97.36,32.86 97.17,32.66 97.17,32.28 97.36,32.09 97.66,32.09 97.86,31.89 97.86,31.51 97.66,31.31 97.36,31.31 97.17,31.12 97.17,30.73 97.36,30.54 97.68,30.54 97.87,30.35 97.87,29.98 97.47,29.58 97.47,29.19 97.66,29 97.92,29 98.12,28.8 98.12,28.54 99.07,27.58 99.07,27.12 100.24,25.94 v2(100.24,24.84)
  BOTTOM w0.076: v2(103.14,79.87) 102.76,80.25 UH1.AR11
  BOTTOM w0.17: v2(100.24,24.84) 100.66,25.25 JDIMM2.121
DDR_B_MA10: length 69.6
  IN1 w0.076: 109.87,66.11 109.1,66.87 109.1,73.66 108.61,74.15 108.61,77.95 v2(108.63,77.97)
  IN1 w0.193: v2(108.91,21.28) 109.47,21.85 109.47,27.51 108.8,28.18 108.8,28.53 109,28.73 109.12,28.73 109.32,28.92 109.32,29.3 109.12,29.5 109,29.5 108.8,29.69 108.8,30.08 109.24,30.52 109.24,30.92 108.8,31.36 108.8,31.76 109,31.96 109.14,31.96 109.33,32.15 109.33,32.54 109.14,32.73 109,32.73 108.8,32.92 108.8,40.38 109.88,41.46 109.88,42.07 109.68,42.27 109.2,42.27 109,42.46 109,42.85 109.2,43.04 109.69,43.04 109.88,43.24 109.88,44.27 109.36,44.79 109.36,46.17 109.88,46.69 109.88,47.79 109.69,47.98 109.25,47.98 109.05,48.18 109.05,48.56 109.25,48.76 109.69,48.76 109.88,48.95 109.88,51.03 111.19,52.34 111.19,52.81 111.38,53 111.62,53 111.82,53.19 111.82,53.58 111.62,53.77 111.38,53.77 111.19,53.97 111.19,54.35 111.38,54.54 111.62,54.54 111.82,54.74 111.82,55.12 111.62,55.32 111.38,55.32 111.19,55.51 111.19,55.9 111.38,56.09 111.62,56.09 111.82,56.28 111.82,56.67 111.62,56.86 111.38,56.86 111.19,57.05 111.19,58.45 111.38,58.64 111.41,58.64 111.6,58.83 111.6,59.22 111.41,59.41 111.38,59.41 111.19,59.61 111.19,59.99 111.38,60.18 111.41,60.18 111.6,60.38 111.6,60.76 111.41,60.96 111.38,60.96 111.19,61.15 111.19,61.54 111.38,61.73 111.41,61.73 111.6,61.92 111.6,62.31 111.41,62.5 111.38,62.5 111.19,62.69 111.19,63.08 111.38,63.27 111.41,63.27 111.6,63.47 111.6,63.85 111.41,64.05 111.38,64.05 111.19,64.24 111.19,64.79 109.87,66.11
  BOTTOM w0.076: v2(108.63,77.97) 108.5,77.97 UH1.AH7
  BOTTOM w0.17: JDIMM2.146 v2(108.91,21.28)
DDR_B_MA11: length 72.8
  IN1 w0.076: v2(104.98,80.57) 104.42,80.02 104.42,78.44 104.11,78.12 104.11,77.49 103.22,76.61 103.22,63.17 103.64,62.74
  IN1 w0.193: 103.64,62.74 103.64,60.29 97.6,54.24 97.6,50.26 97.79,50.07 98.18,50.07 98.37,49.88 98.37,49.49 98.18,49.3 97.79,49.3 97.6,49.1 97.6,48.49 97.79,48.3 98.33,48.3 98.52,48.11 98.52,47.72 98.33,47.53 97.79,47.53 97.6,47.33 97.6,46.95 97.79,46.76 98.33,46.76 98.52,46.56 98.52,46.18 98.33,45.98 97.79,45.98 97.6,45.79 97.6,45.4 97.79,45.21 98.33,45.21 98.52,45.02 98.52,44.63 98.33,44.44 98.22,44.44 98.03,44.25 98.03,40.16 98.61,39.57 98.61,39.1 98.81,38.91 98.94,38.91 99.14,38.71 99.14,38.33 98.94,38.13 98.81,38.13 98.61,37.94 98.61,37.56 98.81,37.36 98.94,37.36 99.14,37.17 99.14,36.78 98.94,36.59 98.81,36.59 98.61,36.4 98.61,34.23 99.16,33.68 99.16,32.42 98.82,32.08 98.82,31.64 99.16,31.31 99.16,30.87 98.82,30.54 98.82,30.1 99.16,29.76 99.16,29.33 98.82,28.99 98.82,28.55 99.57,27.81 99.57,27.32 100.74,26.15 100.74,22.81 v2(100.85,22.71)
  BOTTOM w0.076: v2(104.98,80.57) 104.84,80.57 UH1.AN11
  BOTTOM w0.17: JDIMM2.120 100.41,22.27 v2(100.85,22.71)
DDR_B_MA12: length 67.1
  IN1 w0.076: 102.65,62.59 102.65,75.32 102.87,75.55 102.87,76.85 103.51,77.49 103.51,78.9 v2(103.15,79.26)
  IN1 w0.193: v2(100.22,23.35) 99.75,23.83 99.75,25.74 98.57,26.91 98.57,27.38 96.67,29.28 96.67,34.15 97.62,35.1 97.62,39.16 96.6,40.18 96.6,54.65 102.65,60.7 102.65,62.59
  BOTTOM w0.076: UH1.AR10 102.81,79.6 v2(103.15,79.26)
  BOTTOM w0.17: JDIMM2.119 100.16,26.63 99.66,26.13 99.66,23.91 v2(100.22,23.35)
DDR_B_MA13: length 70.3
  IN1 w0.076: v2(110.46,79.27) 109.94,78.75 109.94,77.74 110.37,77.31 110.37,74.57 110.99,73.95 110.99,71.53 110.88,71.43 110.88,69.13 116.04,63.97
  IN1 w0.193: v2(113.95,22.44) 113.85,22.44 112.95,21.55 112.09,21.55 111.81,21.83 111.81,22.27 112,22.46 112.3,22.46 112.88,23.03 112.88,23.95 112.23,24.6 112.23,25.14 112.63,25.53 112.63,28.8 112.58,28.85 112.58,32.41 112.5,32.5 112.5,34.09 112.19,34.4 112.19,39.31 113.13,40.25 113.13,48.87 116.44,52.18 116.44,63.57 116.04,63.97
  BOTTOM w0.076: v2(110.46,79.27) 110.14,78.95 UH1.AF9
  BOTTOM w0.17: v2(113.95,22.44) 113.31,22.44 111.91,21.04 JDIMM2.158
DDR_B_PAR: length 69.9
  IN1 w0.076: v2(107.72,77.97) 107.72,77.73 108.21,77.24 108.21,73.92 108.71,73.41 108.71,65.86 109.17,65.4
  IN1 w0.193: v2(109,24.15) 108.76,23.91 108.25,23.91 108,24.16 108,27.15 107.33,27.82 107.33,29.08 107.52,29.27 107.6,29.27 107.79,29.46 107.79,29.85 107.6,30.04 107.25,30.04 107.06,30.23 107.06,31.58 107.25,31.77 107.59,31.77 107.78,31.96 107.78,32.35 107.59,32.54 107.25,32.54 107.06,32.74 107.06,33.93 107.23,34.1 107.23,38.44 107.63,38.84 107.63,39.36 107.23,39.77 107.23,40.75 107.42,40.95 107.59,40.95 107.78,41.14 107.78,41.52 107.59,41.72 107.42,41.72 107.23,41.91 107.23,44.22 107.42,44.41 107.85,44.41 108.05,44.61 108.05,44.99 107.85,45.19 107.42,45.19 107.23,45.38 107.23,45.77 107.42,45.96 107.85,45.96 108.05,46.15 108.05,46.54 107.85,46.73 107.42,46.73 107.23,46.92 107.23,47.31 107.42,47.5 107.85,47.5 108.05,47.7 108.05,48.08 107.85,48.28 107.42,48.28 107.23,48.47 107.23,49.79 110.19,52.75 110.19,64.37 109.17,65.4
  BOTTOM w0.076: UH1.AJ7 107.59,77.97 v2(107.72,77.97)
  BOTTOM w0.17: JDIMM2.143 107.24,27.08 107.24,25.47 108.57,24.15 v2(109,24.15)
DDR_B_RAS#: length 69.4
  IN1 w0.076: v2(108.63,79.92) 109,79.55 109,79 109.16,78.84 109.16,77.73 109.01,77.58 109.01,74.41 109.66,73.76 109.66,67.72 109.85,67.54
  IN1 w0.193: v2(110.97,22.96) 112.1,22.96 112.34,23.2 112.34,23.77 112.07,24.04 110.66,24.04 110.47,24.24 110.47,27.92 110.34,28.05 110.34,33.2 109.8,33.74 109.8,39.96 110.88,41.04 110.88,50.62 111.25,50.99 111.52,50.99 111.72,50.8 111.99,50.8 112.26,51.07 112.26,51.34 112.07,51.54 112.07,51.81 112.34,52.08 112.61,52.08 112.81,51.89 113.08,51.89 113.35,52.16 113.35,52.43 113.16,52.63 113.16,52.9 113.64,53.38 113.64,63.75 109.85,67.54
  BOTTOM w0.076: v2(108.63,79.92) 108.5,79.92 UH1.AH10
  BOTTOM w0.17: JDIMM2.152 110.41,22.4 v2(110.97,22.96)
DDR_B_WE#: length 65.5
  IN1 w0.076: 110.09,68 110.09,71.38 110.46,71.75 110.46,73.29 109.21,74.54 109.21,77.54 109.33,77.66 109.33,79.08 109.18,79.23 109.18,80.03 v2(108.63,80.57)
  IN1 w0.193: 110.09,68 114.17,63.92 114.17,63.08 114.36,62.89 114.48,62.89 114.67,62.7 114.67,62.31 114.48,62.12 114.36,62.12 114.17,61.92 114.17,61.54 114.36,61.35 114.48,61.35 114.67,61.15 114.67,60.77 114.48,60.57 114.36,60.57 114.17,60.38 114.17,59.99 114.36,59.8 114.48,59.8 114.67,59.61 114.67,59.22 114.48,59.03 114.36,59.03 114.17,58.84 114.17,58.45 114.36,58.26 114.48,58.26 114.67,58.06 114.67,57.68 114.48,57.48 114.36,57.48 114.17,57.29 114.17,56.91 114.36,56.71 114.48,56.71 114.67,56.52 114.67,56.13 114.48,55.94 114.36,55.94 114.17,55.75 114.17,55.36 114.36,55.17 114.48,55.17 114.67,54.97 114.67,54.59 114.48,54.4 114.36,54.4 114.17,54.2 114.17,53.82 114.36,53.62 114.48,53.62 114.67,53.43 114.67,53.04 114.48,52.85 114.36,52.85 114.17,52.66 114.17,52.25 111.38,49.45 111.38,40.84 110.3,39.76 110.3,33.95 110.84,33.41 110.84,28.25 110.96,28.13 v2(110.96,26.3)
  BOTTOM w0.076: UH1.AH11 108.5,80.57 v2(108.63,80.57)
  BOTTOM w0.17: JDIMM2.151 110.16,27.08 110.93,26.3 v2(110.96,26.3)
DDR_CKE0_DIMMA: length 45.3
  IN3 w0.178: v2(95.9,37.19) 95.44,37.66 95.44,39.13 95.72,39.42 95.72,45.08 95.29,45.51 95.29,57.73 98.25,60.69 98.25,67.83 99.49,69.07 v2(99.57,69.07)
  BOTTOM w0.076: v2(99.57,69.07) 100.09,69.58 100.09,69.86 100.97,70.74 100.97,72.89 101.62,73.54 UH1.AT1
  BOTTOM w0.17: JDIMM1.109 97.65,40.04 97.38,39.77 96.24,39.77 95.43,38.96 95.43,37.67 v2(95.9,37.19)
DDR_CKE1_DIMMA: length 45.6
  IN3 w0.178: v2(95.9,38.51) 95.94,38.51 96.24,38.81 96.24,45.29 95.81,45.72 95.81,57.45 98.73,60.38 98.73,67.27 99.31,67.85 v2(99.56,67.85)
  BOTTOM w0.076: 100.59,69.71 100.59,70.02 101.18,70.6 101.18,72.86 101.91,73.6 101.91,74.09 UH1.AT2
  BOTTOM w0.17: v2(99.56,67.85) 100.59,68.88 100.59,69.71 ; v2(95.9,38.51) 95.96,38.51 96.4,38.07 96.4,35.24 97.9,33.74 JDIMM1.110
DDR_CKE2_DIMMB: length 65.9
  IN1 w0.076: v2(102.23,78.01) 102.01,78.01 100,75.99 100,66.78 99.83,66.62
  IN1 w0.193: v2(96.55,24.42) 95.61,24.42 95.44,24.59 95.44,24.86 95.75,25.16 95.75,25.44 95.47,25.71 95.2,25.71 94.9,25.41 94.63,25.41 94.35,25.68 94.35,25.95 94.45,26.05 94.45,26.33 94.18,26.6 93.91,26.6 93.81,26.5 93.53,26.5 93.25,26.78 93.25,55.47 99.83,62.05 99.83,66.62
  BOTTOM w0.089: v2(102.23,78.01) 102.07,78.01 UH1.AT8
  BOTTOM w0.17: v2(96.55,24.42) 96.55,25.77 97.66,26.88 JDIMM2.109
DDR_CKE3_DIMMB: length 67
  IN1 w0.076: v2(102.23,79.92) 101.85,79.54 101.85,78.23 99.03,75.41 99.03,66.81 99.33,66.5
  IN1 w0.193: v2(96.52,23.11) 96.22,23.11 92.75,26.58 92.75,55.67 99.33,62.26 99.33,66.5
  BOTTOM w0.089: v2(102.23,79.92) 102.1,79.92 UH1.AT10
  BOTTOM w0.17: v2(96.52,23.11) 97.91,21.73 JDIMM2.110
DDR_CS0_DIMMA#: length 50.9
  IN3 w0.178: v2(113.49,37.69) 113.72,37.69 113.93,37.91 113.93,41.96 114.62,42.65 114.62,45.63 114.44,45.81 114.08,45.81 113.9,45.99 113.9,46.52 114.08,46.7 114.44,46.7 114.62,46.88 114.62,54.46 115.25,55.08 115.25,58.91 113.37,60.79 v2(113.14,60.79)
  BOTTOM w0.076: 110.3,71.6 110.61,71.92 110.61,75.8 110.83,76.01 111.35,76.01 UH1.AD5
  BOTTOM w0.17: v2(113.49,37.69) 113.3,37.51 112.29,37.51 111.5,38.29 109.79,38.29 109.36,38.72 109.36,39.7 109.65,39.99 JDIMM1.149 ; v2(113.14,60.79) 112.67,60.79 110.3,63.16 110.3,71.6
DDR_CS1_DIMMA#: length 54
  IN3 w0.178: v2(113.15,62.2) 113.72,62.2 114.25,61.67 114.25,61.37 114.13,61.25 114.13,60.95 114.43,60.64 114.73,60.64 114.85,60.76 115.15,60.76 115.56,60.36 115.56,60 115.41,59.85 115.41,59.48 115.81,59.08 115.81,54.35 115.6,54.14 115.39,54.14 115.17,53.92 115.17,53.5 115.39,53.28 115.6,53.28 115.81,53.07 115.81,52.64 115.6,52.43 115.39,52.43 115.17,52.22 115.17,51.79 115.39,51.58 115.6,51.58 115.81,51.36 115.81,50.94 115.6,50.72 115.39,50.72 115.14,50.48 115.14,42.43 114.51,41.8 114.51,36.14 114.33,35.96 114.05,35.96 113.52,36.49 v2(113.45,36.49)
  BOTTOM w0.076: 110.81,71.48 110.95,71.62 110.95,73.22 111.22,73.5 111.22,73.86 110.94,74.14 UH1.AE2
  BOTTOM w0.17: 110.81,71.48 v1(110.81,70.09) 110.81,63.41 111.09,63.13 111.33,63.13 111.51,63.31 111.51,63.32 111.77,63.58 112.13,63.58 112.35,63.37 112.35,63.01 112.1,62.76 112.1,62.52 112.67,61.96 112.91,61.96 v2(113.15,62.2) ; JDIMM1.157 111.65,40.06 112.35,39.37 113.63,39.37 113.99,39.02 113.99,36.66 113.81,36.49 v2(113.45,36.49)
DDR_CS2_DIMMB#: length 64
  IN1 w0.076: 110.69,68.26 110.69,73.81 110.16,74.34 110.16,77.29 109.77,77.67 109.77,79 110.05,79.28 110.05,79.5 v2(110.44,79.89)
  IN1 w0.193: 110.69,68.26 115.51,63.43 115.51,52.42 112.31,49.21 112.31,40.6 111.36,39.65 111.36,34.05 111.67,33.75 111.67,32.16 111.75,32.07 111.75,28.51 111.8,28.46 111.8,25.88 v2(110.96,25.03)
  BOTTOM w0.076: v2(110.44,79.89) 110.09,80.25 UH1.AF11
  BOTTOM w0.17: JDIMM2.149 109.66,26.34 v2(110.96,25.03)
DDR_CS3_DIMMB#: length 66.9
  IN1 w0.076: v2(111.31,77.3) 111.31,77.18 111.69,76.81 111.69,74.44 112.23,73.9 112.23,69.88 118.27,63.84 118.27,63.69
  IN1 w0.193: 118.27,63.69 118.27,49.29 115.6,46.62 115.6,40.14 114.45,38.99 114.45,32.13 114.58,32 114.58,24.29 114.84,24.03 114.84,23.4 115.29,22.95 v2(115.29,22.92)
  BOTTOM w0.076: UH1.AE7 111.26,77.3 v2(111.31,77.3)
  BOTTOM w0.17: JDIMM2.157 111.66,27.22 112.78,26.1 113.47,26.1 114.68,24.9 114.68,23.53 v2(115.29,22.92)
DDR_VTT_PG_CTRL: length 3.2
  BOTTOM w0.102: UH1.BT13 86.88,82.46 v1(86.07,82.46) UC1.2
DGPU_HOLD_RST#: length 77.7
  IN3 w0.117: v2(161,28.23) 160.87,28.23 160.39,27.75 160.05,27.75 160.05,27.75 155.05,27.75 153.77,29.03 149.91,29.03 v2(149.9,29.01)
  BOTTOM w0.089: UH2.AL36 161.37,28.61 v2(161,28.23)
  BOTTOM w0.102: UV14.1 140.28,76.3 RV58.2 139.52,75.54 138.81,75.54 138.69,75.43 137.88,75.43 137.34,74.89 136.17,74.89 135.47,74.18 135.47,73.39 135.24,73.16 135.24,68.78 140.07,63.96 140.07,53.03 140.95,52.14 140.95,45.61 143.27,43.3 143.27,34.22 142.97,33.92 142.35,33.92 141.87,33.44 141.87,29.77 142.5,29.14 148.6,29.14 149.02,29.56 149.51,29.56 149.88,29.19 149.88,29.03 v2(149.9,29.01)
DGPU_PEX_RST#: length 22.9
  TOP w0.102: v1(158.71,73.45) 158.2,72.94 RV571.1 ; UV18.4 156.54,72.75 RV573.1 RV571.1 ; RV571.1 157.62,72.35 v2(157.31,72.05)
  IN1 w0.114: v2(147.62,78.45) 147.62,78.4 148.72,77.31 148.72,74.92 150.18,73.47 153.33,73.47 153.7,73.09 153.7,72.52 154.17,72.05 v2(157.31,72.05)
  BOTTOM w0.102: v2(147.62,78.45) 148.23,79.06 RV208.2 148.72,79.8 RV39.2 RV40.1 149.85,79.94 QV88.2
DGPU_PEX_RST#_R: length 13.3
  BOTTOM w0.102: UV1.AJ12 159.17,84.78 159.17,82.51 158.96,82.31 157.77,82.31 157.49,82.03 157.49,80.94 157.24,80.69 157.04,80.69 156.73,80.38 156.73,80.37 156.72,80.36 156.72,80.1 156.45,79.82 154.55,79.82 154.4,79.97 v1(152.23,79.97) 150.73,79.97 RV40.2
DGPU_PWR_EN: length 71.5
  TOP w0.102: QV3.2 147.58,74.05 147.11,73.57 144.87,73.57 143.36,72.07 143.36,68.46 140.8,65.9 140.8,64.18 141.21,63.77 v2(141.21,63.64) ; RH127.1 162.35,28.87 160.41,28.87 160,29.28 v2(160,29.35) 160,29.56 159.67,29.89 154.82,29.89 RH129.1
  IN1 w0.114: v2(141.21,63.64) 140.57,63.01 140.57,46.35 145.77,41.15 145.77,40.42 150.53,35.66 150.53,32.78 152.52,30.79 152.72,30.79 153.15,30.79 154.91,29.02 156.92,29.02 156.97,28.97 159.24,28.97 159.25,28.97 159.62,28.97 v2(160,29.35)
  BOTTOM w0.089: UH2.AJ39 160,29.67 v2(160,29.35)
DGPU_PWR_EN#: length 7.5
  TOP w0.102: RV578.1 152.79,75.56 RV534.2 151.98,74.98 151.38,74.38 150.04,74.38 v1(149.74,74.69) 148.92,75.5 147.56,75.5 QV3.6
DGPU_PWR_EN#_R: length 41.6
  TOP w0.102: QZ8.2 147.9,105.47 v2(147.46,105.02) ; QZ7.2 QZ7.5 156.16,76.59 155.99,76.42 RV578.2 152.82,76.44 CV603.1 151.98,76.93 151.56,77.34 QV85.2 151.56,78.99 151.81,79.24 152.94,79.24 153.25,79.54 153.25,81.02 v2(153.71,81.47)
  IN1 w0.114: v2(153.71,81.47) 153.69,81.49 153.69,90.68 147.46,96.92 v2(147.46,105.02)
DGPU_PWRGD_EC: length 60.9
  TOP w0.102: RH500.1 167.9,19.78 167.73,19.95 v2(167.73,20.21) ; v2(218.22,20.41) 218.75,20.94 UE1.24
  IN1 w0.114: v2(218.22,20.41) 217.43,21.2 214.9,21.2 214.81,21.29 212.48,21.29 212.12,21.66 211.34,21.66 211.04,21.36 211.04,21.35 210.32,20.63 210.31,20.63 210.14,20.46 205.58,20.46 205.04,19.92 198.87,19.92 197.51,18.56 187.42,18.56 187.2,18.34 180.67,18.34 179.97,17.64 179.44,17.64 178.04,19.04 175.28,19.04 175.03,19.3 174.93,19.39 173.49,19.39 173.21,19.11 172.15,19.11 171.86,18.83 171.86,18.82 171.77,18.73 169.78,18.73 168.94,19.57 168.11,19.57 167.73,19.95 v2(167.73,20.21)
  BOTTOM w0.076: UH2.BD24 167.59,22.35 167.59,21.76 167.8,21.55 167.8,20.28 v2(167.73,20.21)
  BOTTOM w0.102: v2(218.22,20.41) 218.22,20.69 v1(218.5,20.97)
DGPU_PWROK: length 53.7
  TOP w0.102: RH86.2 155.03,30.98 157.02,30.98 157.86,30.14 160.18,30.14 160.61,29.71 v2(160.61,29.33) 160.69,29.33 161.38,30.01 163.28,30.01 163.56,30.29 163.56,32.22 163.31,32.48 163.31,33.44 v2(163.89,34.03)
  IN2 w0.127: v2(163.89,34.03) 164.38,34.03 164.82,33.59 164.82,32.27 165.19,31.9 169.31,31.9 169.61,32.2 169.61,35.62 170.31,36.33 171.65,36.33 172.19,35.79 180.54,35.79 181.14,36.39 181.14,38.57 179.7,40.01 179.7,43.64 178.27,45.08 v2(178.24,45.08)
  BOTTOM w0.089: UH2.AJ38 160.59,29.36 v2(160.61,29.33)
  BOTTOM w0.102: v2(178.24,45.08) 178.24,46.03 175.9,48.36 PR1026.2
DH_CHG: length 17.8
  IN1 w0.635: v2(24.9,18.15) v2(25.66,18.15) 26.76,18.15 27.65,19.04 27.65,30.17 29.35,31.87 29.35,33.01
  vias: v1(25.99,17.47) v2(29.35,34.28) v2(29.35,33.7)
DISPOFF#: length 10.2
  TOP w0.102: UZ23.1 66.7,29.82 66.43,30.09 65.16,30.09 64.55,29.48 63.28,29.48 RV536.1 ; RV536.1 RV566.2 ; RV536.1 62.43,29.96 v1(61.84,30.55) 61.16,31.23 v2(61.1,31.23)
  BOTTOM w0.102: JEDP1.17 61.88,32.01 v2(61.1,31.23)
DL_CHG: length 12.7
  IN3 w0.635: v2(22.03,27.55) v2(22.74,27.55) 26.93,27.55 28.01,28.63 28.01,31.8 29.22,33.01 30.62,33.01
  vias: v2(30.87,34.41) v2(31.23,33.9)
DMI_CRX_PTX_N0: length 73.2
  TOP w0.102: v2(167.35,45.24) 167.53,45.42 167.53,46.38 165.66,48.25 152.65,48.25 148.87,44.48 144.21,44.48 141.31,47.38 141.31,62.14 130.95,72.51 130.95,73.95 130.06,74.84 130.06,75.35 127.59,77.82 126.44,77.82 126.17,78.09 126.17,78.32 126.04,78.45 v2(125.93,78.45)
  BOTTOM w0.076: v2(167.35,45.24) 167.48,45.11 167.48,44.68 166.92,44.13 166.65,44.13 166.36,43.84 166.36,43.78 166.06,43.48 166.02,43.48 165.89,43.35 165.89,43.06 UH2.C27 ; v2(125.93,78.45) 125.61,78.12 UH1.E8
DMI_CRX_PTX_N1: length 71.2
  TOP w0.102: v2(166.12,45.49) 166.27,45.64 166.27,46.34 164.98,47.64 152.93,47.64 149.12,43.83 143.92,43.83 140.62,47.12 140.62,61.94 130.31,72.25 v4(130.31,73.08) 130.31,73.69 129.42,74.58 129.42,74.91 127,77.33 126.13,77.33 126.09,77.29 125.65,77.29 v2(125.28,77.66)
  BOTTOM w0.076: v2(125.28,77.66) 124.94,77.31 UH1.F6 ; v2(166.12,45.49) 166.29,45.32 166.29,44.55 165.5,43.76 165.5,43.41 165.63,43.29 UH2.B28
DMI_CRX_PTX_N2: length 68.8
  TOP w0.102: v2(164.96,45.27) 165.13,45.45 165.13,45.86 163.97,47.03 153.21,47.03 149.37,43.2 143.69,43.2 140.01,46.87 140.01,61.66 127.39,74.29 127.39,75.24 126.18,76.45 126.18,76.62 125.93,76.87 125.93,76.87 v2(125.92,76.88)
  BOTTOM w0.076: UH2.B29 165.12,43.09 165.04,43.01 164.9,43.01 164.82,43.09 164.82,43.28 165.1,43.56 165.1,43.89 165.38,44.17 165.38,44.49 165.33,44.55 165.33,44.7 165.16,44.87 165.16,45.07 v2(164.96,45.27) ; v2(125.92,76.88) 125.61,76.56 UH1.E5
DMI_CRX_PTX_N3: length 71
  TOP w0.076: v2(123.92,79.24) 124.13,79.04 124.31,79.04 124.62,78.72 124.62,78.29 124.92,78 124.92,77.47 125.54,76.84 125.54,76.71 125.56,76.7 125.56,76.69
  TOP w0.102: v2(164.97,44.41) 164.82,44.56 164.82,44.83 164.53,45.12 164.53,45.37 163.28,46.62 153.4,46.62 v4(150.72,43.94) 149.54,42.76 143.49,42.76 139.61,46.65 139.61,61.47 125.56,75.51 125.56,76.69
  BOTTOM w0.076: v2(123.92,79.24) 123.75,79.24 123.52,79.01 UH1.J9 ; v2(164.97,44.41) 164.86,44.31 164.86,43.62 164.5,43.26 UH2.B30
DMI_CRX_PTX_P0: length 73.2
  TOP w0.102: v2(167.94,45.25) 167.74,45.46 167.74,46.46 165.74,48.45 152.56,48.45 148.79,44.68 144.29,44.68 141.51,47.46 141.51,62.23 131.15,72.59 131.15,74.03 130.26,74.92 130.26,75.44 127.68,78.02 126.52,78.02 126.37,78.17 126.37,78.35 126.47,78.45 v2(126.58,78.45)
  BOTTOM w0.076: UH1.D8 126.26,78.12 v2(126.58,78.45) ; v2(167.94,45.25) 167.65,44.96 167.65,44.62 166.99,43.96 166.71,43.96 166.53,43.77 166.53,43.71 166.37,43.55 166.37,43.45 166.52,43.29 166.52,43.16 166.41,43.04 166.27,43.04 166.11,43.2 UH2.B27
DMI_CRX_PTX_P1: length 71.2
  TOP w0.102: v2(166.82,45.49) 166.93,45.49 167.03,45.6 167.03,45.86 166.93,45.96 166.58,45.96 166.47,46.06 166.47,46.43 165.06,47.84 152.84,47.84 149.03,44.03 144,44.03 140.83,47.21 140.83,62.03 130.52,72.34 130.52,72.77 130.54,72.8 130.54,73.36 130.52,73.39 130.52,73.78 129.63,74.67 129.63,74.83 129.63,75 127.09,77.54 126.43,77.54 126.3,77.66 v2(125.93,77.66)
  BOTTOM w0.076: UH1.E6 125.61,77.36 125.91,77.66 v2(125.93,77.66) ; UH2.A28 165.73,43.75 165.79,43.81 165.89,43.81 165.97,43.73 166.06,43.73 166.12,43.79 166.12,43.88 166.04,43.96 166.04,44.07 166.46,44.48 166.46,45.02 166.53,45.1 166.74,45.1 166.82,45.18 v2(166.82,45.49)
DMI_CRX_PTX_P2: length 68.8
  TOP w0.102: v2(126.57,76.88) 126.57,76.88 126.57,76.87 126.39,76.69 126.39,76.53 127.59,75.33 127.59,74.37 140.22,61.75 140.22,46.95 143.77,43.4 149.29,43.4 153.12,47.23 164.05,47.23 165.34,45.95 165.34,45.48 v2(165.55,45.27)
  BOTTOM w0.076: UH1.D5 126.26,76.56 v2(126.57,76.88) ; v2(165.55,45.27) 165.32,45.05 165.32,44.94 165.49,44.77 165.49,44.62 165.55,44.56 165.55,44.1 165.27,43.82 165.27,43.41 165.37,43.3 165.37,43.08 165.12,42.82 UH2.C29
DMI_CRX_PTX_P3: length 71.1
  TOP w0.076: 125.36,76.69 125.36,76.7 125.38,76.72 125.38,76.78 124.75,77.4 124.75,77.93 124.46,78.22 124.46,78.65 124.24,78.87 124.05,78.87 123.99,78.81 v2(123.99,78.45)
  TOP w0.102: 125.36,76.69 125.36,75.43 139.41,61.38 139.41,46.57 143.41,42.56 149.62,42.56 150.64,43.57 150.67,43.57 151.09,43.99 151.09,44.03 153.48,46.42 163.19,46.42 164.33,45.29 164.33,45.04 164.62,44.75 164.62,44.63 164.4,44.42 v2(164.38,44.42)
  BOTTOM w0.076: UH1.J8 123.67,78.45 v2(123.99,78.45) ; UH2.A30 164.62,43.61 164.69,43.69 164.69,43.93 164.6,44.03 164.27,44.03 164.19,44.1 164.19,44.33 164.28,44.42 v2(164.38,44.42)
DMI_CTX_PRX_N0: length 76.5
  TOP w0.102: v2(137.17,61.59) 136.87,61.89 136.37,61.89 135.54,61.07 135.54,47.06 145.17,37.43 161.71,37.43 162.21,36.92 164.53,36.92 164.98,37.38 164.98,38.52 165.29,38.83 165.9,38.83 166,38.93 166,39.13 165.9,39.23 v2(165.74,39.23)
  BOTTOM w0.076: UH1.A8 127.99,78.05 127.91,78.14 127.91,78.26 127.99,78.34 128.71,78.34 128.73,78.32 128.74,78.32
  BOTTOM w0.102: 128.74,78.32 129.91,78.32 132.04,76.19 v4(132.04,73.47) 132.04,65.41 135.59,61.86 136.96,61.86 137.17,61.65 v2(137.17,61.59) ; UH2.L27 166.23,38.75 v2(165.74,39.23)
DMI_CTX_PRX_N1: length 73.7
  TOP w0.102: v2(137.13,59.57) 137.03,59.67 137.03,59.91 137.12,60 138.33,60 138.8,59.53 138.8,46.18 143.05,41.93 152.86,41.93 153.44,41.34 156.96,41.34 158.63,43.02 165.29,43.02 166.41,41.9 167.14,41.9 167.4,41.65 167.4,41.14 167.27,41.01 166.94,41.01 166.81,41.14 v2(166.81,41.38)
  BOTTOM w0.076: UH1.B6 127.39,77.27 127.32,77.34 127.32,77.45 127.44,77.57 128.8,77.57 128.82,77.56 128.84,77.56
  BOTTOM w0.101: UH2.E24 v2(166.81,41.38)
  BOTTOM w0.102: 128.84,77.56 128.93,77.56 131.33,75.15 131.33,64.6 135.9,60.03 136.99,60.03 137.13,59.88 v2(137.13,59.57)
DMI_CTX_PRX_N2: length 69.4
  TOP w0.102: v2(137.13,57.5) 137.13,57.7 137.26,57.82 137.88,57.82 138.19,57.51 138.19,53.58 137.37,52.77 137.37,46.72 142.78,41.32 152.55,41.32 153.14,40.73 157.31,40.73 158.2,41.62 162.14,41.62 162.32,41.8 164.72,41.8 164.96,41.56 164.96,41.16 165.18,40.93 165.45,40.93 v2(165.77,40.62)
  BOTTOM w0.076: 128.71,76.6 128.7,76.6 128.68,76.62 128.64,76.62 128.63,76.63 128.62,76.63 128.44,76.82 128.17,76.82 128.1,76.75 128.1,76.61 UH1.A5
  BOTTOM w0.101: UH2.G27 v2(165.77,40.62)
  BOTTOM w0.102: v2(137.13,57.5) 137.28,57.65 137.28,57.82 137.18,57.92 136.51,57.92 130.67,63.77 130.67,74.87 128.94,76.6 128.71,76.6
DMI_CTX_PRX_N3: length 69.8
  TOP w0.102: v2(137.14,55.65) 137.36,55.86 137.47,55.86 137.58,55.76 137.58,54.08 136.74,53.24 136.74,46.51 136.76,46.49 136.76,46.47 143.21,40.02 146.71,40.02 148.34,38.39 155.56,38.39 156.07,38.9 160.83,38.9 161.95,37.79 163.7,37.79 164.04,38.13 164.04,38.61 164.14,38.71 164.4,38.71 164.5,38.61 v2(164.5,38.4)
  BOTTOM w0.076: 129.02,75.63 129.01,75.64 129.01,75.67 128.65,76.02 128.03,76.02 127.94,75.93 127.7,75.93 127.62,75.86 127.62,75.51 127.55,75.44 127.31,75.44 127.24,75.5 UH1.B4
  BOTTOM w0.089: v2(164.5,38.4) 164.79,38.69 UH2.L29
  BOTTOM w0.102: v2(137.14,55.65) 137.14,55.81 137.04,55.91 136.64,55.91 130.01,62.54 130.01,74.64 129.02,75.63
DMI_CTX_PRX_P0: length 76.6
  TOP w0.102: v2(165.74,38.34) 165.74,38.52 165.64,38.62 165.37,38.62 165.19,38.44 165.19,37.29 164.61,36.72 162.13,36.72 161.62,37.23 145.09,37.23 135.34,46.97 135.34,61.15 136.28,62.09 137.04,62.09 v2(137.17,62.22)
  BOTTOM w0.076: 128.74,78.53 128.73,78.53 128.71,78.51 127.93,78.51 127.74,78.33 127.74,78.24 UH1.B8
  BOTTOM w0.102: 128.74,78.53 129.99,78.53 132.24,76.27 132.24,73.78 132.27,73.76 132.27,73.17 132.24,73.14 132.24,65.5 135.67,62.07 137.02,62.07 v2(137.17,62.22) ; UH2.N27 166.23,38.08 165.96,38.34 v2(165.74,38.34)
DMI_CTX_PRX_P1: length 73.7
  TOP w0.102: v2(166.81,40.62) 167,40.8 167.35,40.8 167.6,41.05 167.6,41.73 167.23,42.1 166.49,42.1 165.37,43.22 158.55,43.22 156.87,41.54 153.53,41.54 152.94,42.13 143.14,42.13 139,46.27 139,59.61 138.41,60.2 137.36,60.2 v2(137.14,60.42)
  BOTTOM w0.076: 128.84,77.76 128.82,77.76 128.8,77.74 127.37,77.74 127.15,77.52 127.15,77.34 127.08,77.27 UH1.C6
  BOTTOM w0.101: UH2.G24 v2(166.81,40.62)
  BOTTOM w0.102: 128.84,77.76 129.01,77.76 131.53,75.24 131.53,64.68 135.99,60.23 136.96,60.23 v2(137.14,60.42)
DMI_CTX_PRX_P2: length 69.4
  TOP w0.102: v2(165.77,41.38) 165.52,41.14 165.26,41.14 165.16,41.24 165.16,41.65 164.81,42 162.23,42 162.05,41.82 158.12,41.82 157.23,40.93 153.22,40.93 152.64,41.52 142.86,41.52 137.58,46.8 137.58,52.68 138.39,53.5 138.39,57.6 137.96,58.03 137.27,58.03 137.14,58.16 v2(137.14,58.38)
  BOTTOM w0.076: UH1.B5 127.76,76.68 127.8,76.68 128.1,76.99 128.51,76.99 128.69,76.8 128.71,76.8
  BOTTOM w0.101: UH2.E26 v2(165.77,41.38)
  BOTTOM w0.102: v2(137.14,58.38) 137.14,58.38 136.89,58.13 136.6,58.13 130.87,63.85 130.87,74.95 129.02,76.8 128.71,76.8
DMI_CTX_PRX_P3: length 69.9
  TOP w0.102: v2(164.5,39.16) 164.5,39 164.42,38.92 164.06,38.92 163.84,38.7 163.84,38.22 163.61,37.99 162.04,37.99 160.92,39.11 155.98,39.11 155.48,38.6 148.42,38.6 146.8,40.22 143.29,40.22 136.97,46.55 136.97,46.57 136.94,46.6 136.94,53.16 137.78,53.99 137.78,55.85 137.56,56.07 137.3,56.07 137.14,56.22 v2(137.14,56.32)
  BOTTOM w0.076: UH1.D4 127.03,76.1 127.87,76.1 127.96,76.19 128.72,76.19 129.13,75.78 129.15,75.78 129.16,75.78
  BOTTOM w0.089: UH2.K29 164.79,39.45 v2(164.5,39.16)
  BOTTOM w0.102: v2(137.14,56.32) 136.94,56.12 136.72,56.12 130.21,62.63 130.21,74.73 129.16,75.78
DMIC_CLK: length 47.1
  TOP w0.102: v2(271.54,26.57) 271.76,26.34 RA28.1 CA30.1 272.22,24.57 DA1.2 273.15,24.44 RA37.2
  IN1 w0.114: v2(271.54,26.57) 271.39,26.72 271.39,27.03 271.13,27.3 270.58,27.3 269.95,26.66 262.9,26.66 261.55,25.31 260.72,25.31 260.26,25.77 260.26,26.2 260.08,26.38 257.51,26.38 257.36,26.23 256.53,26.23 255.3,25 249.8,25 v2(249.11,25.69)
  BOTTOM w0.102: RZ41.2 EC5206.1 241.67,36.77 241.18,36.29 241.18,34.97 241.46,34.69 v1(242.83,34.69) 243.07,34.45 243.07,34.45 244.3,33.21 247.37,33.21 248.45,32.14 248.45,26.15 248.9,25.69 v2(249.11,25.69)
DMIC_CLK_CAM: length 7.5
  BOTTOM w0.102: JCAM1.3 239.02,42.94 238.67,42.59 238.67,39.94 239.01,39.6 v4(240.71,39.6) 241.03,39.6 241.28,39.35 241.28,38.95 RZ41.1
DMIC_CLK_R: length 5.6
  TOP w0.102: RA28.2 273.57,26.34 274.14,25.77 275.41,25.77 275.92,26.28 277.68,26.28 277.81,26.15 HDA1.3
DMIC_DAT: length 48.2
  TOP w0.102: RA27.1 271.6,27.23 v2(270.95,26.58) 271.03,26.51 v1(271.03,25.62) 271.03,25.01 271.35,24.68 DA1.3 270.48,24.44 RA36.2
  IN1 w0.114: v2(249.11,25.01) 249.17,25.07 249.39,25.07 249.71,24.76 255.98,24.76 256.66,25.43 259.93,25.43 260.29,25.07 261.65,25.07 263,26.42 270.05,26.42 270.69,27.05 271.03,27.05 271.15,26.93 271.15,26.78 v2(270.95,26.58)
  BOTTOM w0.102: v2(249.11,25.01) 248.22,25.9 248.22,32.04 247.28,32.98 244.21,32.98 242.83,34.36 242.7,34.36 242.65,34.41 240.78,34.41 240.21,34.98 240.21,36.3 EC5205.1 RZ42.2
