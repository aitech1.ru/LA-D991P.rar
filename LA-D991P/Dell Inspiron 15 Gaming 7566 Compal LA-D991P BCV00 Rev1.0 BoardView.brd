# Allegro board Dell Inspiron 15 Gaming 7566 Compal LA-D991P BCV00 Rev1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3VS_CAM: length 0.7
  TOP w0.127: v2(230.87,48.25) v3(230.87,47.54)
+3VS_DTH: length 10.1
  TOP w0.508: RM5.2 261.45,28.56 v2(261.38,28.56) ; RM23.1 RM20.1 263.84,43.37 264.3,42.92 v2(264.3,42.54) ; v2(270.77,28.56) 270.69,28.64 CM40.1 269.58,28.64 268.67,27.73 UM2.8 ; v2(269.38,27.12) 269.63,26.86 RM10.1 ; RM7.2 v2(264.04,28.44) ; RM14.1 v2(270.9,42.54)
  BOTTOM w0.508: RM14.1 v2(270.9,42.54) ; v2(264.3,42.54) 263.97,42.54 RM6.1
  vias: v2(270.27,43.32) v2(270.9,29.23) v3(268.36,45.1)
+3VS_TP: length 137.2
  TOP w0.254: v2(151.46,19.68) 151.84,19.68 152.66,18.85 152.66,13.13 151.52,11.99 149.74,11.99 149.17,12.56 v2(149.17,13.52) 148.6,13.52 148.47,13.39 147.01,13.39 v2(146.57,13.83) v3(146.57,15.53) 146.17,15.93 141.92,15.93 RE123.1 141.42,15.75 141.17,15.49 v2(141.17,15.21)
  TOP w0.508: QE13.2 133.69,17.91 134.52,17.09 134.52,16.37 134.16,16.01 134.16,15.77
  IN2 w0.254: v2(151.46,19.68) 151.83,19.68 154.21,17.29 158.2,17.29 158.99,16.5 158.99,16.27 160.06,15.2 161,15.2 161.93,16.14 162.9,16.14 163.83,15.22 168.07,15.22 170.11,13.17 174.3,13.17 175.52,11.95 179.28,11.95 179.4,12.08 179.41,12.08 179.57,12.25 179.58,12.25 183.46,16.12 187.39,16.12 187.4,16.13 187.52,16.13 189.17,17.78 191.87,17.78 192.45,18.37 197.27,18.37 200.29,21.39 209.05,21.39 209.78,20.67 212.53,20.67 212.76,20.89 213.68,20.89 214.29,20.28 214.29,20.28 214.33,20.25 216.15,20.25 216.86,19.54 220.01,19.54 221.27,20.79 222.54,20.79 224.57,22.82 229.27,22.82 230.08,23.64 232.39,23.64 233.11,24.35 v2(234.32,24.35)
  IN2 w0.381: v2(131.89,15.51) 131.89,15.62 132.2,15.94 140.44,15.94 v2(141.17,15.21)
  BOTTOM w0.254: RE9.2 v2(151.46,19.68) ; v2(146.57,13.83) 146.28,13.54 DE4.5 ; RE7.2 149.81,13.77 149.55,13.52 v2(149.17,13.52) ; v2(234.32,24.35) 234.32,23.29 234.52,23.1 RE24.1 RE55.1
  BOTTOM w0.508: JTP.8 132.03,15.65 v2(131.89,15.51)
+3VS_WLAN: length 7.3
  BOTTOM w0.254: v2(200.92,27.68) 200.92,27.96 201.28,28.31 201.71,28.31 202.06,28.66 JNGFF1.64 ; v2(201.53,27.68) 201.97,27.68 202.47,28.18 202.47,28.59 202.56,28.68 JNGFF1.66
  BOTTOM w0.305: JNGFF1.2 184.56,28.3 v2(184.52,28.26) ; v2(185.15,28.26) 185.06,28.35 JNGFF1.4
  vias: v2(198.38,33.72) v2(198.38,33.09) v3(198.21,30.11) v3(198.59,27.78) v3(199.96,28.92)
+5V_AVDD:
  vias: v3(287.97,18.46)
+5V_CHGUSB_1:
  vias: v2(290.54,31.33) v2(290.52,29.39) v2(290.56,30.75) v2(290.57,30.14) v2(293.2,29.45) v2(293.2,28.74) v2(293.74,29.9) v2(293.72,29.1) v2(293.66,27.75) v2(293.99,28.26) v2(295.28,26.23) v2(295.95,26.23) v3(294.29,28.74)
+5V_CHGUSB_2:
  vias: v2(284.01,37) v2(284.19,37.58) v2(284.59,37) v2(284.77,37.56) v2(285.23,36.97) v2(285.38,37.56) v2(291.42,41.32) v2(291.42,40.63) v2(291.47,40.02) v2(292.01,41.57) v2(291.98,40.93) v2(291.98,40.35) v2(294.12,48.35) v2(294.37,47.79) v2(294.73,48.33) v3(293.46,43.68)
+5V_PVDD: length 11.2
  TOP w0.203: HDA1.41 281.91,28.3 282.02,28.41 282.02,29.31 282.03,29.31 282.03,30.42 281.57,30.88 CA14.1 ; CA12.1 279.41,30.72 279.08,30.39 279.08,29.1 279.91,28.26 HDA1.46
  TOP w0.508: CA11.1 279.33,30.98 CA12.1 279.49,30.98 CA13.1 281.49,30.98 CA14.1 281.75,31.08 v2(282.43,31.08)
  vias: v1(292.58,24.88) v2(277.5,30.57) v2(277.94,30.11) v2(278.52,30.14) v2(291.35,24.88) v2(291.98,25.14) v2(292.24,24.5)
+5VALW: length 312
  TOP w0.203: UZ1.4 v2(216.24,12.94)
  TOP w0.254: UZ16.4 74.21,48.91 ; RW4.2 206.44,33.34 205.88,33.9 205.11,33.9 204.61,33.39 204.21,33.39 v2(203.54,32.71) ; UZ17.4 v2(166.52,72.27)
  TOP w0.305: JPW.1 201.1,34.23 201.46,33.87 202.34,33.87 203.03,33.19 203.06,33.19 v2(203.54,32.71) ; CZ97.1 130.72,99.08 130.8,99.01 UZ15.3
  TOP w0.508: 11.64,21.86 11.67,21.83 13.57,21.83 v2(14.03,22.29) 14.64,22.29 15.25,22.9 15.25,25.14 14.31,26.08 PR104.2 ; v2(69.03,52.06) 72.1,52.06 74.21,49.94 74.21,48.91 ; v2(136.98,114.61) 137.72,114.61 138.19,114.14 138.19,111.29 137.68,110.78 137.68,108.58 136.76,107.66 135.72,107.66 130.72,102.66 v2(130.72,100.6) CZ97.1 ; v2(142.12,18.13) 142.61,18.61 142.61,22.49 144.05,23.94 v2(144.05,28.5) ; 253.78,23.94 248.88,23.94 248.49,24.33 JLED.4 ; RV534.1 v2(151.06,74.89) ; v2(197.69,13.07) 197.69,19.21 199.86,21.38 v2(199.86,25.05)
  IN1 w0.508: v2(166.52,72.27) 166.52,72.75 166,73.28 163.29,73.28 162.93,72.91 158.48,72.91 157.49,73.9 153.93,73.9 153.3,74.54 151.42,74.54 v2(151.06,74.89)
  IN2 w0.508: v2(199.86,25.05) 202.25,27.44 202.25,29.67 203.16,30.57 203.16,31.34 203.15,31.35 203.15,32.3 203.54,32.69 v2(203.54,32.71)
  IN3 w0.508: v2(58.73,22.55) 58.99,22.29 61.07,22.29 62.62,23.84 62.62,29.66 63.69,30.72 65.19,30.72 66.56,32.1 66.56,43.96 67.01,44.41 67.01,50.04 v2(69.03,52.06) ; v2(151.06,74.89) 149.13,74.89 148.37,75.66 148.15,75.66 146.21,77.6 146.21,81.27 144.92,82.56 v2(144.92,83.65) 140.64,87.92 139.71,87.92 139.18,88.45 139.14,88.45 134.25,93.34 134.25,95.42 133.39,96.28 133.23,96.28 130.72,98.79 v2(130.72,100.6) ; v2(254.13,29.72) 254.13,30.28 252.27,32.15 250.38,32.15 248.78,33.75 248.78,34.1 245.98,36.9 244.31,36.9 243.38,35.97 238.43,35.97 236.47,37.93 236.47,42.34 235.52,43.3 233.84,43.3 226.81,50.33 222.18,50.33 219.44,53.08 219.44,57.6 v2(215.2,61.84)
  BOTTOM w0.254: CZ86.1 131.82,100.27 132.63,100.27 UZ9.3
  BOTTOM w0.457: RH506.1 285.73,59.73 RW3.2 284.95,58.89 v2(284.42,59.42)
  BOTTOM w0.508: RH504.1 13.6,21.86 v2(14.03,22.29) 14.67,22.93 RH505.1 ; v2(144.05,28.5) 142.25,28.5 141.23,29.52 141.23,32.76 140.09,33.9 140.09,38.47 139.58,38.98 139.58,41.52 140.24,42.18 140.24,51.76 139.38,52.62 139.38,63.19 134.63,67.94 134.63,73.41 134.86,73.64 134.86,74.83 135.52,75.5 137.09,75.5 137.63,76.04 138.44,76.04 138.87,76.47 138.87,77.9 140.41,79.44 143.67,79.44 145.6,81.37 145.6,82.96 v2(144.92,83.65) ; v2(130.72,100.6) 130.77,100.65 CZ86.1 ; v2(215.2,61.84) 215.14,61.9 JUART.1
  vias: v2(10.03,19.33) v2(10.03,18.67) v2(10.67,19.33) v2(10.67,18.67) v2(11.3,19.33) v2(11.3,18.67) v2(37.35,31.36) v2(37.35,30.72) v2(37.35,30.09) v2(37.35,29.45) v2(37.35,28.82) v2(37.86,31.04) v2(37.86,30.41) v2(37.86,29.77) v2(37.86,29.14) v2(38.36,31.36) v2(38.36,30.72) v2(38.36,30.09) v2(38.36,29.45) v2(38.36,28.82) v2(38.87,31.04) v2(38.87,30.41) v2(38.87,29.77) v2(138.39,17.95) v2(138.99,17.95) v2(215.86,10.91) v2(216.24,12.08) v2(216.49,10.91) v2(216.85,12.08) v2(217.08,10.91) v2(217.46,12.08) v2(217.66,10.91) v2(218.07,12.11) v2(218.25,10.89) v2(218.83,10.86) v2(219.42,12.08) v2(242.02,18.1) v2(242.4,18.58) v2(242.86,18.13) v2(243.14,18.64) v2(243.52,18.1) v2(243.85,18.61) v2(255.69,22.75) v2(256.3,22.72) v2(279.28,37.51) v2(279.89,38.09) v2(279.89,37.51) v2(280.48,38.09) v2(280.48,37.48) v2(281.14,38.12) v2(290.89,35.47) v2(290.92,34.86) v2(291.5,35.5) v2(291.55,34.89) v2(292.11,35.5) v2(292.21,34.89) v3(11.26,20.54) v3(36.56,29.53) v3(253.5,28.84)
+5VALWP: length 68.8
  IN1 w0.254: v2(49.41,21.95) 49.28,21.95 46.87,19.55 44.03,19.55 42.41,17.93 41.05,17.93 40.45,18.53 40.45,24.44 35.7,29.2 v2(35.7,33.39) ; v2(35.06,33.39) 35.06,29.21 40.06,24.21 40.06,18.35 40.94,17.47 42.61,17.47 44.24,19.1 47.13,19.1 49.48,21.44 50.34,21.44 51.75,22.85 53.96,22.85 55.59,24.48 v2(57.24,24.48)
  BOTTOM w0.203: PU400.14 v2(49.41,21.95)
  BOTTOM w0.254: PC402.2 PR402.2 57.01,25.14 57.24,24.91 v2(57.24,24.48)
  vias: v2(35.06,34.03) v2(35.7,34.03) v2(36.33,34.03) v2(36.33,33.39) v2(36.97,34.03) v2(36.97,33.39) v2(37.6,34.03) v2(37.6,33.39) v2(38.24,35.3) v2(38.24,34.66) v2(38.24,34.03) v2(38.24,33.39) v2(38.87,35.3) v2(38.87,34.66) v2(38.87,34.03) v2(38.87,33.39) v3(37.04,35.25)
+5VS: length 596.3
  TOP w0.508: F1.2 125.74,15.97 125.74,14.87 CE5.1 126.98,14.85 v2(127.12,14.71) ; 131.48,131.03 132.34,130.17 PR1531.1 ; 131.48,131.03 v2(131.48,131.21) ; 131.48,131.03 131.48,128.67 130.82,128.01 PR1533.1 ; v2(92.72,132.71) 92.72,132.45 90.69,130.42 v2(90.69,130.29) PR1500.1 90.83,129.47 91.13,129.47 92.11,128.49 92.11,126.76 88.86,123.51 83.07,123.51 82.12,124.45 63.92,124.45 63.31,123.84 63.31,113.6 v3(65.03,111.88) v2(66.56,110.35) 66.56,110.1 70.37,106.29 v2(70.62,106.29) ; 214.13,36.31 RE1.2 ; 214.13,36.31 214.13,36.82 214.41,37.1 214.41,38.52 215.05,39.16 217.37,39.16 218.84,40.63 235.42,40.63 238.38,37.67 v2(239.23,37.67) ; 214.13,36.31 v2(213.6,36.31) 212.33,36.31 211.82,35.81 211.82,35.18 212.17,34.83 212.17,32.6 QE4.3 ; PR1400.1 121.29,129.73 v2(121.8,129.73) 122.13,129.73 123.68,131.28 123.68,132.68 v2(123.71,132.71) ; v2(80.43,79.49) 80.43,79.06 85.28,74.21 85.28,65.41 76.12,56.25 67.86,56.25 67.17,55.57 67.16,55.57 65.36,53.76 65.36,52.87 v2(65.34,52.85) ; v2(111.58,129.47) 111.31,129.73 PR1414.1 110.88,130.17 111.77,131.05 111.77,131.69 v2(112.79,132.71) ; RZ26.1 64.53,33.01 v2(64.78,32.76) ; PR1428.1 100.97,130.17 v2(100.85,130.29) v2(103.13,132.58) ; v2(209.61,39.23) 208.29,40.55 208.29,57.56 PR1030.1
  IN1 w0.508: v2(67.19,97.15) 67.32,97.15 68.84,95.62 68.84,93.59 69.73,92.7 73.8,92.7 80.02,86.48 81.29,86.48 82.81,84.95 82.81,81.4 80.91,79.49 v2(80.43,79.49) 79.92,80 v2(72.78,80) ; v2(112.79,132.71) 112.79,132.32 113.47,131.64 114.53,131.64 114.61,131.56 122.97,131.56 123.71,132.3 v2(123.71,132.71)
  IN1 w1.016: 295.49,62.66 292.25,59.43 292.25,49.84 292.85,49.24 292.85,46.85 294.83,44.87 294.83,36.57 294.19,35.93 294.19,33.49 293.18,32.48 291.86,32.48 291.32,33.01 288.4,33.01 287.33,31.94 282.05,31.94 281.57,31.46 277.34,31.46
  IN2 w0.508: v2(103.13,132.58) 103.13,132.96 ; 103.13,132.96 102.63,133.47 93.23,133.47 92.72,132.96 v2(92.72,132.71) ; 103.13,132.96 103.64,133.47 112.35,133.47 112.74,133.09 112.74,132.76 v2(112.79,132.71) ; v2(70.62,106.29) 67.95,103.62 67.95,97.91 v2(67.19,97.15) ; v2(64.78,32.76) 63.94,32.76 63.56,32.38 63.56,30.14 62.87,29.45 61.15,29.45 60.94,29.66 56.6,29.66 ; v2(213.6,36.31) 209.43,36.31 209.05,36.69 209.05,37.43 209.61,37.99 v2(209.61,39.23) 207.71,39.23 199.83,47.11 194.42,47.11 192.14,49.39 177.68,49.39 v2(176.69,50.38)
  IN2 w1.016: 55.97,29.17 55.97,23.82 57.62,22.16 57.62,17.74 60.08,15.28 61.71,15.28 63.7,17.27 92.12,17.27 94.47,14.93 100.19,14.93 100.32,15.06 101.94,15.06 102.08,14.93 109.76,14.93 111.4,13.29 124.1,13.29 125.76,14.94 126.89,14.94 v2(127.12,14.71)
  IN3 w0.508: v2(171.84,50.41) 171.97,50.28 176.59,50.28 v2(176.69,50.38) ; v2(123.71,132.71) 123.71,132.93 124.22,133.44 129.42,133.44 131.48,131.38 v2(131.48,131.21) ; v2(64.78,32.76) 64.53,32.76 63.43,33.85 63.43,39.07 64.89,40.53 64.89,42.79 63.55,44.14 63.55,44.8 64.6,45.85 64.6,52.11 v2(65.34,52.85)
  IN3 w1.016: 246.62,37.61 247.3,37.61 250.2,34.71 251.66,34.71 257.64,28.73 257.64,26.74 258.18,26.2 ; 195.84,11.17 195.1,10.42 185.19,10.42 183.14,8.36 182.17,8.36 180.86,7.05 172.05,7.05 171.21,7.89 171.1,7.89 166.44,12.55 160.55,12.55 157.54,15.56 151.34,15.56 151.2,15.42 147.83,15.42 145.67,17.58 143.74,17.58 142.63,16.47 128.88,16.47 v2(127.12,14.71)
  BOTTOM w0.305: v2(257.24,20.64) 257.21,20.64 257.26,20.69 257.64,20.69 RA74.1
  BOTTOM w0.381: v2(123.71,132.71) 123.66,132.65 123.65,132.65 123.49,132.49 123.49,132.31 PR1402.1
  BOTTOM w0.508: PR1403.1 v2(121.8,129.73) ; PR1504.1 90.69,129.67 v2(90.69,130.29) ; v2(70.62,106.29) PR1516.1 PR1512.1 ; PR1028.2 177.05,50.03 v2(176.69,50.38) ; PR1418.1 111.31,129.73 v2(111.58,129.47) ; PR1432.1 100.91,130.23 v2(100.85,130.29) ; v2(92.72,132.71) 92.72,132.02 PR1502.1 ; PR1416.1 v2(112.79,132.71) ; PR1016.2 v2(171.84,50.41) ; PR1514.1 v2(66.56,110.35) ; PR1430.1 v2(103.13,132.58) ; PR1101.1 v2(72.78,80)
  vias: v2(56.52,30.55) v2(56.77,29.97) v2(207.9,11.56) v2(207.9,10.98) v2(207.9,10.39) v2(207.96,12.17) v2(208.48,11.56) v2(208.48,10.98) v2(208.48,10.39) v2(208.58,13.06) v2(209.22,13.05) v2(209.76,12.83) v2(209.78,12.22) v2(210.41,12.8) v2(210.4,12.21) v2(242.45,36.82) v2(242.91,37.2) v2(256.73,19.88) v2(258.91,25.85) v2(259.52,25.85) v2(270.24,21.76) v2(270.5,21.17) v2(270.85,21.71) v2(271.1,21.17) v2(271.54,21.58) v2(273.19,29.45) v2(273.57,29.91) v2(273.95,30.37) v2(296.25,63.67) v2(296.28,63.06)
+5VS_HDD: length 6.2
  TOP w0.102: v2(195.39,13.79) 195.39,14.61 v3(196.54,15.76)
  TOP w0.127: v3(196.61,11.7) 195.39,12.92 v2(195.39,13.79) v3(196.58,13.79)
+5VS_KBL: length 8.4
  TOP w0.508: v2(121.83,14.77) 121.9,14.85 CE4.1 122.74,14.65 CE6.1 123.44,15.88 F1.1
  BOTTOM w0.508: v3(123.71,17.14) 123.35,17.49 121.96,17.49 121.59,17.13 JBL1.1 121.59,15.01 v2(121.83,14.77)
+5VS_TS: length 1.7
  TOP w0.102: v2(61.73,33.01) 61.73,32.58 v3(61.48,32.32)
  TOP w0.508: RZ26.2 v2(61.73,33.01)
+19VB_1VALWP:
  vias: v1(253.15,18.2) v2(253.37,18.79) v2(254.26,18.79)
+19VB_+0.95VSP:
  vias: v3(68.44,72.96)
+19VB_+1.05VSP:
  vias: v2(222.67,46.47) v2(223.1,46.9) v2(223.53,46.47) v3(225.05,50.21)
+VCC_CORE: length 25.5
  BOTTOM w0.102: UH1.L14 122.21,81.96 UH1.K14 122.92,82.01 ; UH1.L14 121.55,81.91 ; UH1.L14 121.98,82.62 ; 122.72,81.85 UH1.K13 122.69,81.32 ; 121.51,81.31 121.66,81.31 UH1.L13 122.33,81.55 v2(122.44,81.66)
  BOTTOM w0.152: UH1.P13 118.82,81.87 ; UH1.P13 119.47,81.55 ; UH1.P13 119.06,81.46 118.32,81.46 UH1.R13 118.56,81.87 v2(118.69,81.87) 118.82,81.87 ; 118.82,81.87 UH1.P14 ; UH1.P14 119.46,81.89 ; UH1.P14 119.46,82.51 ; 114.04,81.76 113.82,81.55 UH1.AA13 113.53,81.55 v2(113.21,81.87) 112.88,82.2 UH1.AC14 ; 115.8,81.89 UH1.W14 ; UH1.W14 115.8,82.51 ; UH1.W14 115.18,82.51 ; UH1.W14 UH1.W13 115.7,81.55 115.83,81.67 ; UH1.AC14 112.58,82.2 v2(112.25,81.87) ; UH1.AC14 112.75,82.71 ; UH1.AC14 UH1.AC13 112.61,81.55 112.29,81.87 v2(112.25,81.87) ; 116.09,82.51 UH1.V14 ; UH1.V14 116.09,81.89 ; UH1.V14 116.72,82.51 ; UH1.V14 UH1.V13 116.19,81.55 116.08,81.66 ; v2(112.25,81.87) 111.93,82.2 UH1.AD14 ; v2(112.25,81.87) 111.93,81.55 UH1.AD13 111.58,81.55 111.51,81.62 ; 119.75,81.86 UH1.N13 120.37,81.86 ; 111.52,82.51 UH1.AD14 ; UH1.AD14 111.52,81.89 ; 111.24,81.6 111.19,81.55 UH1.AE13 UH1.AE14 ; UH1.AE14 111.23,81.89 ; UH1.AE14 111.23,82.51 ; 119.75,81.89 UH1.N14 120.37,81.89
  BOTTOM w0.254: RH197.1 108.12,106.3 109.28,105.15 v2(109.28,104.46)
  vias: v2(103.77,113.27) v2(103.77,112.64) v2(103.77,112) v2(103.77,111.37) v2(104.4,113.27) v2(104.4,112.64) v2(104.4,112) v2(104.4,111.37) v2(105.04,113.27) v2(105.04,112.64) v2(105.04,112) v2(105.04,111.37) v2(105.67,113.27) v2(105.67,112.64) v2(105.67,112) v2(105.67,111.37) v2(106.31,113.27) v2(106.31,112.64) v2(106.31,112) v2(106.31,111.37) v2(106.94,113.27) v2(106.94,112.64) v2(106.94,112) v2(106.94,111.37) v2(107.58,112) v2(107.58,111.37) v2(108.21,112) v2(108.21,111.37) v2(108.98,112) v2(108.98,111.37) v2(109.48,90.8) v2(109.48,90.16) v2(109.48,89.53) v2(109.48,88.76) v2(109.61,112) v2(109.61,111.37) v2(110.11,101.83) v2(110.25,100.03) v2(110.25,98.73) v2(110.25,96.13) v2(110.74,101.83) v2(110.85,92.51) v2(111.04,100.68) v2(111.04,99.38) v2(111.04,98.08) v2(111.38,101.83) v2(111.4,81.86) v2(111.52,111.62) v2(111.49,111.01) v2(111.83,100.03) v2(111.83,98.73) v2(111.83,97.43) v2(111.83,96.13) v2(111.9,110.23) v2(111.9,109.46) v2(111.9,108.83) v2(112.01,101.83) v2(112.13,111.01) v2(112.15,111.62) v2(112.53,110.23) v2(112.53,109.46) v2(112.53,108.83) v2(112.61,98.08) v2(112.61,96.78) v2(112.61,95.49) v2(112.65,101.83) v2(112.76,111.01) v2(112.75,92.51) v2(112.91,111.62) v2(112.91,85.59) v2(112.94,90.72) v2(112.94,90.08) v2(112.94,89.45) v2(112.94,88.81) v2(113.17,110.23) v2(113.17,109.46) v2(113.17,108.83) v2(113.28,101.83) v2(113.4,111.01) v2(113.4,100.03) v2(113.4,98.73) v2(113.4,96.13) v2(113.55,85.59) v2(113.67,113.53) v2(113.67,112.89) v2(113.67,112.26) v2(113.67,111.62) v2(113.8,110.23) v2(113.8,109.46) v2(113.8,108.83) v2(113.92,101.83) v2(114.06,111.01) v2(114.19,100.68) v2(114.19,99.38) v2(114.19,98.08) v2(114.19,96.78) v2(114.31,113.53) v2(114.31,112.89) v2(114.31,112.26) v2(114.31,111.62) v2(114.55,101.83) v2(114.59,92.51) v2(114.69,111.01) v2(114.94,113.53) v2(114.94,112.89) v2(114.94,112.26) v2(114.94,111.62) v2(114.98,98.73) v2(114.99,97.42) v2(114.98,96.13) v2(114.96,95.49) v2(115.05,82.53) v2(115.19,101.83) v2(115.33,111.01) v2(115.58,113.53) v2(115.58,112.89) v2(115.58,112.26) v2(115.58,111.62) v2(115.82,101.83) v2(115.76,100.68) v2(115.76,99.38) v2(115.76,98.08) v2(115.96,111.01) v2(116.21,113.53) v2(116.21,112.89) v2(116.21,112.26) v2(116.21,111.62) v2(116.46,101.83) v2(116.5,92.43) v2(116.6,111.01) v2(116.55,100.68) v2(116.55,100.03) v2(116.55,98.73) v2(116.55,97.43) v2(116.55,96.13) v2(116.85,112) v2(116.89,82.53) v2(117.03,87.9) v2(117.09,101.83) v2(117.23,111.5) v2(117.23,110.86) v2(117.23,110.23) v2(117.23,109.59) v2(117.23,108.96) v2(117.34,99.38) v2(117.34,98.08) v2(117.34,96.78) v2(117.34,95.49) v2(117.31,85.99) v2(117.73,101.83) v2(117.8,111.18) v2(117.8,110.42) v2(117.8,109.78) v2(118.13,100.68) v2(118.13,100.03) v2(118.13,98.73) v2(118.13,96.13) v2(118.28,92.43) v2(118.69,85.81) v2(118.91,99.38) v2(118.89,98.75) v2(118.91,98.08) v2(118.88,97.43) v2(118.91,96.78) v2(118.91,96.15) v2(119.49,87.9) v2(119.62,81.83) v2(119.65,100.7) v2(119.68,99.37) v2(119.67,98.74) v2(119.68,96.77) v2(121.29,112) v2(121.29,111.37) v2(121.93,112) v2(121.93,111.37) v2(122.03,110.61) v2(122.03,109.97) v2(122.03,109.34) v2(122.56,113.4) v2(122.56,112.77) v2(122.56,112.13) v2(122.56,111.5) v2(122.56,110.86) v2(122.56,110.23) v2(122.56,109.59) v2(122.56,108.96) v2(123.2,113.4) v2(123.2,112.77) v2(123.2,112.13) v2(123.2,111.5) v2(123.2,110.86) v2(123.2,110.23) v2(123.2,109.59) v2(123.2,108.96) v2(123.83,113.4) v2(123.83,112.77) v2(123.83,112.13) v2(123.83,111.5) v2(123.83,110.86) v2(123.83,110.23) v2(123.83,109.59) v2(123.83,108.96) v2(124.47,113.4) v2(124.47,112.77) v2(124.47,112.13) v2(124.47,111.5) v2(124.47,110.86) v2(124.47,110.23) v2(124.47,109.59) v2(124.47,108.96) v2(125.1,113.4) v2(125.1,112.77) v2(125.1,112.13) v2(125.1,111.5) v2(125.1,110.86) v2(125.1,110.23) v2(125.1,109.59) v2(125.1,108.96) v2(125.74,112) v2(125.74,111.37) v2(126.37,112) v2(126.37,111.37) v3(124.55,115.28)
+VCCGT: length 40.6
  TOP w0.381: v2(105.38,91.24) 104.98,91.24 PC1375.1 104.61,91.6 PC1376.1
  TOP w0.508: PC1372.1 102.02,84.16 v2(102.51,84.16) ; PC1363.1 104.5,84.1 v2(104.93,84.1) ; v2(95.27,84.16) 94.78,84.16 PC1378.1 ; PC1314.1 97.03,91.63 PC1379.1 95.81,91.4 v2(95.36,91.4) ; v2(95.58,89.8) 96.19,89.8 PC1311.1 97.74,90 PC1306.1 ; v2(101.32,89.97) 101.72,89.97 PC1348.1 103.2,90.26 PC1354.1 ; PC1373.1 99.61,84.16 v2(100.1,84.16) ; v2(97.69,84.16) 97.19,84.16 PC1374.1 ; v2(101.48,85.74) 102.09,85.74 PC1300.1 103.12,85.95 PC1350.1 ; v2(95.51,88.12) 95.67,87.96 96.13,87.96 PC1305.1 97.62,88.18 PC1310.1
  BOTTOM w0.152: UH1.AN14 104.65,82.2 v2(104.98,81.87) ; UH1.AN14 104.21,81.89 ; UH1.AN14 104.21,82.51 ; v2(97.65,81.91) 97.93,82.2 UH1.BA14 ; v2(97.65,81.91) 97.37,82.2 UH1.BB14 ; v2(97.65,81.91) 97.28,81.55 UH1.BB13 96.93,81.55 96.85,81.62 ; v2(97.65,81.91) 98.02,81.55 UH1.BA13 UH1.BA14 ; v2(104.98,81.87) 104.65,81.55 UH1.AN13 104.35,81.55 104.22,81.67 ; v2(104.98,81.87) 105.3,82.2 UH1.AM14 ; v2(104.98,81.87) 105.3,81.55 UH1.AM13 ; 101.46,81.89 UH1.AT14 ; UH1.AT14 101.46,82.51 ; UH1.AT14 102.09,82.51 ; UH1.AM13 UH1.AM14 ; UH1.AM13 UH1.AL13 ; 100.26,82.51 UH1.AW14 ; UH1.AW14 99.63,81.89 ; UH1.AW14 99.63,82.51 ; 94.15,81.89 UH1.BF14 ; UH1.BF14 94.77,81.89 ; UH1.BF14 94.77,82.51 ; UH1.BF14 94.15,82.51 ; UH1.AM14 105.43,82.64 105.43,82.65 ; UH1.AM14 105.61,82.02 105.88,82.02 UH1.AL13 ; 96.89,82.51 UH1.BB14 ; UH1.BB14 96.89,81.89 ; 94.15,81.86 UH1.BF13 94.77,81.86 ; UH1.AL13 106.43,81.55 106.7,81.81 ; 95.06,81.89 UH1.BD14 ; UH1.BD14 95.51,82.2 v2(95.83,81.87) 95.51,81.55 UH1.BD13 95.16,81.55 95.02,81.69 ; UH1.BD14 95.06,82.51 ; 103.29,82.51 UH1.AP14 ; UH1.AP14 103.92,82.51 ; UH1.AP14 UH1.AP13 103.79,81.55 103.9,81.66 ; UH1.AP14 103.92,81.89 ; UH1.BA14 98.12,82.63 98.12,82.64 ; 101.17,82.51 UH1.AU14 ; UH1.AU14 101.17,81.89 ; UH1.AU14 100.55,82.51
  BOTTOM w0.254: RH203.1 107.62,102.01
  vias: v2(84.44,112) v2(84.44,111.34) v2(84.46,114.54) v2(84.46,113.91) v2(84.46,113.27) v2(84.46,112.64) v2(85.1,114.54) v2(85.1,113.91) v2(85.1,113.27) v2(85.1,112.64) v2(85.07,112) v2(85.07,111.37) v2(85.73,114.54) v2(85.73,113.91) v2(85.73,113.27) v2(85.73,112.64) v2(85.71,112) v2(85.71,111.29) v2(86.37,114.54) v2(86.37,113.91) v2(86.37,113.27) v2(86.37,112.64) v2(86.34,112) v2(86.34,111.37) v2(87,114.54) v2(87,113.91) v2(87,113.27) v2(87,112.64) v2(86.98,112) v2(87.64,114.54) v2(87.64,113.91) v2(87.64,113.27) v2(88.27,114.54) v2(88.27,113.91) v2(89.05,98.89) v2(90,101.46) v2(90.31,113.32) v2(90.28,112.74) v2(90.28,112.11) v2(90.28,111.47) v2(90.28,110.84) v2(90.54,101.78) v2(90.92,112.74) v2(90.92,112.11) v2(90.92,111.47) v2(90.92,110.84) v2(90.94,113.32) v2(91.17,101.78) v2(91.58,113.32) v2(91.55,112.74) v2(91.55,112.11) v2(91.55,111.47) v2(91.55,110.84) v2(91.81,101.78) v2(92.21,113.32) v2(92.19,112.74) v2(92.19,112.11) v2(92.19,111.47) v2(92.19,110.84) v2(92.14,100.71) v2(92.44,101.78) v2(92.82,112.74) v2(92.82,112.11) v2(92.82,111.47) v2(92.82,110.84) v2(92.85,113.32) v2(92.93,100.03) v2(92.93,98.73) v2(92.93,98.08) v2(92.93,96.13) v2(93.08,101.78) v2(93.48,113.32) v2(93.46,112.74) v2(93.46,112.11) v2(93.46,111.47) v2(93.71,101.78) v2(93.72,98.08) v2(93.72,96.78) v2(93.72,95.49) v2(93.72,94.07) v2(94.12,113.32) v2(94.09,112.74) v2(94.09,112.11) v2(94.09,111.47) v2(94.35,101.78) v2(94.5,100.03) v2(94.5,98.73) v2(94.5,96.13) v2(94.7,113.32) v2(94.68,112.74) v2(94.68,112.11) v2(94.68,111.47) v2(94.92,82.52) v2(94.98,101.78) v2(95.29,100.68) v2(95.29,99.38) v2(95.29,98.08) v2(95.29,96.78) v2(95.45,85.74) v2(95.62,101.78) v2(95.89,112.77) v2(95.89,112.11) v2(95.89,111.5) v2(96.08,98.73) v2(96.08,97.43) v2(96.08,96.13) v2(96.08,95.49) v2(96.25,101.76) v2(96.53,112.77) v2(96.53,112.16) v2(96.53,111.52) v2(96.5,110.89) v2(96.75,82.51) v2(96.91,101.75) v2(96.87,100.68) v2(96.87,99.38) v2(97.16,112.77) v2(97.16,112.16) v2(97.16,111.52) v2(97.16,110.89) v2(97.56,101.75) v2(97.65,100.03) v2(97.65,98.73) v2(97.65,97.43) v2(97.65,96.13) v2(97.8,112.77) v2(97.8,112.16) v2(97.8,111.52) v2(97.83,110.94) v2(98.2,101.75) v2(98.43,112.77) v2(98.43,112.16) v2(98.43,111.52) v2(98.46,110.94) v2(98.44,98.08) v2(98.44,96.78) v2(98.44,95.49) v2(99.07,112.77) v2(99.07,112.16) v2(99.07,111.52) v2(99.1,110.94) v2(99.23,100.03) v2(99.23,98.73) v2(99.23,96.13) v2(99.7,112.77) v2(99.7,112.16) v2(99.7,111.52) v2(99.73,110.94) v2(100.02,100.68) v2(100.02,99.38) v2(100.02,98.08) v2(100.02,96.78) v2(100.34,112.77) v2(100.34,112.16) v2(100.34,111.52) v2(100.34,110.91) v2(100.29,91.25) v2(100.4,82.52) v2(100.8,98.73) v2(100.8,97.43) v2(100.8,96.13) v2(100.81,95.5) v2(100.97,112.77) v2(100.97,112.16) v2(100.97,111.52) v2(100.97,110.91) v2(101.29,88) v2(101.34,88.6) v2(101.61,112.74) v2(101.61,112.13) v2(101.61,111.5) v2(101.61,110.89) v2(101.59,100.68) v2(101.59,99.38) v2(102.38,100.03) v2(102.38,98.73) v2(102.38,97.43) v2(102.38,96.13) v2(103.17,98.08) v2(103.17,96.78) v2(103.17,95.49) v2(103.95,100.03) v2(103.95,98.73) v2(103.95,96.13) v2(104.06,81.87) v2(104.72,96.15) v2(104.74,100.68) v2(104.74,99.38) v2(104.74,98.08) v2(104.74,96.78) v2(105.52,100.69) v2(105.53,98.73) v2(105.53,96.13) v2(106.32,100.03) v2(106.32,99.38) v2(106.32,98.08) v2(106.32,96.78) v2(106.44,89.52) v2(106.48,86.87) v2(107.1,98.73) v2(107.1,97.43) v2(107.1,96.13) v2(107.89,98.08) v2(107.89,96.78) v2(107.89,95.49) v3(86.93,115.99)
+VCCIO: length 67.4
  TOP w0.508: RH515.2 124.04,84.72 v2(124.01,84.75) 123.75,85.02 CH102.1 ; RH30.2 v2(127.14,101.72)
  IN2 w0.508: 121.8,93.47 121.8,94.1 120.58,95.32 120.58,101.01 119.85,101.74 119.85,102.43 120.18,102.76 121.7,102.76 122.59,103.65 125.36,103.65 127.14,101.87 v2(127.14,101.72)
  BOTTOM w0.102: UH1.J16 123.27,84.66 ; UH1.J16 122.65,84.66 ; UH1.J16 122.65,84.04 ; UH1.J16 123.27,84.04 ; UH1.G21 124.59,88 ; UH1.G21 124.02,88.57 ; UH1.G21 124.02,88 ; UH1.H15 123.92,83.25 ; UH1.H15 123.92,83.88 ; UH1.H15 123.3,83.88 ; UH1.H16 123.92,84.04 ; UH1.H16 123.3,84.04 ; UH1.H16 123.3,84.66 ; UH1.H16 123.92,84.66 ; 123.3,85.45 UH1.H17 ; UH1.H17 123.3,84.83 ; UH1.H17 123.92,85.45 ; UH1.H17 123.92,84.83 ; 122.65,92.54 UH1.J26 123.27,92.54 123.3,92.54 UH1.H26 ; 124.02,85.42 UH1.G17 124.02,84.85 ; 123.3,87.03 UH1.H19 ; UH1.H19 123.92,87.03 ; UH1.H19 123.3,86.4 ; UH1.H19 123.92,86.4 ; 123.3,87.81 UH1.H20 ; UH1.H20 123.92,87.81 ; UH1.H20 123.3,87.19 ; UH1.H20 123.92,87.19 ; 124.02,83.28 UH1.G15 124.02,83.85 ; UH1.J17 123.27,84.83 ; UH1.J17 122.65,85.45 ; UH1.J17 123.27,85.45 ; UH1.J17 122.65,84.83 ; UH1.H21 123.92,88.6 ; UH1.H21 123.3,88.6 ; UH1.H21 123.3,87.98 ; UH1.H21 123.92,87.98 ; 122.65,86.4 UH1.J19 ; UH1.J19 122.65,87.03 ; UH1.J19 123.27,86.4 ; UH1.J19 123.27,87.03 ; 122.65,88.6 UH1.J21 ; UH1.J21 122.65,87.98 ; UH1.J21 123.27,87.98 ; UH1.J21 123.27,88.6 ; 122.65,87.19 UH1.J20 ; UH1.J20 123.27,87.81 ; UH1.J20 122.65,87.81 ; UH1.J20 123.27,87.19 ; 123.27,83.88 UH1.J15 122.65,83.88 ; 124.02,86.43 UH1.G19 124.02,87 ; UH1.H27 123.3,92.7 123.27,92.7 UH1.J27 122.65,92.7
  BOTTOM w0.254: RH24.1 122.66,67.45 120.1,67.45 v2(119.75,67.1) ; UH1.AG12 109.56,81.37 109.56,82.77 110.2,83.4 119.03,83.4 119.8,82.64 120.18,82.64 120.94,83.4 121.9,83.4
  vias: v2(68.38,59.58) v2(68.42,58.9) v2(68.89,59.86) v2(68.89,59.27) v2(68.93,58.61) v2(69.43,60.16) v2(69.43,59.58) v2(69.43,58.92) v2(69.49,58.34) v2(122.39,91.96) v2(122.41,85.4) v2(122.43,84.1) v2(122.47,92.6) v2(122.49,89.63) v2(122.57,87.06) v2(124.01,87.9) v2(123.99,87.13) v2(124.01,86.32) v2(124.65,87.87) v2(129.37,82.79) v2(129.96,82.79) v2(130.59,82.79) v2(130.69,78.6) v2(131.23,82.79) v2(131.3,78.6) v2(131.86,82.79) v2(131.94,78.6) v3(68.36,58.31)
+VCCIO_PG: length 2.1
  TOP w0.102: RH103.1 192.08,23.52 PR712.2 v1(192.08,22.37)
+VCCSA: length 1.6
  BOTTOM w0.254: RH201.2 119.3,104.75 119.54,104.99 120.23,104.99
  vias: v2(120.95,93.83) v2(120.95,92.56) v2(121,90.87) v2(121.17,101.97) v2(121.14,89.42) v2(121.17,88.1) v2(121.29,100.68) v2(121.29,100.04) v2(121.29,99.41) v2(121.29,98.75) v2(121.3,98.08) v2(121.29,97.42) v2(121.29,96.79) v2(121.28,96.13) v2(122.03,100.04) v2(122.06,99.38) v2(122.06,98.75) v2(122.09,98.09) v2(122.06,96.78) v2(122.04,96.16) v2(122.84,98.75) v2(122.85,96.78) v2(131.45,111.12) v2(131.45,110.48) v2(131.45,109.85) v2(131.45,109.21) v2(132.09,111.12) v2(132.09,110.48) v2(132.09,109.85) v2(132.09,109.21) v2(132.72,111.12) v2(132.72,110.48) v2(132.72,109.85) v2(132.72,109.21) v2(133.36,111.12) v2(133.36,110.48) v2(133.36,109.85) v2(133.36,109.21) v2(133.36,108.58) v2(133.99,111.12) v2(133.99,110.48) v2(133.99,109.85) v2(133.99,109.21) v2(133.99,108.58) v3(135.14,111.45)
+VCCST: length 216.7
  TOP w0.508: RH164.1 130.74,77.53 131.21,77.99 131.24,77.99 131.25,77.99 132.11,77.99 v2(132.41,77.69) ; RH144.1 83.3,94.99 81.59,93.28 81.19,93.28 v2(81.18,93.29) ; v2(86.19,89.35) 85.91,89.63 RH151.1 85.84,90.21 RH152.1 84.97,89.93 82.99,87.95 v2(82.99,87.04)
  TOP w0.762: v2(146.8,45.51) 148.44,45.51 152.2,49.27 166.08,49.27 168.42,46.93 v3(170.22,46.93) 182.25,46.93 182.81,47.49 187.18,47.49 187.88,46.79 187.88,40.4 183.97,36.49 183.86,36.49
  IN1 w0.508: v2(124.01,94.98) 123.41,94.98 122.51,94.08 v2(122.51,93.42) ; v2(132.41,77.69) 134.63,79.91 134.63,90.29 132.01,92.9 v2(131.28,92.9)
  IN2 w0.508: v2(82.99,87.04) 82.99,90.41 82.71,90.69 81.72,90.69 81.19,91.23 81.19,93.29 v2(81.18,93.29)
  IN3 w0.762: 122.84,88.53 122.09,87.78 121.92,87.78 121.18,87.04 116.09,87.04 115.58,86.53 113.4,86.53 112.23,87.7 111.13,87.7 110.58,87.14 110.58,86.68 109.53,85.64 103.01,85.64 102.14,86.5 99.6,86.5 98.84,87.26 88.86,87.26 86.78,89.35 v2(86.19,89.35) ; v2(146.8,45.51) 146.49,45.2 143.14,45.2 141.11,47.23 141.11,59.68 143.32,61.89 143.32,72.1 144.31,73.09 144.31,74.22 143.37,75.16 143.37,78.93 133.59,88.71 130.62,88.71
  BOTTOM w0.203: UH1.H30 124.01,94.99 124.01,94.99 v2(124.01,94.98) ; UH1.H28 123.44,93.97 123.13,93.97 UH1.J28 122.89,93.8 v2(122.51,93.42)
  BOTTOM w0.508: PR1103.1 69.58,80.69 PR1104.1 PC1101.1 71.76,79.37 72.11,79.02 74.98,79.02 78.11,82.16 78.11,83.35 79.46,84.7 81.54,84.7 82.99,86.15 v2(82.99,87.04) ; v2(81.18,93.29) 81.36,93.46 RH156.1
  vias: v2(130.85,92.47)
+VCCSTG: length 96.6
  TOP w0.254: v2(82.36,91.48) 82.36,92.95 83.25,93.84 84.19,93.84 84.82,93.21 RH497.1
  TOP w0.508: v2(135.06,105.73) 135.06,97.7 133.92,96.56 CZ47.1 133.74,96.21 133.66,96.21 v2(132.93,95.47) ; CH106.1 124.75,96.15 124.52,96.15 v2(124.36,96) ; RH56.1 82.84,95.88 81.82,94.86 v2(81.29,94.86) 81.09,94.86 79.89,96.05 79.89,97.42 v1(78.29,99.02) v2(77.61,99.71)
  IN2 w0.508: v2(77.61,99.71) 77.78,99.71 79.31,101.23 79.31,102.35 80.25,103.29 82.48,103.29 87.36,108.17 132.62,108.17 v2(135.06,105.73) ; v2(81.29,94.86) 81.52,94.86 82.36,94.02 v2(82.36,91.48)
  BOTTOM w0.203: UH1.G30 124.31,95.94 v2(124.36,96)
  BOTTOM w0.254: v2(124.02,94.2) 124.01,94.2 123.66,94.55 UH1.H29
  BOTTOM w0.508: RH165.1 81.54,94.61 v2(81.29,94.86) ; RH496.1 v2(82.36,91.48)
  vias: v2(132.32,95.44)
GND: length 3719.2
  TOP w0.127: v3(234.73,42.36) v2(234.02,42.36)
  TOP w0.203: v2(234.67,25.2) 234.68,25.21 234.88,25.21 235.01,25.34 UE1.84 ; v2(232.47,33.04) 232.7,33.04 233.05,32.68 UE1.100 ; CE78.1 229.68,14.14 v2(229.12,14.7) 229.12,15.16 229.05,15.23 UE1.51 ; v2(221.62,24) 221.37,23.74 UE1.17 ; v2(234.3,17.47) 234.25,17.42 UE1.64 ; v2(212.65,12.9) 212.7,12.94 UZ1.11 ; UE1.124 223.45,30.78 223.76,30.47 v2(223.91,30.47)
  TOP w0.254: UM1.G3 268.06,34.2 v2(268.06,34.25) ; UM1.D4 v2(264.91,35.02) ; v2(121.04,112.64) 120.6,112.64 PC1274.2 120.72,113.27 v2(121.04,113.27) ; v2(278.78,40.25) 279.06,39.97 280.07,39.97 RI49.2 ; UM1.E4 v2(265.69,35.04) UM1.E5 ; CZ57.2 70.58,49.38 71.18,48.78 UZ16.5 ; UM1.B6 263.69,36.23 v2(264.09,35.84) ; v2(99.12,35.4) 99.43,35.4 99.68,35.14 99.68,34.82 99.86,34.64 CD72.2 ; QZ7.4 155.51,77.48 154.92,78.07 154.92,78.81 v2(154.93,78.81) ; UZ22.5 256.69,27.26 v2(256.78,27.17) 256.8,27.14 CZ98.2 ; RI45.2 279.38,39.06 279.35,39.03 279.01,39.03 278.85,39.2 278.31,39.2 v2(277.97,38.86) ; CH203.2 170.95,27.04 170.77,26.86 170.77,25.31 CH186.2 ; v2(117.61,112.64) 118.06,112.64 PC1202.2 117.93,113.27 v2(117.61,113.27) ; v2(268.11,35.8) 267.69,36.22 UM1.G6 ; CD71.2 118.34,33.02 v2(119.57,34.25) ; CD26.2 105.74,26.72 105.48,26.47 v2(105.37,26.47) ; v2(105.42,34.98) 105.48,34.98 105.54,34.93 105.79,34.93 106.34,34.38 CD78.2 ; v2(96.09,26.2) 96.75,26.85 CD85.2 ; v2(121.04,113.91) 120.6,113.91 PC1200.2 120.72,114.54 v2(121.04,114.54) ; v2(171.79,71.87) 171.76,71.85 170.7,71.85 170.28,72.27 UZ17.5 168.91,72.27 168.4,72.77 UZ17.9 ; v2(269.35,40.58) 269.35,43.02 v2(269.38,43.04) 269.38,43.72 268.91,44.19 v2(267.22,44.19) 265.44,44.19 265.06,43.81 v2(265.06,42.15) 265.06,39.67 v2(264.98,39.58) ; CD23.2 119.99,26.9 v2(120.33,26.56) ; v2(282.81,38.12) 282.94,37.99 US1.14 ; v2(173.54,23.92) 173.7,23.76 CH52.2 ; v2(117.61,113.91) 118.06,113.91 PC1201.2 117.93,114.54 v2(117.61,114.54) ; v2(264.93,35.83) 265.29,35.47 UM1.D5 ; v2(224.39,36.29) 224.39,37.96 224.06,38.29 v2(222.16,38.29) 222.11,38.24 220.25,38.24 220.05,38.04 220.05,36.31 v2(220.03,36.31) ; PU1001.6 205.64,56.1 v2(205.75,56) ; v2(11.43,28.81) 11.41,28.79 10.8,28.79 ; JKB1.1 v2(196.07,56.91) ; UM1.B3 263.64,33.84 v2(263.28,34.2)
  TOP w0.305: 135.93,29.4 135.95,29.4 136.28,29.07 CD34.2 ; 135.93,29.4 v2(135.93,29.42) ; 135.93,29.4 135.39,28.87 CD35.2 ; v2(12.81,34.76) 12.8,34.75 11.28,34.75 10.77,35.25 JIO1.26 ; v2(188.22,24.17) 187.9,23.85 UZ21.3 ; JAPS.12 v2(178.68,10.73) ; v2(206.41,34.85) 206.41,34.85 206.43,34.86 206.06,35.22 204.39,35.22 204.1,34.93 JPW.4 ; v2(191.16,27.53) 190.61,26.97 UH14.3 ; JAPS.14 179.68,11.04 179.37,10.73 v2(179.28,10.73) ; JAPS.10 177.68,11.09 v2(177.33,10.73) ; UZ15.5 130.15,95.79 v2(130.46,95.47) ; JIO1.17 11.72,30.75 12.32,30.15 v2(12.32,29.34) ; v2(277.17,34.66) 277.58,35.07 277.73,35.07 RI51.1 ; v2(157.47,78.95) 157.36,78.85 QZ7.1 ; v2(179.28,93.13) 179.28,93.08 178.65,92.45 RV79.1 ; v2(176.79,88.98) 177.44,89.63 CV374.2 ; QZ6.1 205.82,73.46 205.24,72.89 v2(204.99,72.89) ; JAPS.8 v2(176.68,10.73)
  TOP w0.356: UC16.3 134.39,76.97 v2(133.98,77.38) ; v2(295.54,78.98) DV4.3 v2(295.54,76.57) ; 180.82,89.08 181.44,89.69 RV110.2 ; DV5.3 293.44,68.02 v2(293.74,68.32)
  TOP w0.381: CH111.2 119.68,95.35 v2(119.68,95.48) ; v2(124.66,92.61) 124.65,92.61 124.65,92.6 124.54,92.71 CH110.2 ; CV80.1 174.44,84.59 173.77,85.26 PC1081.2 ; PC1331.2 104.01,92.68 v2(104.52,93.19) 104.01,93.7 PC1329.2 ; v2(154.44,72.51) 154.42,72.53 154.26,72.53 154.05,72.75 UV18.3 ; v2(172.53,76.42) 172.53,76.52 172.65,76.65 CV602.2 ; v2(180.86,88.12) 180.68,88.29 180.68,88.94 180.82,89.08 ; CV107.2 181.32,104.32 v2(181.75,103.88) ; v2(130.46,95.47) 130.34,95.35 CZ28.2 ; PC1377.2 100.67,91.92 v2(100.29,91.92) 100.29,92.14 99.75,92.68 PC1322.2 ; PC1069.2 172.93,89.37 v2(172.32,88.76) ; PC1040.2 167.56,85.82 v2(167.4,85.82) 167.28,85.93 PC1037.2 ; CE100.2 241.36,38.37 241.72,38.73 v2(242.35,38.73) ; PC1247.2 118.7,82.46 v2(118.66,82.51) 118.42,82.74 PC1221.2 ; 120.48,89.08 120.75,88.81 v2(121.14,88.81) ; 120.48,89.08 PC1390.2 ; 120.48,89.08 PC1385.2 ; v2(105.37,91.86) 105.55,91.86 105.6,91.81 105.62,91.81 105.89,91.54 PC1375.2 106.07,92.65 PC1330.2 ; v2(176.84,93.98) 176.87,94 176.87,94.03 176.91,94.07 176.91,94.63 CV209.2 ; v2(97.67,84.8) 97.95,84.8 PC1374.2 ; PC1243.2 117.59,84.29 PC1223.2 ; CH115.2 120.13,100.03 v2(119.67,100.03) ; PC1036.2 173.01,88.12 v2(173.44,87.7) ; v2(158.23,29.45) 157.92,29.15 CH191.2 ; CD3.2 CD4.2 139.74,40.24 v2(140.22,39.76) 140.87,39.11 CD10.2 ; v2(102.5,84.8) 102.78,84.8 PC1372.2 ; v2(100.89,21.99) 101.04,21.99 101.51,21.53 101.51,20.54 101.33,20.36 CD83.2 ; v2(165.27,35.51) 165.26,35.51 165.26,35.54 165.07,35.73 CH183.2 ; QZ6.4 207.16,76.29 v2(206.89,76.56) ; PC1220.2 118.32,85.19 v2(118.71,85.19) 118.71,84.6 PC1233.2 ; CH104.2 123.19,90.28 v2(123.99,91.07) ; PC1039.2 171.94,85.18 v2(172.35,84.77) ; PC1248.2 114.55,83.29 v2(114.04,82.78) ; CA62.2 CA26.2 273.85,27.55 v2(273.62,27.78) ; CH112.2 120.56,85.28 v2(121.09,85.82) 120.37,86.54 CH114.2 ; PC1335.2 95.34,92.59 v2(95.34,92.04) 95.05,92.04 PC1379.2 ; CV104.2 v2(183.69,105.4) ; v2(279.87,14.9) 279.89,14.9 280.5,15.51 RA33.2 ; v2(167.29,96.25) 167.11,96.07 PC1035.2 ; CV381.1 v2(183.71,106.48) ; UZ23.3 65.4,29.18 65.01,28.79 v2(64.93,28.79) ; v2(119.68,97.43) 119.68,97.99 CH135.2 ; PC1373.2 100.37,84.8 v2(100.09,84.8) ; v2(165.4,21.32) 165.4,21.47 165.74,21.81 CH70.2 ; RV573.2 156.53,73.85 156.12,73.44 156.12,73.29 v2(156.11,73.29) ; PC1378.2 95.54,84.8 v2(95.26,84.8) ; v2(121.29,95.49) 122.22,94.57 CH204.2 ; v2(116.21,86.02) 115.88,85.69 PC1222.2 115.9,85.35 PC1269.2 ; CD80.2 v2(99.3,18.71) ; CH173.2 CH80.2 168.6,27.38 169.25,28.03 v2(169.25,28.02) ; PC1363.2 105.27,84.72 v2(104.94,84.72) ; v2(174.34,88.78) 174.68,89.12 PC1062.2 ; CH176.2 165.08,25.59 164.47,24.98 v2(164.47,24.81) ; PC1031.2 v2(181.62,55.74) ; PC1019.2 170.38,87.3 170.85,86.84 PC1041.2
  TOP w0.406: v2(174.41,31.59) 174.11,31.89 CH188.2 ; v2(205.06,80.68) 205.06,80.68 CV402.2 ; RV134.2 197.86,79.93 v2(197.86,79.88)
  TOP w0.457: CV391.2 206.85,85.34 v2(206.69,85.5) ; CV186.2 169.33,101.43 v2(169.24,101.52) 169.18,101.46 CV101.2 ; v2(110.96,25.7) 111.33,25.7 RH212.2 ; CV165.2 183.14,119.23 v2(183.2,119.29) ; CV105.2 183.03,104.27 182.64,103.88 v2(182.64,103.85) ; CV398.2 199.46,106.2 v2(199.46,106.19) ; QV21.3 201.47,92.18 200.97,92.67 v2(200.97,93.03) 200.97,93.16 200.92,93.21 CV401.2 ; CV80.1 v2(174.81,83.9) ; v2(167.57,102.34) 168.18,102.94 CV192.2 ; CV404.2 196.76,76.72 196.3,77.18 v2(196.3,77.51) ; CL44.2 283.35,49.27 283.65,49.57 v2(283.87,49.57) ; v2(201.06,77.48) 201.06,77.48 CV396.2 ; v2(201.06,106.19) 201.05,106.2 CV393.2 ; v2(183.2,120.89) 183,120.89 CV383.2 ; v2(197.86,96.59) 197.84,96.57 CV400.2 ; v2(197.86,106.19) 197.86,106.2 CV399.2 ; v2(150.7,13.52) 151.15,13.97 CZ102.2 ; CE101.2 220.32,35.42 220.03,35.71 v2(220.03,36.31) ; CH103.2 123.49,89.08 123.89,88.68 v2(124.63,88.68) ; CV108.2 CV106.2 182.42,101.17 v2(182.62,100.98) ; CV175.2 179.77,104.31 v2(179.63,104.17)
  TOP w0.508: RV536.2 v2(64.4,29.96) ; RV537.2 63.97,30.98 64.42,31.44 v2(64.42,31.64) 64.2,31.87 RV551.2 ; RV108.2 167.01,102.9 v2(167.57,102.34) ; CV205.2 163.52,97.21 v2(163.39,97.34) ; PR1110.1 65.72,85.04 PC1105.1 65.69,85.99 64.25,85.99 v2(64.04,85.79) ; v2(182.78,93.61) 182.96,93.44 CV76.2 ; PC1106.1 64.79,86.86 ; 64.79,86.86 PC1107.1 ; 64.79,86.86 64.37,86.86 v2(64.04,87.19) ; CI23.2 278.14,36.87 277.56,36.87 277.38,37.05 v2(277.38,37.12) ; v2(165.89,97.34) 165.89,97.24 166.25,96.89 CV211.2 ; CV83.2 185.05,81.59 v2(184.18,80.71) ; PC1026.2 164.04,94.37 163.46,93.79 v2(163.46,93.71) 164.07,93.1 PC1027.2 ; v2(171.69,132.12) CV158.2 172.56,131.47 RV127.2 ; CA37.2 276.29,15.05 v2(276.62,14.72) 276.67,14.72 277.15,15.2 CA36.2 ; v2(138.82,29.42) 138.82,29.33 138.69,29.2 CD30.2 CD31.2 ; v2(176.79,83.98) 176.74,84.03 CV112.2 ; CD25.2 118.21,18.9 118.35,18.77 118.35,18.74 118.38,18.71 118.38,18.69 118.37,18.69 118.37,18.69 118.37,18.69 v2(118.37,18.69) ; CD12.2 v2(139.02,31.94) ; CD28.2 v2(140.34,24.31) ; v2(202.66,84.68) 202.5,84.52 CV179.1 ; v2(170.38,95.81) 170.44,95.74 PC1029.2 ; v2(193.41,78.98) 193.99,79.56 CV191.2 ; PC1323.2 v2(106.86,83.97) ; CD81.2 128.26,19.33 128.87,18.72 128.86,18.72 v2(128.86,18.69) ; CV159.2 169.87,131.46 RV130.2 v2(170.44,132) ; v2(189.99,77.36) RV162.1 RV155.1 ; CD87.2 71.96,19.08 v2(71.53,18.66) ; CE103.2 215.86,22.72 v2(216.42,23.28) ; v2(116.2,35.63) 115.61,35.63 114.77,34.79 114.77,33.8 CD96.2 ; v2(85.37,18.72) 84.8,19.3 CD20.2 ; v2(235.52,35.93) 235.98,35.48 CE76.2 ; v2(199.46,87.88) 199.44,87.9 CV184.2 ; PC318.1 32.14,35.93 v2(31.63,35.42) ; JLED.5 242.49,21.5 v2(241.86,21.5) ; CV603.2 150.76,76.44 150,75.68 v2(149.62,75.68) ; CV166.2 175.78,120.31 v2(176.01,120.08) ; v2(260.74,25.9) 260.41,25.57 RM8.2 ; RM26.1 v2(259.85,41.57) ; v2(240.77,18.13) 240.29,17.64 CE64.1 ; PC1342.2 99.35,82.26 CH124.2 99.74,81.87 v2(100.4,81.87) ; CV395.2 201.94,99.07 v2(201.86,98.99) ; CV169.2 179.43,131.86 v2(179.3,131.99) ; v2(156.73,44.06) 156.41,44.38 CH181.2 ; PR105.2 v2(11.69,24.07) ; v2(86.75,31.36) 86.43,31.04 CD86.2 86.43,29.9 v2(86.75,29.58) ; v2(142.44,25.05) 141.58,25.05 CD27.2 ; v2(11.41,41.85) 11.49,41.93 PC100.2 ; CZ41.2 62.27,40.88 61.73,41.42 v2(61.71,41.42) ; CV193.2 171.07,97.23 v2(170.91,97.38) ; v2(108.55,18.68) 108.5,18.63 CD22.2 ; CV153.2 176.75,88.94 v2(176.79,88.98) ; RV152.1 v2(182.63,72.76) ; v2(125.18,42.56) 125.07,42.56 124.56,43.07 CD70.2 125.16,43.88 v2(125.21,43.88) ; v2(167.32,93.8) 166.78,94.33 PC1025.2 ; RZ71.2 184.08,23.18 v2(184.52,23.61) 184.81,23.91 CC5.1 ; v2(68.08,47.49) 68.26,47.67 CZ49.2 ; RV107.2 162.21,104.59 CV210.2 162.2,104.2 v2(161.95,103.95) ; CH128.2 124.61,76.08 v2(123.88,75.35) ; CH136.2 120.57,91.93 v2(120.95,91.93) ; v2(290.66,39.36) 290.87,39.16 CA4.2 ; v2(67.7,35.42) 67.38,35.74 RZ40.2 ; PC1223.2 117.59,82.74 v2(117.78,82.55) ; CV189.2 193.81,78.32 v2(193.43,77.94) ; v2(135.89,30.14) 135.38,30.14 CD13.2 ; RV134.2 198.75,81.74 RV136.2 ; v2(112.29,80.61) 112.18,80.72 CH125.2 ; CM40.2 270.09,27.8 270.52,27.8 v2(270.65,27.93) ; v2(124.62,83.15) 124.39,82.92 RH516.2 ; CV75.2 177.9,104.83 CV102.2 CV173.2 176.98,103.53 v2(177.25,103.26) ; RE114.1 239.66,28.44 240.04,28.06 v2(240.04,26.96) ; v2(122.41,85.98) 122.84,86.41 CH102.2 ; v2(64.4,26.03) 64.32,25.95 RV567.2 ; CI24.2 293.05,34.66 v2(293.15,34.76) ; v2(180.88,131.17) 181.4,131.69 CV161.2 ; CA38.2 272.32,15.13 v2(271.92,14.72) 271.46,15.18 CA39.2 ; CV207.2 156.58,119.17 v2(156.7,119.29) ; CT80.2 HT1.2 108.98,86.02 109.31,86.35 v2(109.31,86.48) ; v2(169.18,81.42) 168.86,81.42 168.42,80.98 PC1055.2 ; PC1416.2 v2(109.36,132.6) ; v2(174.31,34.01) 174.14,33.84 RH112.2 ; QV20.3 172.18,127.51 v2(171.71,127.98) ; RV78.1 176.55,101.57 177.41,100.71 v2(177.56,100.71) ; v2(121,90.23) 120.6,90.23 PC1382.2 ; v2(179.61,128.69) RV120.2 180.28,127.77 RV118.2 ; v2(201.06,96.59) 201.06,95.76 CV171.2 ; CV154.2 168.42,96.67 CV103.2 169.34,97.36 v2(169.22,97.49) ; v2(154.7,45.2) 154.14,45.76 CH182.2 ; v2(159.9,123.29) 159.99,123.29 160.46,123.76 CV384.2 ; PC1373.2 100.8,84 101.26,83.54 PC1333.2 ; PC202.2 45.8,45.79 v2(45.6,45.98) ; v2(231.51,36.15) 231.78,35.87 CE63.1 ; RV51.2 175.03,76.52 v2(175.04,76.54) ; v2(177.55,75.3) 178,74.84 RV49.2 RV66.2 ; CZ57.2 70.8,49.74 72.64,49.74 72.7,49.67 v2(72.7,49.67) ; CV181.2 208.9,80.84 v2(209.06,80.68) ; v2(138.83,30.41) 139.07,30.41 CD15.2 ; RN4.2 195.92,30.63 v2(196.03,30.75) ; v2(173.48,82.49) 174.15,81.82 CV214.2 174.26,81.35 173.48,80.57 CV569.2 CV570.2 ; v2(134.12,13.81) 133.56,13.81 CE2.2 ; PC1055.2 168.63,80.92 168.97,80.58 v2(169.23,80.58) ; PC1055.2 PC1054.2 ; v2(197.86,87.88) 197.66,88.08 CV185.2 ; v2(116.6,15.51) 117.25,14.86 QE5.3 ; v2(179.74,30.52) 179.79,30.47 RH109.2 ; CH119.2 106,82.4 v2(105.9,82.51) ; RM11.1 v2(264.3,41.52) ; v2(260.23,43.12) 260.49,43.37 RM4.2 RM24.2 ; v2(268.03,39.39) 268.44,39.8 CM44.2 268.32,40.11 YM1.2 ; v2(163.9,123.29) 163.83,123.35 CV386.2 ; RV155.1 RV153.1 ; RV155.1 v2(189.1,77.41) ; PC320.2 31.49,36.82 v2(30.94,36.27) ; CV204.2 161.28,96.7 CV87.2 ; DE8.2 239.9,30.63 v2(239.94,30.6) ; CH123.2 112.25,76.79 v2(112.25,77.38) ; CZ104.2 13.16,22.98 v2(13.56,23.37) ; RH211.2 69.12,45.84 v2(69.1,45.86) ; CV379.2 175.38,87.1 175.32,87.04 CV78.2 v2(174.8,86.36) ; CV385.2 177.07,117.49 v2(177.07,118.3) ; CD24.2 131.29,29.36 v2(131.07,29.58) ; 182.05,86.57 180.93,86.57 CV375.2 180.2,86.59 v2(180.09,86.48) ; v2(156.6,22.28) 156.4,22.08 CH192.2 ; v2(286.01,45.81) 286.51,46.31 CL22.2 ; CV206.2 164.36,98.07 v2(164.21,98.21) ; PC1514.2 v2(66.71,114.8) ; v2(174.23,93.85) 174.68,93.4 PC1051.2 PC1052.2 ; PC1369.2 PC1367.2 99.68,115.81 v2(99.96,116.09) ; PC1332.2 103.16,81.89 v2(103.15,81.87) ; v2(126.45,13.76) 126.27,13.93 CE5.2 ; PC1311.2 95.13,90.44 v2(95.58,90.44) ; v2(137.68,38.09) 137.11,38.66 CD9.2 ; v2(202.66,87.08) 202.66,88.16 RV132.2 ; CV403.2 199.17,76.84 198.66,77.34 v2(198.66,77.48) ; PC1339.2 95.54,82.81 v2(95.83,82.52) ; CV172.2 199.42,102.23 v2(198.66,102.99) ; CA7.2 289.85,30.95 v2(289.9,30.9) ; CV79.1 153.67,123.56 152.97,124.26 152.97,124.25 v2(152.94,124.22) ; CE4.2 121.56,13.93 v2(120.91,14.58) 120.91,14.85 121.22,15.15 RE4.1 ; v2(198.33,37.29) 198.46,37.16 JPW.5 ; v2(197.95,83.84) 198.44,83.35 CV208.2 ; v2(175.57,117.92) 176.25,117.25 CV86.2 ; v2(208.13,94.51) 207.9,94.74 RV142.2 207.07,94.73 CV177.2 207.1,93.76 CV178.2 RV145.2 ; PC1310.2 100.21,88.94 PC1359.2 ; PC1310.2 99.95,87.55 PC1361.2 ; PC1310.2 98.97,88.53 v2(98.56,88.53) ; RV160.1 v2(185.42,77.36) ; v2(90.13,45.5) 89.79,45.5 88.37,44.07 CD8.2 ; CD84.2 114.53,29.82 v2(113.6,30.75) ; PC1300.2 PC1303.2 98.84,86.37 v2(98.44,86.37) ; CV74.2 157.55,128.84 v2(157.5,128.89) ; JKB1.31 v2(192.31,58.38) ; v2(173.62,91.81) 172.95,91.81 PC1072.2 ; CV388.2 206.2,99.92 v2(206.19,99.92) ; CL41.2 v2(294.52,82.29) ; CH126.2 117.48,74.72 v2(117.15,74.72) ; v2(170.22,24.91) 170.54,25.24 CH186.2 ; CZ12.2 220.06,13.34 v2(220.06,14.3) ; CV377.2 176.71,81.49 v2(176.71,80.58) ; CL21.2 284.85,43.63 v2(284.9,43.58) ; v2(124.47,15.92) 124.84,15.55 CE6.2 ; v2(134.58,44.81) 134.91,44.47 CD17.2 CD16.2 ; PC1322.2 PC1321.2 ; CZ105.2 16.29,35.47 16.8,35.98 v2(17.23,35.98) ; v2(181.69,95.65) 180.96,94.92 CV190.2 ; v2(89.86,90.03) 89.79,89.96 RH183.2 RH184.2 ; v2(69.35,62.47) 69.61,62.73 PC713.2 ; v2(193.43,80.42) 193.81,80.8 CV187.1 ; CM43.2 265.62,39.23 v2(265.41,39.03) ; CH120.2 102.8,75.24 v2(102.07,75.97) ; v2(64.53,62.47) PC711.2 PR704.2 ; v2(67.32,38.73) 67.27,38.73 66.56,39.44 UZ8.2 ; RV154.1 RV161.1 v2(186.44,77.36) ; CH133.2 122.88,100.75 v2(122.05,100.75) ; PC1314.2 98.13,91.92 v2(97.75,91.92) 97.75,92.46 PC1334.2 PC1327.2 ; JFAN2.5 v2(251.57,30.47) ; CZ88.2 134.25,101.34 133.87,101.72 v2(133.49,101.72) ; CD76.2 126.71,31.56 v2(126.9,31.36) ; v2(206.26,102.86) 206.28,102.88 CV183.2 ; CV215.2 160.16,120.36 v2(159.88,120.08) ; v2(17.31,36.69) 14.95,36.69 CZ106.2 ; CZ11.2 219.64,11.31 v2(219.64,10.86) ; CV164.2 164.77,131.36 v2(164.7,131.29) ; CC4.1 170.7,14.64 v2(170.58,14.52) ; v2(103.91,90.59) 104.29,90.59 PC1354.2 104.67,90.21 PC1349.2 ; PR711.2 v2(68.67,60.75) ; PC1029.2 170.44,93.37 PC1034.2 170.43,92.73 v2(170.42,92.72) ; PC1029.2 171.57,94.44 PC1028.2 171.66,94.37 172.24,94.95 v2(172.33,94.95) ; PC1351.2 104.62,87.53 PC1353.2 103.98,88.17 v2(103.98,88.17) ; CD5.2 114.02,43.78 CD79.2 113.53,42.73 v2(113.75,42.51) ; JFAN1.4 52.76,33.12 v2(52.97,32.91) CE99.2 ; CV90.2 CV89.2 162.73,94.7 v2(162.52,94.91) ; v2(166.39,95.81) 166.23,95.65 165.59,95.65 PC1010.2 ; PC1348.2 100.37,90.02 PC1306.2 99.03,90.44 v2(98.63,90.44) ; CD74.2 83.15,34.11 v2(83.32,34.28) ; PC1415.2 v2(108.47,132.58) ; PC1305.2 94.64,88.33 95.12,88.81 v2(95.5,88.81) ; v2(108.62,81.19) 108.43,81.38 CH122.2 ; v2(208.26,87.88) 207.89,87.88 207.6,87.59 CV392.2 ; v2(249.44,23.03) 249.46,23 249.46,22.65 250.21,21.9 JLED.6 ; v2(170.38,84.78) 169.69,84.09 PC1063.2 ; JFAN2.4 245.51,38.18 v2(245.37,38.32) ; v2(172.25,92.83) 172.64,92.83 PC1073.2 ; CH132.2 CH131.2 CH130.2 CH129.2 126.06,61.12 v2(125.21,61.96) ; v2(97.62,82.52) 97.51,82.64 PC1340.2 ; RV133.2 RV135.2 204.67,102.2 205.06,102.6 v2(205.06,102.99) ; CV167.2 164.49,128.3 v2(164.7,128.09) ; CH189.2 174.85,26.57 v2(174.85,27.26) ; CV170.2 206.97,88.12 v2(207.06,88.02) ; 168.02,91.77 167.38,91.77 v2(167.32,91.83) ; 168.02,91.77 PC1075.2 PC1017.2 168.02,87.88 PC1018.2 167.32,87.83 v2(167.27,87.78) ; 168.02,91.77 PC1015.2 PC1012.2 ; CE102.2 224.11,35.42 224.39,35.71 v2(224.39,36.29) ; v2(284.9,44.69) 284.82,44.62 CL32.2 ; v2(215.55,21.66) 215.63,21.58 CE65.2 CE74.2 ; CH134.2 120.15,101.69 v2(120.47,102.01) ; v2(163.84,132.83) 163.6,132.59 CV163.2 ; v2(70.49,64.89) PC710.2 ; CA27.2 273.95,24.88 v2(273.82,25.01) 273.38,25.45 CA30.2 ; CH180.2 v2(154.75,42.08) ; v2(173.75,18.98) 174.37,18.98 CH53.2 ; v2(131.1,43.05) 130.5,43.65 CD7.2 ; CH82.2 172.22,36.31 v2(172.25,36.35) ; v2(105.29,18.68) 105.29,19.09 105.53,19.32 CD82.2 ; UM2.4 263.84,23.92 264.3,24.37 v2(264.3,24.63) ; PC1244.2 PC1242.2 v2(111.75,92.5) ; v2(175.07,128.51) 175.41,128.84 CV382.2 ; RV156.1 v2(184.41,77.51) ; CV110.2 177.38,131.87 v2(177.6,132.09) ; CV188.2 v2(195.74,84.89) ; CZ99.2 259.88,28.62 v2(259.98,28.51) ; v2(175.06,131.69) 174.91,131.84 CV160.1 ; 171.61,5.78 171.08,6.31 JAPS.19 ; v2(292.96,23.02) 293.08,22.9 RA13.2 ; CV568.2 155.75,83.76 155.91,83.91 v2(155.91,83.99) ; PC1304.2 95.06,86.37 v2(95.45,86.37) ; CV213.2 177.41,77.82 176.92,77.33 v2(176.72,77.33) ; PC1341.2 PC1335.2 ; PC101.2 11.74,39.83 11.53,40.05 v2(11.53,40.21) ; CV113.2 171.14,103.14 v2(172.14,104.13) ; CE1.2 212.66,35.25 v2(212.46,35.44) ; PC1330.2 PC1338.2 ; v2(169.19,76.48) 169.55,76.85 CV572.2 ; v2(169.66,91.8) 169.57,91.71 PC1074.2 168.98,90.45 PC1070.2 ; v2(158.15,31.71) 158.15,31.73 158.08,31.8 CH190.2 ; DA3.1 270.57,11.85 v2(269.15,13.27) ; CV378.2 176.73,85.62 v2(176.79,85.56) ; PC1014.2 164.14,89.14 v2(163.41,89.87) ; CV88.2 162.87,89.32 v2(163.41,89.87) ; CV390.2 209.06,85.6 v2(209.06,85.48) ; v2(159.9,126.49) 160.41,126.49 160.92,125.98 RV121.2 160.93,125.81 RV119.2 ; CV380.2 183.21,129.68 v2(183.2,129.69) ; v2(104.1,86.52) 104.46,86.52 PC1350.2 PC1362.2 ; CV94.1 162.78,90.51 v2(163.41,89.87) ; v2(102.4,93.2) 101.97,93.64 PC1325.2 PC1324.2 ; PQ101.3 v2(13.57,24.11) ; v2(103.64,45.33) 103.45,45.14 CD6.2 ; JAPS.20 183.78,7.08 v2(184.41,6.44) ; CH116.2 125.37,99.91 CH117.2 125.55,101.2 125.92,101.56 v2(125.92,101.84) ; RH94.2 v2(187,27.97) ; v2(65.54,64.89) 65.47,64.81 PR709.2 ; v2(120.95,93.2) 120.57,93.2 PC1386.2 ; v2(109.47,95.49) 109.9,95.06 PC1246.2 ; RH88.1 179.92,18.33 v2(179.66,18.07) ; CI19.2 v2(293.58,24.58) ; v2(112.28,82.51) 112.48,82.71 PC1245.2 PC1232.2 ; PC1261.2 v2(115.64,87.68) ; v2(108.68,95.46) 108.68,95.41 108,94.73 PC1320.2 PC1328.2 v2(108,92.55) 108,92.22 PC1203.2 108.99,92.27 v2(108.99,92.64) 108.99,93.37 PC1239.2 ; v2(170.06,78.88) 170.06,78.55 170.5,78.12 CV120.2 170.74,78.34 CV571.2 ; CA3.2 286.75,28.57 v2(287.21,28.11) 286.78,27.68 CA15.1 ; CH113.2 125.96,97.07 CH106.2 126.46,96.44 v2(126.57,96.56) ; v2(242.55,28.21) 242.38,28.21 241.94,27.78 241.94,27.73 CE8.2 ; PC1276.2 118.01,87.77 v2(118.06,87.82) ; v2(69.1,98.29) 69.1,97.53 69.73,96.89 PC1137.2 ; CL20.2 v2(284.05,46.79) ; CD2.2 80.76,43.81 v2(80.65,43.91) ; v2(95.11,44.86) 95.35,44.62 CD73.2 95.69,43.58 CD1.2 ; CV174.2 180.51,101.9 v2(180.09,101.48) ; CV100.2 176.68,91.59 v2(176.79,91.48) ; v2(171.31,87.7) 170.53,87.7 PC1019.2 170.36,87.87 PC1016.2 ; RH209.2 69.81,42.99 69.22,43.58 v2(68.89,43.58) ; US2.2 v2(292.18,31.14) ; CV182.2 209.75,77.35 v2(209.88,77.47) ; QV2.3 v2(66.16,26.65) ; v2(289.62,34.94) 289.6,34.97 289.37,34.97 288.85,35.48 UA1.2 288.85,37.11 CA10.1 ; CH187.2 v2(179.62,22.24) ; CE89.2 240.31,18.79 240.75,19.23 v2(240.75,19.42) ; QV3.1 146.47,74.69 v2(146.47,74.7) ; v2(135.89,30.85) 135.58,30.85 CD14.2 ; v2(172.25,90.82) 172.45,90.61 PC1071.2 ; v2(163.47,91.73) 163.64,91.9 PC1011.2 ; v2(171.79,71.87) 171.91,71.99 CZ95.2 ; PC1376.2 PC1377.2 ; v2(175.03,126.89) 175,126.85 RV116.2 ; v2(209.06,83.88) 208.85,83.67 CV180.2 ; v2(12.97,33.25) 13.63,33.25 PD100.2 ; PC800.2 228.74,44.19 v2(229.24,44.69) ; YM1.4 v2(267.19,43.13) ; JFAN2.6 v2(251.57,42.15) ; CV121.2 162.87,88.43 v2(163.41,87.9) PC1013.2 164.59,87.45 PC1038.2 ; v2(293.15,12.66) 294.07,11.75 RA15.2 ; RH127.2 162.34,27.47 v2(162.51,27.29) ; CZ97.2 v2(129.81,100.52) ; CD77.2 v2(103.64,43.3) ; v2(238.87,24.83) 239.3,25.26 239.3,25.47 RE21.2 ; CD75.2 93.79,33.95 v2(93.74,34) ; v2(132.93,74.34) 131.51,74.34 130.74,75.1 CC298.2 ; CV152.2 173.28,96.57 v2(173.11,96.74) ; RV513.2 RV512.2 163.37,76.52 164.15,77.3 v2(164.25,77.3) 164.32,77.36 PC1053.2 ; JFAN1.6 49.91,39.5 50.14,39.28 v2(50.96,39.28) ; v2(132.85,101.59) 132.85,101.21 133.26,100.8 CZ96.2 ; CD21.2 103.67,19.52 103.9,19.3 v2(103.9,18.66) ; v2(118.9,95.51) 118.9,95.22 119.18,94.94 PC1240.2 PC1231.2 v2(119.18,92.38) ; PC1352.2 PC1360.2 104.35,89.19 v2(103.97,89.19) ; RH13.1 178.65,26.03 v2(179.31,26.03) ; CH200.2 171.97,26.28 171.96,26.28 v2(171.52,26.72) ; RH495.2 156.8,28.46 v2(156.68,28.34) ; PC1326.2 v2(105.02,82.52) ; CV394.2 202.66,77.07 v2(202.66,77.48) ; JFAN1.5 59.36,39.5 59.38,39.49 v2(60.46,39.49) ; v2(180.08,98.98) 180.18,98.89 CV77.2 ; v2(193.91,32.89) 193.91,32.52 JKB1.32 ; v2(101.61,114.42) 102.05,114.42 PC1366.2 101.93,113.78 v2(101.61,113.78) ; PC1021.2 186.17,71.47 v2(186.83,72.13) ; v2(22.36,33.24) 22.06,32.93 PR301.2 ; CD19.2 95.34,19.5 95.67,19.17 v2(95.67,18.74) ; v2(260.28,38.34) 260.28,39.41 RM25.1 ; PC1407.2 v2(127.64,132.83) ; CV162.2 v2(160.65,132.59) ; CH118.2 102.09,82.02 v2(102.23,81.87) ; v2(174.17,29.04) 174.2,29.07 CH202.2 ; CV577.2 v2(64.08,36.19) ; CV168.1 v2(195.57,82.48) ; DA2.1 275.5,11.85 274.61,12.74 v2(274.61,13.22) ; v2(135.76,14.62) 135.76,14.72 136.52,15.48 UE4.2 ; RM9.2 v2(265.06,28.57) ; CH127.2 120.34,80.76 v2(120.52,80.58) ; PC1204.2 v2(108.47,86.48) ; PC1078.2 v2(203.36,58.23) ; CH51.1 175.29,25.24 v2(175.7,24.83) ; CV387.2 207.42,96.64 v2(207.46,96.59) ; CH121.2 101.13,78.51 101.25,78.63 v2(101.38,78.63) ; CH201.2 v2(177.81,29.4) ; CH185.2 CH184.2 167.35,38.04 167.93,38.62 v2(167.93,39.33) ; v2(156.7,122.49) 156.21,122.49 CV109.2 ; RM18.2 v2(270.01,42.54) ; v2(204.73,37.29) 204.73,37.25 204.83,37.16 JPW.6 ; PC1424.2 v2(107.58,132.58) ; CV579.2 v2(64.4,25.01) ; CV576.2 v2(64.4,34.15) ; PR207.2 v2(47.97,44.01) ; JLED.1 v2(244.71,24.95) ; PC1271.2 v2(114.56,87.75)
  GND1 w0.203: 300.21,75.12 JHDMI1.8 ; JHDMI1.8 300.21,74.22 ; JHDMI1.8 300.1,74.67 ; JHDMI1.8 301.11,75.12 ; JHDMI1.8 301.22,74.67 ; JHDMI1.8 301.11,74.22 ; 296.53,59.27 JUSB2.10 ; JUSB2.10 296.53,60.15 ; JUSB2.10 298,60.15 ; JUSB2.10 298,58.39 ; JUSB2.10 296.53,58.39 ; JUSB2.10 299.47,60.15 ; JUSB2.10 299.47,59.27 ; 63.95,75.56 H17.1 ; H17.1 63.95,78.24 ; H17.1 66.63,75.56 ; H17.1 63.46,76.9 ; H17.1 66.63,78.24 ; H17.1 65.29,78.73 ; H17.1 65.29,75.07 ; H17.1 67.12,76.9 ; 301.41,72.72 JHDMI1.11 ; JHDMI1.11 301.41,73.62 ; JHDMI1.11 302.31,73.62 ; JHDMI1.11 302.31,72.72 ; JHDMI1.11 302.42,73.17 ; JHDMI1.11 301.3,73.17 ; H1.1 82.16,107.13 ; H1.1 82.16,110.47 ; H1.1 78.82,110.47 ; H1.1 82.78,108.8 ; H1.1 78.82,107.13 ; H1.1 80.49,106.51 ; H1.1 80.49,111.09 ; H1.1 78.2,108.8 ; 192.26,128.9 H11.1 ; H11.1 192.75,130.24 ; H11.1 194.09,127.07 ; H11.1 195.92,128.9 ; H11.1 194.09,130.73 ; H11.1 195.43,130.24 ; H11.1 195.43,127.56 ; H11.1 192.75,127.56 ; H56.1 89.88,5.73 ; H56.1 88.64,5.29 ; H56.1 86.96,6.97 ; H56.1 87.4,5.73 ; H56.1 90.32,6.97 ; H5.1 196.29,116.18 ; H5.1 197.78,112.66 ; H5.1 194.8,112.66 ; H5.1 194.8,115.64 ; H5.1 197.78,115.64 ; H5.1 198.32,114.15 ; H5.1 194.26,114.15 ; H5.1 196.29,112.12 ; H2.1 142.08,104.55 ; H2.1 141.46,102.88 ; H2.1 139.79,106.84 ; H2.1 137.5,104.55 ; H2.1 138.12,106.22 ; H2.1 141.46,106.22 ; H2.1 138.12,102.88 ; H2.1 139.79,102.26 ; 39.27,43.27 H20.1 ; H20.1 42.31,43.27 ; H20.1 39.27,40.23 ; H20.1 40.79,39.67 ; H20.1 42.87,41.75 ; H20.1 40.79,43.83 ; H20.1 42.31,40.23 ; H20.1 38.71,41.75 ; 301.3,70.17 JHDMI1.17 ; JHDMI1.17 302.42,70.17 ; JHDMI1.17 302.31,70.62 ; JHDMI1.17 302.31,69.72 ; JHDMI1.17 301.41,70.62 ; JHDMI1.17 301.41,69.72 ; 305.72,114.29 JLAN.9 ; JLAN.9 309.22,114.29 ; JLAN.9 305.72,113.24 ; JLAN.9 308.35,114.29 ; JLAN.9 307.47,114.29 ; JLAN.9 305.72,112.71 ; JLAN.9 309.22,113.24 ; JLAN.9 309.22,113.77 ; JHDMI1.2 300.66,78.23 ; JHDMI1.2 301.11,78.12 ; JHDMI1.2 301.22,77.67 ; JHDMI1.2 300.21,77.22 ; JHDMI1.2 300.21,78.12 ; JHDMI1.2 301.11,77.22 ; JHDMI1.2 300.1,77.67 ; 296.53,37.69 JUSB1.10 ; JUSB1.10 298,39.45 ; JUSB1.10 299.47,38.57 ; JUSB1.10 299.47,39.45 ; JUSB1.10 296.53,39.45 ; JUSB1.10 296.53,38.57 ; JUSB1.10 298,37.69 ; 303.11,119.2 H13.1 ; H13.1 306.47,119.2 ; H13.1 306.03,120.44 ; H13.1 306.03,117.96 ; H13.1 304.79,117.52 ; H13.1 303.55,120.44 ; H13.1 304.79,120.88 ; H13.1 303.55,117.96 ; H12.1 287.23,106.56 ; H12.1 284.55,106.56 ; H12.1 287.23,109.24 ; H12.1 284.55,109.24 ; H12.1 284.06,107.9 ; H12.1 285.89,109.73 ; H12.1 287.72,107.9 ; H12.1 285.89,106.07 ; 138.12,72.67 H4.1 ; H4.1 138.12,69.33 ; H4.1 142.08,71 ; H4.1 139.79,73.29 ; H4.1 139.79,68.71 ; H4.1 137.5,71 ; H4.1 141.46,69.33 ; H4.1 141.46,72.67 ; 78.2,70.4 H3.1 ; H3.1 80.49,72.69 ; H3.1 80.49,68.11 ; H3.1 82.78,70.4 ; H3.1 78.82,72.07 ; H3.1 78.82,68.73 ; H3.1 82.16,68.73 ; H3.1 82.16,72.07 ; 305.5,42.69 JUSB2.12 ; JUSB2.12 306.87,42.69 ; JUSB2.12 304.13,42.69 ; JUSB2.12 306.87,43.57 ; JUSB2.12 304.13,43.57 ; 306.59,93.39 JLAN.10 ; JLAN.10 307.47,93.39 ; JLAN.10 309.22,94.44 ; H19.1 215.97,53.1 ; H19.1 215.48,54.44 ; H19.1 215.48,51.76 ; H19.1 214.14,54.93 ; H19.1 214.14,51.27 ; H19.1 212.31,53.1 ; H19.1 212.8,54.44 ; H19.1 212.8,51.76 ; JUSB1.13 299.47,21.99 ; JUSB1.13 298,23.75 ; JUSB1.13 296.53,22.87 ; JUSB1.13 299.47,22.87 ; JUSB1.13 296.53,23.75 ; JUSB1.13 298,21.99 ; JUSB1.13 296.53,21.99 ; JUSB1.12 306.87,22.87 ; JUSB1.12 304.13,21.99 ; JUSB1.12 306.87,21.99 ; JUSB1.12 304.13,22.87 ; JUSB1.12 305.5,21.99 ; H57.1 90.06,9.99 ; H57.1 86.71,8.57 ; H57.1 88.64,10.5 ; H57.1 87.22,9.99 ; H57.1 90.57,8.57 ; 297.27,52.06 JUSB2.7 ; JUSB2.7 297.91,50.59 ; JUSB2.7 297.91,52.25 ; JUSB2.7 297.08,51.42 ; JUSB2.7 297.27,50.79 ; JUSB2.13 299.47,42.69 ; JUSB2.13 299.47,43.57 ; JUSB2.13 296.53,42.69 ; JUSB2.13 298,42.69 ; JUSB2.13 296.53,44.45 ; JUSB2.13 298,44.45 ; JUSB2.13 296.53,43.57 ; 295.77,55.56 JUSB2.4 ; JUSB2.4 296.41,54.09 ; JUSB2.4 297.04,54.29 ; JUSB2.4 295.58,54.92 ; JUSB2.4 296.41,55.75 ; JUSB2.4 295.77,54.29 ; 57.49,55.72 H23.1 ; H23.1 55.81,57.4 ; H23.1 57.49,59.08 ; H23.1 56.25,58.64 ; H23.1 58.73,58.64 ; H23.1 56.25,56.16 ; H23.1 58.73,56.16 ; H23.1 59.17,57.4 ; JUSB2.11 305.5,60.15 ; JUSB2.11 304.13,60.15 ; JUSB2.11 306.87,60.15 ; JUSB2.11 304.13,59.27 ; JUSB2.11 306.87,59.27 ; 296.41,33.39 JUSB1.4 ; JUSB1.4 296.41,35.05 ; JUSB1.4 295.77,33.59 ; JUSB1.4 295.58,34.22 ; JUSB1.4 297.04,33.59 ; JUSB1.4 295.77,34.86 ; 301.41,76.62 JHDMI1.5 ; JHDMI1.5 302.31,76.62 ; JHDMI1.5 301.3,76.17 ; JHDMI1.5 302.42,76.17 ; JHDMI1.5 301.41,75.72 ; JHDMI1.5 302.31,75.72 ; 83.85,130.24 H10.1 ; H10.1 85.19,127.07 ; H10.1 83.85,127.56 ; H10.1 85.19,130.73 ; H10.1 87.02,128.9 ; H10.1 86.53,130.24 ; H10.1 86.53,127.56 ; H10.1 83.36,128.9 ; 297.91,29.89 JUSB1.7 ; JUSB1.7 297.27,30.09 ; JUSB1.7 297.27,31.36 ; JUSB1.7 297.08,30.72 ; JUSB1.7 297.91,31.55 ; H6.1 212.18,67.06 ; H6.1 210.69,66.52 ; H6.1 210.69,70.58 ; H6.1 212.72,68.55 ; H6.1 208.66,68.55 ; H6.1 209.2,67.06 ; H6.1 209.2,70.04 ; H6.1 212.18,70.04 ; 304.13,39.45 JUSB1.11 ; JUSB1.11 305.5,39.45 ; JUSB1.11 304.13,38.57 ; JUSB1.11 306.87,38.57 ; JHDMI1.21 301.09,67.3 ; JHDMI1.21 302.74,65.54 ; JHDMI1.21 301.09,65.54 ; JHDMI1.21 299.44,66.42 ; JHDMI1.21 299.44,65.54 ; JHDMI1.21 299.44,67.3 ; JHDMI1.21 302.74,67.3 ; 299.44,81.8 JHDMI1.20 ; JHDMI1.20 301.09,81.8 ; JHDMI1.20 299.44,80.04 ; JHDMI1.20 301.09,80.04 ; JHDMI1.20 299.44,80.92 ; JHDMI1.20 302.74,80.04 ; JHDMI1.20 302.74,81.8
  VCC w0.203: H5.1 196.29,116.18 ; H5.1 194.8,115.64 ; H5.1 197.78,115.64 ; H5.1 197.78,112.66 ; H5.1 194.8,112.66 ; H5.1 198.32,114.15 ; H5.1 196.29,112.12 ; H5.1 194.26,114.15 ; 192.75,130.24 H11.1 ; H11.1 194.09,127.07 ; H11.1 195.43,130.24 ; H11.1 192.26,128.9 ; H11.1 195.43,127.56 ; H11.1 192.75,127.56 ; H11.1 195.92,128.9 ; H11.1 194.09,130.73 ; JUSB2.12 306.87,43.57 ; JUSB2.12 304.13,43.57 ; JUSB2.12 304.13,42.69 ; JUSB2.12 305.5,42.69 ; JUSB2.12 306.87,42.69 ; 300.21,78.12 JHDMI1.2 ; JHDMI1.2 300.1,77.67 ; JHDMI1.2 301.11,78.12 ; JHDMI1.2 300.21,77.22 ; JHDMI1.2 301.11,77.22 ; JHDMI1.2 300.66,78.23 ; JHDMI1.2 301.22,77.67 ; JHDMI1.21 302.74,67.3 ; JHDMI1.21 299.44,65.54 ; JHDMI1.21 301.09,67.3 ; JHDMI1.21 299.44,67.3 ; JHDMI1.21 299.44,66.42 ; JHDMI1.21 302.74,65.54 ; JHDMI1.21 301.09,65.54 ; H19.1 215.48,51.76 ; H19.1 215.48,54.44 ; H19.1 212.31,53.1 ; H19.1 212.8,51.76 ; H19.1 215.97,53.1 ; H19.1 214.14,51.27 ; H19.1 212.8,54.44 ; H19.1 214.14,54.93 ; JHDMI1.20 302.74,81.8 ; JHDMI1.20 301.09,80.04 ; JHDMI1.20 301.09,81.8 ; JHDMI1.20 302.74,80.04 ; JHDMI1.20 299.44,80.04 ; JHDMI1.20 299.44,80.92 ; JHDMI1.20 299.44,81.8 ; JUSB2.13 299.47,42.69 ; JUSB2.13 298,42.69 ; JUSB2.13 299.47,43.57 ; JUSB2.13 296.53,42.69 ; JUSB2.13 296.53,44.45 ; JUSB2.13 296.53,43.57 ; JUSB2.13 298,44.45 ; JUSB1.12 306.87,22.87 ; JUSB1.12 306.87,21.99 ; JUSB1.12 304.13,22.87 ; JUSB1.12 304.13,21.99 ; JUSB1.12 305.5,21.99 ; 139.79,102.26 H2.1 ; H2.1 138.12,102.88 ; H2.1 141.46,106.22 ; H2.1 141.46,102.88 ; H2.1 137.5,104.55 ; H2.1 138.12,106.22 ; H2.1 139.79,106.84 ; H2.1 142.08,104.55 ; 301.41,70.62 JHDMI1.17 ; JHDMI1.17 302.42,70.17 ; JHDMI1.17 302.31,69.72 ; JHDMI1.17 301.41,69.72 ; JHDMI1.17 301.3,70.17 ; JHDMI1.17 302.31,70.62 ; 209.2,70.04 H6.1 ; H6.1 210.69,70.58 ; H6.1 212.18,67.06 ; H6.1 212.18,70.04 ; H6.1 210.69,66.52 ; H6.1 212.72,68.55 ; H6.1 208.66,68.55 ; H6.1 209.2,67.06 ; JUSB1.13 298,23.75 ; JUSB1.13 298,21.99 ; JUSB1.13 299.47,22.87 ; JUSB1.13 296.53,21.99 ; JUSB1.13 296.53,22.87 ; JUSB1.13 296.53,23.75 ; JUSB1.13 299.47,21.99 ; 300.21,74.22 JHDMI1.8 ; JHDMI1.8 300.21,75.12 ; JHDMI1.8 301.22,74.67 ; JHDMI1.8 301.11,74.22 ; JHDMI1.8 300.1,74.67 ; JHDMI1.8 301.11,75.12 ; 304.13,38.57 JUSB1.11 ; JUSB1.11 306.87,38.57 ; JUSB1.11 305.5,39.45 ; JUSB1.11 304.13,39.45 ; JUSB2.4 296.41,55.75 ; JUSB2.4 295.77,55.56 ; JUSB2.4 295.77,54.29 ; JUSB2.4 296.41,54.09 ; JUSB2.4 297.04,54.29 ; JUSB2.4 295.58,54.92 ; JHDMI1.11 302.31,72.72 ; JHDMI1.11 302.31,73.62 ; JHDMI1.11 301.41,73.62 ; JHDMI1.11 302.42,73.17 ; JHDMI1.11 301.3,73.17 ; JHDMI1.11 301.41,72.72 ; 295.77,34.86 JUSB1.4 ; JUSB1.4 296.41,35.05 ; JUSB1.4 295.58,34.22 ; JUSB1.4 297.04,33.59 ; JUSB1.4 296.41,33.39 ; JUSB1.4 295.77,33.59 ; JLAN.10 309.22,94.44 ; JLAN.10 307.47,93.39 ; JLAN.10 306.59,93.39 ; 301.3,76.17 JHDMI1.5 ; JHDMI1.5 301.41,76.62 ; JHDMI1.5 301.41,75.72 ; JHDMI1.5 302.31,75.72 ; JHDMI1.5 302.42,76.17 ; JHDMI1.5 302.31,76.62 ; JUSB1.10 299.47,39.45 ; JUSB1.10 298,39.45 ; JUSB1.10 299.47,38.57 ; JUSB1.10 296.53,38.57 ; JUSB1.10 296.53,39.45 ; JUSB1.10 298,37.69 ; JUSB1.10 296.53,37.69 ; JUSB2.7 297.91,52.25 ; JUSB2.7 297.27,50.79 ; JUSB2.7 297.08,51.42 ; JUSB2.7 297.91,50.59 ; JUSB2.7 297.27,52.06 ; 297.27,31.36 JUSB1.7 ; JUSB1.7 297.91,29.89 ; JUSB1.7 297.27,30.09 ; JUSB1.7 297.08,30.72 ; JUSB1.7 297.91,31.55 ; JUSB2.10 299.47,59.27 ; JUSB2.10 298,58.39 ; JUSB2.10 296.53,59.27 ; JUSB2.10 296.53,58.39 ; JUSB2.10 298,60.15 ; JUSB2.10 299.47,60.15 ; JUSB2.10 296.53,60.15 ; 78.82,68.73 H3.1 ; H3.1 80.49,68.11 ; H3.1 78.2,70.4 ; H3.1 82.16,72.07 ; H3.1 82.16,68.73 ; H3.1 80.49,72.69 ; H3.1 78.82,72.07 ; H3.1 82.78,70.4 ; JUSB2.11 305.5,60.15 ; JUSB2.11 304.13,60.15 ; JUSB2.11 306.87,60.15 ; JUSB2.11 304.13,59.27 ; JUSB2.11 306.87,59.27
  IN2 w0.508: v2(294.97,17.9) 294.97,21.08 293.04,23.02 v2(292.96,23.02)
  GND2 w0.203: JUSB1.11 305.5,39.45 ; JUSB1.11 304.13,39.45 ; JUSB1.11 306.87,38.57 ; JUSB1.11 304.13,38.57 ; JUSB2.11 305.5,60.15 ; JUSB2.11 304.13,60.15 ; JUSB2.11 306.87,59.27 ; JUSB2.11 304.13,59.27 ; JUSB2.11 306.87,60.15 ; 137.5,71 H4.1 ; H4.1 141.46,72.67 ; H4.1 139.79,73.29 ; H4.1 138.12,69.33 ; H4.1 141.46,69.33 ; H4.1 142.08,71 ; H4.1 138.12,72.67 ; H4.1 139.79,68.71 ; H6.1 210.69,70.58 ; H6.1 208.66,68.55 ; H6.1 209.2,67.06 ; H6.1 212.72,68.55 ; H6.1 212.18,70.04 ; H6.1 210.69,66.52 ; H6.1 209.2,70.04 ; H6.1 212.18,67.06 ; H10.1 87.02,128.9 ; H10.1 83.36,128.9 ; H10.1 83.85,127.56 ; H10.1 86.53,130.24 ; H10.1 85.19,130.73 ; H10.1 86.53,127.56 ; H10.1 83.85,130.24 ; H10.1 85.19,127.07 ; 296.53,43.57 JUSB2.13 ; JUSB2.13 298,42.69 ; JUSB2.13 299.47,42.69 ; JUSB2.13 296.53,42.69 ; JUSB2.13 298,44.45 ; JUSB2.13 296.53,44.45 ; JUSB2.13 299.47,43.57 ; 78.82,107.13 H1.1 ; H1.1 80.49,106.51 ; H1.1 78.2,108.8 ; H1.1 82.78,108.8 ; H1.1 82.16,107.13 ; H1.1 78.82,110.47 ; H1.1 82.16,110.47 ; H1.1 80.49,111.09 ; 297.27,31.36 JUSB1.7 ; JUSB1.7 297.91,29.89 ; JUSB1.7 297.27,30.09 ; JUSB1.7 297.91,31.55 ; JUSB1.7 297.08,30.72 ; 296.41,54.09 JUSB2.4 ; JUSB2.4 295.77,55.56 ; JUSB2.4 297.04,54.29 ; JUSB2.4 295.77,54.29 ; JUSB2.4 295.58,54.92 ; JUSB2.4 296.41,55.75 ; H11.1 195.43,130.24 ; H11.1 195.43,127.56 ; H11.1 194.09,127.07 ; H11.1 192.26,128.9 ; H11.1 192.75,130.24 ; H11.1 192.75,127.56 ; H11.1 194.09,130.73 ; H11.1 195.92,128.9 ; 305.72,112.71 JLAN.9 ; JLAN.9 305.72,114.29 ; JLAN.9 308.35,114.29 ; JLAN.9 305.72,113.24 ; JLAN.9 309.22,113.77 ; JLAN.9 309.22,113.24 ; JLAN.9 309.22,114.29 ; JLAN.9 307.47,114.29 ; 284.06,107.9 H12.1 ; H12.1 284.55,106.56 ; H12.1 284.14,107.16 ; H12.1 287.23,106.56 ; H12.1 287.23,109.24 ; H12.1 285.15,106.15 ; H12.1 286.63,109.65 ; H12.1 284.55,109.24 ; H12.1 287.72,107.9 ; H12.1 285.89,106.07 ; H12.1 285.89,109.73 ; 301.41,72.72 JHDMI1.11 ; JHDMI1.11 301.41,73.62 ; JHDMI1.11 302.42,73.17 ; JHDMI1.11 301.3,73.17 ; JHDMI1.11 302.31,73.62 ; JHDMI1.11 302.31,72.72 ; 301.3,76.17 JHDMI1.5 ; JHDMI1.5 301.41,76.62 ; JHDMI1.5 302.31,76.62 ; JHDMI1.5 302.31,75.72 ; JHDMI1.5 302.42,76.17 ; JHDMI1.5 301.41,75.72 ; H20.1 42.31,43.27 ; H20.1 40.79,43.83 ; H20.1 40.79,39.67 ; H20.1 42.87,41.75 ; H20.1 39.27,43.27 ; H20.1 42.31,40.23 ; H20.1 39.27,40.23 ; H20.1 38.71,41.75 ; H19.1 215.48,51.76 ; H19.1 214.14,54.93 ; H19.1 215.97,53.1 ; H19.1 212.8,51.76 ; H19.1 212.31,53.1 ; H19.1 212.8,54.44 ; H19.1 214.14,51.27 ; H19.1 215.48,54.44 ; JUSB1.4 297.04,33.59 ; JUSB1.4 295.77,33.59 ; JUSB1.4 296.41,35.05 ; JUSB1.4 295.77,34.86 ; JUSB1.4 296.41,33.39 ; JUSB1.4 295.58,34.22 ; JHDMI1.21 302.74,67.3 ; JHDMI1.21 302.74,65.54 ; JHDMI1.21 299.44,65.54 ; JHDMI1.21 301.09,67.3 ; JHDMI1.21 299.44,67.3 ; JHDMI1.21 301.09,65.54 ; JHDMI1.21 299.44,66.42 ; H17.1 66.63,78.24 ; H17.1 66.63,75.56 ; H17.1 67.12,76.9 ; H17.1 63.46,76.9 ; H17.1 65.29,78.73 ; H17.1 63.95,78.24 ; H17.1 63.95,75.56 ; H17.1 65.29,75.07 ; JHDMI1.8 301.11,74.22 ; JHDMI1.8 301.11,75.12 ; JHDMI1.8 300.1,74.67 ; JHDMI1.8 301.22,74.67 ; JHDMI1.8 300.21,75.12 ; JHDMI1.8 300.21,74.22 ; H13.1 306.47,119.2 ; H13.1 303.11,119.2 ; H13.1 304.79,120.88 ; H13.1 303.55,120.44 ; H13.1 306.03,117.96 ; H13.1 303.18,118.52 ; H13.1 304.79,117.52 ; H13.1 303.55,117.96 ; H13.1 305.47,120.81 ; H13.1 304.11,117.59 ; H13.1 306.03,120.44 ; H3.1 80.49,72.69 ; H3.1 82.78,70.4 ; H3.1 82.16,72.07 ; H3.1 78.82,72.07 ; H3.1 78.2,70.4 ; H3.1 78.82,68.73 ; H3.1 80.49,68.11 ; H3.1 82.16,68.73 ; 301.41,70.62 JHDMI1.17 ; JHDMI1.17 302.31,70.62 ; JHDMI1.17 301.41,69.72 ; JHDMI1.17 302.42,70.17 ; JHDMI1.17 302.31,69.72 ; JHDMI1.17 301.3,70.17 ; 304.13,42.69 JUSB2.12 ; JUSB2.12 306.87,42.69 ; JUSB2.12 305.5,42.69 ; JUSB2.12 304.13,43.57 ; JUSB2.12 306.87,43.57 ; 55.81,57.4 H23.1 ; H23.1 57.49,59.08 ; H23.1 59.17,57.4 ; H23.1 56.25,58.64 ; H23.1 56.25,56.16 ; H23.1 58.73,58.64 ; H23.1 57.49,55.72 ; H23.1 58.73,56.16 ; 298,37.69 JUSB1.10 ; JUSB1.10 299.47,39.45 ; JUSB1.10 296.53,39.45 ; JUSB1.10 298,39.45 ; JUSB1.10 296.53,38.57 ; JUSB1.10 299.47,38.57 ; JUSB1.10 296.53,37.69 ; JHDMI1.2 301.11,77.22 ; JHDMI1.2 300.1,77.67 ; JHDMI1.2 300.21,77.22 ; JHDMI1.2 301.11,78.12 ; JHDMI1.2 301.22,77.67 ; JHDMI1.2 300.66,78.23 ; JHDMI1.2 300.21,78.12 ; JLAN.10 309.22,94.44 ; JLAN.10 306.59,93.39 ; JLAN.10 307.47,93.39 ; 137.5,104.55 H2.1 ; H2.1 142.08,104.55 ; H2.1 138.12,106.22 ; H2.1 141.46,106.22 ; H2.1 141.46,102.88 ; H2.1 139.79,102.26 ; H2.1 138.12,102.88 ; H2.1 139.79,106.84 ; JUSB1.12 306.87,21.99 ; JUSB1.12 304.13,22.87 ; JUSB1.12 304.13,21.99 ; JUSB1.12 306.87,22.87 ; JUSB1.12 305.5,21.99 ; 88.64,5.29 H56.1 ; H56.1 89.88,5.73 ; H56.1 87.4,5.73 ; H56.1 86.96,6.97 ; H56.1 90.32,6.97 ; 86.71,8.57 H57.1 ; H57.1 90.06,9.99 ; H57.1 90.57,8.57 ; H57.1 88.64,10.5 ; H57.1 87.22,9.99 ; JUSB1.13 299.47,22.87 ; JUSB1.13 296.53,21.99 ; JUSB1.13 296.53,22.87 ; JUSB1.13 298,23.75 ; JUSB1.13 296.53,23.75 ; JUSB1.13 299.47,21.99 ; JUSB1.13 298,21.99 ; 296.53,60.15 JUSB2.10 ; JUSB2.10 296.53,59.27 ; JUSB2.10 299.47,60.15 ; JUSB2.10 298,58.39 ; JUSB2.10 299.47,59.27 ; JUSB2.10 296.53,58.39 ; JUSB2.10 298,60.15 ; 194.26,114.15 H5.1 ; H5.1 194.8,115.64 ; H5.1 194.8,112.66 ; H5.1 196.29,112.12 ; H5.1 198.32,114.15 ; H5.1 197.78,115.64 ; H5.1 197.78,112.66 ; H5.1 196.29,116.18 ; JUSB2.7 297.91,52.25 ; JUSB2.7 297.91,50.59 ; JUSB2.7 297.27,50.79 ; JUSB2.7 297.08,51.42 ; JUSB2.7 297.27,52.06 ; JHDMI1.20 301.09,81.8 ; JHDMI1.20 299.44,80.92 ; JHDMI1.20 301.09,80.04 ; JHDMI1.20 299.44,80.04 ; JHDMI1.20 302.74,81.8 ; JHDMI1.20 299.44,81.8 ; JHDMI1.20 302.74,80.04
  BOTTOM w0.102: v2(109.36,132.6) 109.2,132.76 109.2,132.83 v3(108.76,133.28) ; v3(53.12,32.3) 53.12,32.76 v2(52.97,32.91) ; v2(110.37,125.21) 110.5,125.21
  BOTTOM w0.127: 176.83,44.36 176.83,44.28 176.44,43.89 176.34,43.89 176.18,43.73 176.18,43.37 UH2.B6 ; v2(175.57,72.46) 175.57,71.06 YV1.4 ; v3(77.94,95.52) 78.17,95.29 v2(78.17,94.25) ; v3(14.31,24.11) v2(13.57,24.11) ; v3(64.7,64.89) v2(65.54,64.89) ; v2(179.64,72.86) 179.96,72.55 179.96,69.38 179.64,69.07 178.01,69.07 177.77,69.31 v2(177.77,69.93) ; v3(281.31,25.35) v2(281.31,24.76)
  BOTTOM w0.152: 170.04,32.52 UH2.AC18 ; UH2.AC18 170.61,33.09 ; UH2.AC18 170.04,33.09 ; UH2.AL29 165.33,29.28 ; UH2.AL29 164.76,28.71 ; UH2.AL29 165.33,28.71 ; UH2.AL29 164.76,29.28 ; UH2.AF29 165.19,30.97 ; UH2.AF29 164.62,31.54 ; UH2.AF29 164.62,30.97 ; UH2.AF29 165.19,31.54 ; UH2.AG33 163.16,30.74 ; UH2.AG33 163.16,31.31 ; UH2.AG33 162.59,31.31 ; 163.91,34.86 UH2.W31 ; UH2.W31 164.48,34.86 ; UH2.W31 164.48,34.29 ; UH2.AL10 174.83,29.01 ; UH2.AL10 174.26,28.45 ; UH2.AL10 174.83,28.45 ; UH2.AL10 174.26,29.01 ; UH2.AD36 161.63,31.85 ; UH2.AD36 161.63,32.42 ; UH2.AD36 161.06,31.85 ; UH2.AD36 161.06,32.42 ; 166.17,30.19 UH2.AH26 ; UH2.AH26 166.73,30.76 ; UH2.AH26 166.73,30.19 ; UH2.AH26 166.17,30.76 ; 169.26,32.31 UH2.AE20 ; UH2.AE20 169.83,31.74 ; UH2.AE20 169.83,32.31 ; UH2.AE20 169.26,31.74 ; 162.59,31.85 UH2.AD33 ; UH2.AD33 162.59,32.42 ; UH2.AD33 163.16,31.85 ; UH2.AD33 163.16,32.42 ; 166.17,34.07 UH2.Y26 166.73,34.63 ; 169.26,32.52 UH2.AC20 ; UH2.AC20 169.83,33.09 ; UH2.AC20 169.26,33.09 ; UH2.AC20 169.83,32.52 ; 164.62,33.29 UH2.AA29 ; UH2.AA29 165.19,33.29 ; UH2.AA29 165.19,33.86 ; UH2.AA29 164.62,33.86 ; 158.27,39.83 UH2.K43 158.54,39.79 ; UH2.J7 176.27,39.66 ; UH2.J7 175.71,40.23 ; UH2.J7 175.71,39.66 ; UH2.J7 176.27,40.23 ; UH2.AJ10 174.83,30.13 ; UH2.AJ10 174.83,29.56 ; UH2.AJ10 174.26,30.13 ; UH2.AJ10 174.26,29.56 ; 166.94,30.97 UH2.AF25 ; UH2.AF25 167.51,30.97 ; UH2.AF25 166.94,31.54 ; UH2.AF25 167.51,31.54 ; UH2.V45 156.57,35.08 v2(156.57,35.08) ; 165.94,39.74 UH2.K27 ; UH2.K27 166.51,39.17 ; UH2.K27 166.51,39.74 ; 169.26,34.63 UH2.Y20 ; UH2.Y20 169.26,34.07 ; UH2.Y20 169.83,34.07 ; UH2.Y20 169.83,34.63 ; UH2.AB11 174.17,33.75 ; UH2.AB11 173.6,33.18 ; UH2.AB11 173.6,33.75 ; UH2.AB11 174.17,33.18 ; 167.71,34.84 UH2.V23 168.28,34.84 ; UH2.H22 168.95,39.93 ; UH2.H22 168.95,40.5 ; UH2.H22 168.38,40.5 ; UH2.H22 168.38,39.93 ; 174.37,35.47 UH2.U10 ; UH2.U10 174.94,36.04 ; UH2.U10 174.94,35.47 ; UH2.U10 174.37,36.04 ; UH2.AL19 170.06,29.28 ; UH2.AL19 170.06,28.71 ; UH2.AL19 169.49,29.28 ; 166.17,30.97 UH2.AF26 ; UH2.AF26 166.17,31.54 ; UH2.AF26 166.73,31.54 ; UH2.AF26 166.73,30.97 ; UH2.AL32 163.94,28.99 ; UH2.AL32 163.94,28.42 ; UH2.AL32 163.37,28.42 ; UH2.AL32 163.37,28.99 ; 177.15,32.56 UH2.AD4 ; UH2.AD4 177.69,32.02 ; UH2.AD4 177.69,32.56 ; UH2.AN4 177.69,27.48 ; UH2.AN4 177.15,27.48 ; UH2.AN4 177.15,28.01 ; UH2.AC29 165.19,32.52 ; UH2.AC29 164.62,32.52 ; UH2.AC29 165.19,33.09 ; UH2.AC29 164.62,33.09 ; 169.83,35.41 UH2.V20 ; UH2.V20 169.26,34.84 ; UH2.V20 169.83,34.84 ; 174.98,28.1 UH2.AN8 ; UH2.AN8 175.55,27.53 ; UH2.AN8 175.55,28.1 ; UH2.AN8 174.98,27.53 ; 163.35,31.31 UH2.AG32 ; UH2.AG32 163.35,30.74 ; UH2.AG32 163.92,30.74 ; UH2.AG32 163.92,31.31 ; UH2.D27 166.5,41.95 ; UH2.D27 165.97,41.95 ; UH2.D27 165.97,42.49 ; UH2.D27 166.5,42.49 ; UH2.D17 171.05,41.95 ; UH2.D17 171.05,42.49 ; UH2.D17 170.52,41.95 ; UH2.U38 160.97,36.04 ; UH2.U38 160.97,35.47 ; UH2.U38 160.4,36.04 ; UH2.U38 160.4,35.47 ; UH2.U33 163.26,36.04 ; UH2.U33 162.69,35.47 ; UH2.U33 163.26,35.47 ; UH2.U33 162.69,36.04 ; UH2.AJ29 165.19,29.99 ; UH2.AJ29 164.62,29.42 ; UH2.AJ29 165.19,29.42 ; UH2.AJ29 164.62,29.99 ; 163.64,28.06 UH2.AN31 ; UH2.AN31 164.21,28.06 ; UH2.AN31 164.21,27.49 ; UH2.AN31 163.64,27.49 ; UH2.B25 167.04,42.84 ; UH2.B25 167.04,43.37 ; UH2.B25 166.51,42.84 ; 160.4,37.16 UH2.R38 ; UH2.R38 160.4,36.59 ; UH2.R38 160.97,37.16 ; UH2.R38 160.97,36.59 ; UH2.AD14 172.65,32.42 ; UH2.AD14 172.08,32.42 ; UH2.AD14 172.65,31.85 ; UH2.AU39 160.29,25.94 ; UH2.AU39 160.29,25.38 ; UH2.AU39 159.72,25.94 ; UH2.AU45 157.04,25.96 156.75,26.25 156.75,26.38 v2(156.73,26.41) ; 170.04,31.54 UH2.AF18 ; UH2.AF18 170.04,30.97 ; UH2.AF18 170.61,31.54 ; UH2.AF18 170.61,30.97 ; 162.16,27.05 UH2.AR34 ; UH2.AR34 162.16,26.48 ; UH2.AR34 162.73,26.48 ; v2(156.68,28.34) 156.71,28.3 157.15,28.3 UH2.AM45 ; UH2.U14 172.65,36.04 ; UH2.U14 172.08,36.04 ; UH2.U14 172.08,35.47 ; UH2.U14 172.65,35.47 ; UH2.AA21 169.06,33.86 ; UH2.AA21 168.49,33.29 ; UH2.AA21 169.06,33.29 ; UH2.AA21 168.49,33.86 ; 175.11,39.15 UH2.L8 ; UH2.L8 175.68,38.58 ; UH2.L8 175.68,39.15 ; UH2.L8 175.11,38.58 ; UH2.AH45 156.74,30.53 v2(156.7,30.57) ; UH2.AJ31 164.48,29.56 ; UH2.AJ31 164.48,30.13 ; UH2.AJ31 163.91,30.13 ; UH2.AJ31 163.91,29.56 ; UH2.N10 174.18,38.17 ; UH2.N10 174.18,37.6 ; UH2.N10 174.75,38.17 ; 161.65,40.48 UH2.H35 161.65,39.91 ; UH2.AN11 173.47,28.06 ; UH2.AN11 174.04,28.06 ; UH2.AN11 173.47,27.49 ; 170.67,25.67 UH2.AV17 ; UH2.AV17 170.67,25.1 ; UH2.AV17 171.24,25.1 ; UH2.AA17 171.38,33.29 ; UH2.AA17 170.81,33.29 ; UH2.AA17 170.81,33.86 ; UH2.AA17 171.38,33.86 ; 167.08,42.41 UH2.D25 166.47,42.41 ; v2(179.31,32.93) 179.28,32.91 179.24,32.91 179.13,32.79 UH2.AC1 ; UH2.AE18 170.04,31.74 ; UH2.AE18 170.61,31.74 ; UH2.AE18 170.04,32.31 ; UH2.J11 174.36,39.6 ; UH2.J11 173.79,39.6 ; UH2.J11 174.36,40.17 ; UH2.J11 173.79,40.17 ; 164.94,42.2 UH2.D29 165.51,41.94 ; v2(163.48,44.34) 163.48,43.79 163.46,43.77 UH2.A32 ; UH2.AE21 169.06,32.31 ; UH2.AE21 168.49,32.31 ; UH2.AE21 169.06,31.74 ; UH2.AE21 168.49,31.74 ; 167.51,34.84 UH2.V25 166.94,34.84 ; 165.19,35.41 UH2.V29 ; UH2.V29 164.62,35.41 ; UH2.V29 164.62,34.84 ; 176.62,26.35 UH2.AR5 177.15,26.89 ; UH2.AH18 170.61,30.19 ; UH2.AH18 170.61,30.76 ; UH2.AH18 170.04,30.76 ; UH2.AH18 170.04,30.19 ; UH2.N36 161.79,38.07 ; UH2.N36 161.22,37.5 ; UH2.N36 161.22,38.07 ; UH2.N36 161.79,37.5 ; 168.49,32.52 UH2.AC21 ; UH2.AC21 168.49,33.09 ; UH2.AC21 169.06,32.52 ; UH2.AC21 169.06,33.09 ; UH2.V18 170.04,35.41 ; UH2.V18 170.61,35.41 ; UH2.V18 170.04,34.84 ; UH2.BE32 163.45,21.9 162.87,21.33 162.87,21.17 v2(162.72,21.02) ; UH2.AB8 175.7,33.75 ; UH2.AB8 175.13,33.75 ; UH2.AB8 175.13,33.18 ; UH2.AB8 175.7,33.18 ; UH2.C42 159,42.38 ; UH2.C42 159,42.95 ; UH2.C42 158.43,42.38 ; 173.75,26.97 UH2.AP11 ; UH2.AP11 174.32,27.53 ; UH2.AP11 174.32,26.97 ; 168.38,36.88 UH2.P22 ; UH2.P22 168.38,37.45 ; UH2.P22 168.95,37.45 ; 175.36,41.32 UH2.F8 ; UH2.F8 175.36,40.75 ; UH2.F8 175.93,41.32 ; UH2.F8 175.93,40.75 ; 177.14,38.1 UH2.N4 177.14,37.56 ; 172.03,29.56 UH2.AJ14 ; UH2.AJ14 172.6,30.13 ; UH2.AJ14 172.6,29.56 ; UH2.AJ14 172.03,30.13 ; UH2.AJ36 161.63,30.13 ; UH2.AJ36 161.63,29.56 ; UH2.AJ36 161.06,30.13 ; UH2.AJ36 161.06,29.56 ; UH2.AB7 176.46,33.18 ; UH2.AB7 176.46,33.75 ; UH2.AB7 175.89,33.18 ; UH2.AB7 175.89,33.75 ; 176.62,37.16 UH2.R5 ; UH2.R5 176.62,36.63 ; UH2.R5 177.15,37.16 ; UH2.R5 177.15,36.63 ; v2(170.14,44.16) 170.14,44.03 170.28,43.89 UH2.A18 ; UH2.U17 171.38,36.18 ; UH2.U17 170.81,35.61 ; UH2.U17 170.81,36.18 ; UH2.U17 171.38,35.61 ; 170.06,40.5 UH2.H19 ; UH2.H19 169.49,40.5 ; UH2.H19 169.49,39.93 ; UH2.U31 164.48,36.04 ; UH2.U31 163.91,36.04 ; UH2.U31 164.48,35.47 ; UH2.U31 163.91,35.47 ; 165.94,27.96 UH2.AN27 ; UH2.AN27 165.94,27.39 ; UH2.AN27 166.51,27.39 ; UH2.AN27 166.51,27.96 ; 163.4,36.04 UH2.U32 ; UH2.U32 163.97,35.47 ; UH2.U32 163.97,36.04 ; UH2.U32 163.4,35.47 ; 170.81,29.99 UH2.AJ17 ; UH2.AJ17 170.81,29.42 ; UH2.AJ17 171.38,29.42 ; UH2.AJ17 171.38,29.99 ; 175.65,25.52 UH2.AU7 ; UH2.AU7 175.65,26.09 ; UH2.AU7 176.22,25.52 ; UH2.AU7 176.22,26.09 ; UH2.W33 163.16,34.29 ; UH2.W33 163.16,34.86 ; UH2.W33 162.59,34.29 ; UH2.W33 162.59,34.86 ; UH2.AJ28 165.96,29.99 ; UH2.AJ28 165.39,29.42 ; UH2.AJ28 165.39,29.99 ; UH2.AJ28 165.96,29.42 ; UH2.D36 161.42,42.49 ; UH2.D36 161.42,41.95 ; UH2.D36 161.96,42.49 ; 174.34,37.18 UH2.R10 ; UH2.R10 174.34,36.61 ; UH2.R10 174.91,36.61 ; UH2.R33 163.26,37.16 ; UH2.R33 162.69,36.59 ; UH2.R33 163.26,36.59 ; UH2.R33 162.69,37.16 ; 167.59,33.41 UH2.AA25 167.51,33.29 ; UH2.T2 177.91,36.3 v2(177.76,36.45) ; UH2.T2 UH2.T1 ; UH2.T2 178,36.02 ; UH2.T2 178,36.58 ; UH2.G42 v2(158.22,40.61) ; UH2.G42 158.3,41.27 ; UH2.G42 158.83,40.74 ; UH2.G42 158.83,41.27 ; UH2.G42 158.3,40.74 ; 174.21,28.1 UH2.AN10 ; UH2.AN10 174.78,27.53 ; UH2.AN10 174.78,28.1 ; UH2.AN10 174.21,27.53 ; UH2.AE4 177.6,31.45 ; UH2.AE4 177.6,32.06 ; UH2.AE4 177.04,31.45 ; 172.05,36.61 UH2.R14 ; UH2.R14 172.62,36.61 ; UH2.R14 172.62,37.18 ; UH2.R14 172.05,37.18 ; UH2.AG13 173.41,30.74 ; UH2.AG13 172.84,30.74 ; UH2.AG13 172.84,31.31 ; 168.49,30.76 UH2.AH21 169.06,30.76 ; 161,25.58 UH2.AU36 ; UH2.AU36 161.57,25.58 ; UH2.AU36 161.57,26.15 ; 167.05,37.64 UH2.N24 ; UH2.N24 167.05,38.21 ; UH2.N24 167.62,37.64 ; UH2.N24 167.62,38.21 ; UH2.N19 170.06,38.21 ; UH2.N19 170.06,37.64 ; UH2.N19 169.49,37.64 ; UH2.N19 169.49,38.21 ; UH2.B37 161.08,43.34 161.16,43.41 UH2.A37 ; UH2.B37 161.36,42.88 ; UH2.B37 161.36,42.73 ; 162.61,28.99 UH2.AL33 ; UH2.AL33 163.18,28.42 ; UH2.AL33 162.61,28.42 ; UH2.AL33 163.18,28.99 ; UH2.N41 159.48,37.7 ; UH2.N41 159.48,38.23 ; UH2.N41 158.95,38.23 ; UH2.N41 158.95,37.7 ; UH2.D45 156.82,42.26 v2(156.65,42.08) ; 163.7,41.95 UH2.D31 ; UH2.D31 164.23,42.49 ; UH2.D31 164.23,41.95 ; UH2.D31 163.7,42.49 ; 160.72,25.15 UH2.AW37 160.72,24.58 ; UH2.AL24 167.62,28.71 ; UH2.AL24 167.05,29.28 ; UH2.AL24 167.62,29.28 ; UH2.AL24 167.05,28.71 ; UH2.D35 162.53,41.85 ; UH2.D35 162.53,42.41 ; UH2.D35 161.92,42.41 ; UH2.AB38 160.87,33.18 ; UH2.AB38 160.3,33.75 ; UH2.AB38 160.3,33.18 ; UH2.AB38 160.87,33.75 ; 172.08,33.18 UH2.AB14 ; UH2.AB14 172.65,33.18 ; UH2.AB14 172.65,33.75 ; 163.24,41.94 UH2.D33 162.7,41.94 ; 166.94,31.74 UH2.AE25 167.51,31.74 ; UH2.N22 168.95,38.21 ; UH2.N22 168.38,37.64 ; UH2.N22 168.95,37.64 ; UH2.N22 168.38,38.21 ; 164.76,36.89 UH2.R29 ; UH2.R29 164.76,36.32 ; UH2.R29 165.33,36.89 ; UH2.R29 165.33,36.32 ; 168.49,34.63 UH2.Y21 ; UH2.Y21 168.49,34.07 ; UH2.Y21 169.06,34.63 ; UH2.Y21 169.06,34.07 ; 176.49,38.15 UH2.N5 ; UH2.N5 177.02,37.62 ; UH2.N5 177.02,38.15 ; UH2.N5 176.49,37.62 ; 167.71,31.54 UH2.AF23 ; UH2.AF23 168.28,30.97 ; UH2.AF23 167.71,30.97 ; UH2.AF23 168.28,31.54 ; UH2.AE28 165.96,31.74 ; UH2.AE28 165.39,32.31 ; UH2.AE28 165.39,31.74 ; 167.33,25.06 UH2.AV24 167.62,25.67 ; 169.26,30.76 UH2.AH20 ; UH2.AH20 169.83,30.19 ; UH2.AH20 169.83,30.76 ; 163.91,30.74 UH2.AG31 ; UH2.AG31 164.48,30.74 ; UH2.AG31 163.91,31.31 ; UH2.AG31 164.48,31.31 ; UH2.AR7 176.28,26.48 ; UH2.AR7 175.71,26.48 ; UH2.AR7 175.71,27.05 ; 165.39,30.97 UH2.AF28 ; UH2.AF28 165.96,31.54 ; UH2.AF28 165.39,31.54 ; UH2.AF28 165.96,30.97 ; 170.06,41.94 UH2.D19 169.52,41.94 ; UH2.AJ18 170.61,29.42 ; UH2.AJ18 170.61,29.99 ; UH2.AJ18 170.04,29.99 ; UH2.AJ18 170.04,29.42 ; 162.65,41.82 UH2.E33 ; UH2.E33 162.65,41.29 ; UH2.E33 163.18,41.29 ; UH2.E33 163.18,41.82 ; 164.62,34.63 UH2.Y29 ; UH2.Y29 165.19,34.07 ; UH2.Y29 164.62,34.07 ; 161.05,26.77 UH2.AT36 ; UH2.AT36 161.62,26.21 ; UH2.AT36 161.62,26.77 ; UH2.J39 160.35,40.08 ; UH2.J39 159.78,39.51 ; UH2.J39 159.78,40.08 ; UH2.J39 160.35,39.51 ; 177.33,38.27 UH2.L4 177.05,38.27 ; 173.9,41.85 UH2.D12 173.9,42.41 ; UH2.BB11 173.54,23.7 v2(173.54,23.92) ; UH2.AF21 169.06,30.97 ; UH2.AF21 168.49,31.54 ; UH2.AF21 169.06,31.54 ; UH2.AF21 168.49,30.97 ; UH2.AR42 158.64,27.07 v2(158.18,27.07) ; 171.38,34.63 UH2.Y17 ; UH2.Y17 171.38,34.07 ; UH2.Y17 170.81,34.07 ; 158.85,38.72 UH2.L41 ; UH2.L41 159.38,39.25 ; UH2.L41 159.38,38.72 ; 171.24,36.83 UH2.P17 170.67,37.4 ; 173.27,39.13 UH2.L12 ; UH2.L12 173.84,39.13 ; UH2.L12 173.84,38.56 ; 170.06,28.72 UH2.AM19 169.49,28.15 ; UH2.AA18 170.61,33.29 ; UH2.AA18 170.04,33.86 ; UH2.AA18 170.04,33.29 ; UH2.AA18 170.61,33.86 ; UH2.AJ26 166.73,29.42 ; UH2.AJ26 166.17,29.42 ; UH2.AJ26 166.17,29.99 ; UH2.AJ26 166.73,29.99 ; UH2.K10 174.95,39.4 ; UH2.K10 174.38,39.4 ; UH2.K10 174.95,38.83 ; UH2.K10 174.38,38.83 ; 164.62,31.74 UH2.AE29 ; UH2.AE29 165.19,31.74 ; UH2.AE29 164.62,32.31 ; UH2.AE29 165.19,32.31 ; 174.6,41.94 UH2.D10 174.03,42.2 ; UH2.AV6 176.52,25.44 ; UH2.AV6 176.52,24.87 ; UH2.AV6 175.95,24.87 ; UH2.AV6 175.95,25.44 ; UH2.AA20 169.83,33.29 ; UH2.AA20 169.83,33.86 ; UH2.AA20 169.26,33.86 ; UH2.AA20 169.26,33.29 ; UH2.AT9 175.22,26.37 ; UH2.AT9 174.65,26.37 ; UH2.AT9 175.22,25.8 ; UH2.AH28 165.96,30.76 ; UH2.AH28 165.39,30.76 ; UH2.AH28 165.96,30.19 ; UH2.AH28 165.39,30.19 ; 174.72,42.22 UH2.C10 174.99,42.26 ; 162.24,38.64 UH2.M35 ; UH2.M35 161.67,38.07 ; UH2.M35 161.67,38.64 ; 173.5,28.45 UH2.AL11 ; UH2.AL11 174.07,28.45 ; UH2.AL11 173.5,29.01 ; UH2.AL11 174.07,29.01 ; v2(164.49,22.99) 164.49,23.04 UH2.BB30 ; UH2.AM22 168.95,28.15 ; UH2.AM22 168.38,28.72 ; UH2.AM22 168.38,28.15 ; 171.79,38.3 UH2.L15 ; UH2.L15 172.36,38.3 ; UH2.L15 171.79,38.87 ; UH2.L15 172.36,38.87 ; 164.81,42.41 UH2.D30 ; UH2.D30 164.2,42.41 ; UH2.D30 164.2,41.85 ; 167.05,43.61 UH2.A25 167.05,43.31 ; v2(157.04,37.96) 157.04,37.5 UH2.P45 ; 170.81,30.76 UH2.AH17 ; UH2.AH17 170.81,30.19 ; UH2.AH17 171.38,30.76 ; UH2.AH17 171.38,30.19 ; 169.35,41.85 UH2.D21 169.35,42.41 ; UH2.Y18 170.04,34.07 ; UH2.Y18 170.61,34.07 ; UH2.Y18 170.04,34.63 ; 169.26,31.54 UH2.AF20 ; UH2.AF20 169.83,30.97 ; UH2.AF20 169.26,30.97 ; UH2.AF20 169.83,31.54 ; 174.03,25.85 UH2.AT10 ; UH2.AT10 174.6,26.42 ; UH2.AT10 174.03,26.42 ; v2(158.23,29.45) 158.38,29.3 UH2.AK42 ; UH2.U29 165.19,36.18 ; UH2.U29 165.19,35.61 ; UH2.U29 164.62,36.18 ; UH2.U29 164.62,35.61 ; 163.26,27.33 UH2.AR33 162.69,27.33 ; 158.95,33.85 UH2.AA42 158.95,34.15 ; 177.2,33.73 UH2.AB5 ; UH2.AB5 176.67,33.2 ; UH2.AB5 176.67,33.73 ; 175.13,34.29 UH2.W8 ; UH2.W8 175.7,34.29 ; UH2.W8 175.7,34.86 ; UH2.W8 175.13,34.86 ; UH2.T4 177.61,35.99 ; UH2.T4 177.05,36.6 ; UH2.T4 177.61,36.6 ; 171.8,41.9 UH2.E15 ; UH2.E15 172.34,41.9 ; UH2.E15 171.8,41.37 ; UH2.E15 172.34,41.37 ; UH2.AD32 163.92,31.85 ; UH2.AD32 163.35,31.85 ; UH2.AD32 163.35,32.42 ; UH2.AD32 163.92,32.42 ; 171.81,25.89 UH2.AT15 171.81,26.46 ; 175.43,25.09 UH2.AW9 175.43,24.53 ; UH2.H24 167.62,39.93 ; UH2.H24 167.05,39.93 ; UH2.H24 167.62,40.5 ; 177.6,27.51 UH2.AP4 ; UH2.AP4 177.6,26.9 ; UH2.AP4 177.04,26.9 ; UH2.U8 175.7,35.47 ; UH2.U8 175.13,35.47 ; UH2.U8 175.7,36.04 ; UH2.U8 175.13,36.04 ; 173.6,32.42 UH2.AD11 ; UH2.AD11 174.17,32.42 ; UH2.AD11 174.17,31.85 ; 171.79,37.54 UH2.N15 ; UH2.N15 172.36,37.54 ; UH2.N15 171.79,38.11 ; UH2.N15 172.36,38.11 ; UH2.U18 170.61,35.61 ; UH2.U18 170.61,36.18 ; UH2.U18 170.04,36.18 ; UH2.U18 170.04,35.61 ; 174.71,41.02 UH2.G9 ; UH2.G9 175.28,40.45 ; UH2.G9 174.71,40.45 ; UH2.G9 175.28,41.02 ; UH2.R22 168.38,36.32 ; UH2.R22 168.95,36.32 ; UH2.R22 168.38,36.89 ; 167.78,41.94 UH2.D24 167.21,42.2 ; 158.83,43.33 UH2.A42 158.71,43.25 ; UH2.W14 172.65,34.29 ; UH2.W14 172.65,34.86 ; UH2.W14 172.08,34.86 ; UH2.AR9 175.37,26.44 ; UH2.AR9 175.37,27.01 ; UH2.AR9 174.8,27.01 ; UH2.AR9 174.8,26.44 ; 161.64,26 UH2.AU35 162.21,26 ; UH2.AL13 173.31,28.45 ; UH2.AL13 172.74,28.45 ; UH2.AL13 173.31,29.01 ; UH2.AL13 172.74,29.01 ; 166.23,25.72 UH2.AV27 166.51,25.67 ; 177.4,32.98 UH2.AB4 177.14,33.02 ; UH2.BB16 171.36,23.33 171.36,23.05 171.33,23.03 171.33,23.04 v2(171.32,23.04) ; UH2.M42 158.4,38.7 ; UH2.M42 158.95,38.7 ; UH2.M42 158.4,38.09 ; UH2.AN22 168.95,27.39 ; UH2.AN22 168.38,27.39 ; UH2.AN22 168.38,27.96 ; UH2.AN22 168.95,27.96 ; UH2.AG11 174.17,30.74 ; UH2.AG11 174.17,31.31 ; UH2.AG11 173.6,30.74 ; 167.05,28.72 UH2.AM24 ; UH2.AM24 167.05,28.15 ; UH2.AM24 167.62,28.15 ; UH2.AM24 167.62,28.72 ; 177.89,40.5 UH2.H3 177.62,40.46 ; 177.14,31.28 UH2.AG4 177.4,30.7 ; UH2.AH29 165.19,30.76 ; UH2.AH29 165.19,30.19 ; UH2.AH29 164.62,30.19 ; UH2.AH29 164.62,30.76 ; UH2.AB32 163.92,33.18 ; UH2.AB32 163.35,33.18 ; UH2.AB32 163.35,33.75 ; 177.99,34.9 UH2.V3 177.46,34.9 ; 158.6,38.83 UH2.K42 158.86,39.41 ; 177.61,33.72 UH2.AA4 177.61,34.33 ; UH2.U11 174.17,36.04 ; UH2.U11 174.17,35.47 ; UH2.U11 173.6,36.04 ; UH2.U11 173.6,35.47 ; 167.71,30.76 UH2.AH23 168.28,30.76 ; UH2.AJ15 172.09,29.56 ; UH2.AJ15 172.09,30.13 ; UH2.AJ15 171.52,30.13 ; UH2.AJ15 171.52,29.56 ; UH2.AB15 171.52,33.18 ; UH2.AB15 172.09,33.18 ; UH2.AB15 171.52,33.75 ; 170.67,40.4 UH2.H17 170.95,39.78 ; 165.39,35.61 UH2.U28 ; UH2.U28 165.39,36.18 ; UH2.U28 165.96,36.18 ; UH2.J10 175,40.02 ; UH2.J10 174.43,39.45 ; UH2.J10 175,39.45 ; UH2.J10 174.43,40.02 ; 177.14,28.47 UH2.AL4 177.4,29.04 ; 172.33,41.94 UH2.D15 171.8,41.94 ; 161.4,39.18 UH2.K36 ; UH2.K36 161.4,39.75 ; UH2.K36 161.97,39.18 ; UH2.K36 161.97,39.75 ; UH2.H29 165.33,39.93 ; UH2.H29 165.33,40.5 ; UH2.H29 164.76,39.93 ; 169.49,37.45 UH2.P19 170.06,37.45 ; 161.35,42.79 UH2.C37 161.35,42.26 ; 162.91,38.94 UH2.K33 162.63,38.99 ; 163.91,33.18 UH2.AB31 ; UH2.AB31 164.48,33.18 ; UH2.AB31 164.48,33.75 ; 176.77,39.62 UH2.J5 ; UH2.J5 177.3,39.62 ; UH2.J5 177.3,40.16 ; UH2.J5 176.77,40.16 ; UH2.AM15 172.38,28.18 ; UH2.AM15 171.81,28.75 ; UH2.AM15 171.81,28.18 ; UH2.AM15 172.38,28.75 ; 165.39,34.07 UH2.Y28 165.96,34.07 ; 173.09,25.14 UH2.AW13 173.37,25.09 ; UH2.E31 163.64,41.95 ; UH2.E31 163.64,41.42 ; UH2.E31 164.17,41.95 ; UH2.AB10 174.94,33.75 ; UH2.AB10 174.37,33.75 ; UH2.AB10 174.94,33.18 ; UH2.AB10 174.37,33.18 ; 172.9,41.32 UH2.E13 ; UH2.E13 172.9,41.85 ; UH2.E13 173.43,41.32 ; UH2.E13 173.43,41.85 ; 163.92,34.86 UH2.W32 ; UH2.W32 163.35,34.86 ; UH2.W32 163.35,34.29 ; UH2.AH25 166.94,30.76 ; UH2.AH25 167.51,30.76 ; UH2.AH25 166.94,30.19 ; 177.15,39.38 UH2.K4 177.69,39.38 ; UH2.W38 160.3,34.29 ; UH2.W38 160.3,34.86 ; UH2.W38 160.87,34.29 ; 165.63,42.22 UH2.C28 165.9,42.26 ; 158.4,36.43 UH2.T42 158.95,36.43 ; UH2.AW19 169.77,24.38 169.22,23.83 UH2.BB21 ; UH2.AW19 170.06,24.91 ; UH2.AW19 169.49,24.91 ; v2(156.74,32.97) 156.74,32.97 156.9,32.81 UH2.AC45 ; UH2.AL17 171.24,28.71 ; UH2.AL17 170.67,29.28 ; UH2.AL17 170.67,28.71 ; UH2.AL17 171.24,29.28 ; UH2.AJ32 163.92,30.13 ; UH2.AJ32 163.92,29.56 ; UH2.AJ32 163.35,30.13 ; 160.87,30.74 UH2.AG38 160.87,31.31 ; 164.76,28.77 UH2.AM29 ; UH2.AM29 165.33,28.77 ; UH2.AM29 164.76,28.2 ; UH2.AM29 165.33,28.2 ; 175.74,28.05 UH2.AN7 175.74,27.48 ; UH2.N35 162.53,37.54 ; UH2.N35 162.53,38.11 ; UH2.N35 161.96,37.54 ; 160.64,24.85 UH2.AY38 160.07,24.85 ; UH2.AM27 166.51,28.15 ; UH2.AM27 165.94,28.15 ; UH2.AM27 166.51,28.72 ; 171.02,42.41 UH2.D16 ; UH2.D16 171.63,41.85 ; UH2.D16 171.63,42.41 ; 177.32,29.17 UH2.AK4 177.6,29.17 ; UH2.BB34 v2(162.31,23.01) ; 170.67,28.72 UH2.AM17 ; UH2.AM17 170.67,28.15 ; UH2.AM17 171.24,28.72 ; UH2.AM17 171.24,28.15 ; 171.52,35.47 UH2.U15 ; UH2.U15 172.09,35.47 ; UH2.U15 172.09,36.04 ; UH2.U15 171.52,36.04 ; UH2.BB25 166.76,23.67 166.76,24.07 166.6,24.23 v2(166.6,24.24) ; 168.49,34.84 UH2.V21 169.06,34.84 ; 177.14,35.29 UH2.U4 177.4,35.25 ; 167.39,33.17 UH2.AC25 167.51,33.09 ; 177.15,34.83 UH2.W4 ; UH2.W4 177.69,34.83 ; UH2.W4 177.69,34.3 ; UH2.W4 177.15,34.3 ; UH2.L13 172.74,38.27 ; UH2.L13 173.31,38.27 ; UH2.L13 172.74,38.84 ; 175.49,32.46 175.49,32.21 UH2.AD8 175.27,32.28 175.27,32.43 ; 177.46,39.45 UH2.J3 177.46,39.98 ; 165.94,39.93 UH2.H27 166.51,39.93 ; 159.03,42.89 UH2.B40 159.57,42.89 ; 157.97,40.98 UH2.F44 157.97,41.52 ; UH1.G28 123.98,93.47 123.98,92.58 124.31,92.25 ; v2(172.64,21.2) 172.64,21.88 UH2.BE14
  BOTTOM w0.203: UH1.T3 UH1.T4 UH1.T5 ; UH1.T3 117.46,75.03 v2(117.15,74.72) ; UH1.T3 UH1.T2 UH1.T1 117.55,73.73 v2(117.21,73.39) ; UH1.AP33 103.63,97.11 v2(103.95,97.43) 103.62,97.76 UH1.AP34 ; v2(105.9,82.51) 106.03,82.51 UH1.AL14 ; UH1.A10 128.74,79.63 v2(128.78,79.59) ; UH1.AG8 UH1.AG7 109.09,77.11 UH1.AG6 ; v2(179.31,26.03) 179.23,25.95 UH2.AU1 ; UH1.F13 124.96,81.85 UH1.G12 124.31,81.14 v2(123.98,80.81) ; UH1.AU12 UH1.AU11 ; UH1.AU11 101.3,79.99 101.31,79.95 v2(101.33,79.94) ; UH1.AU11 UH1.AU10 ; UH1.BD37 95.76,99.71 v2(96.08,100.03) 95.75,100.36 UH1.BD38 ; UH1.BA9 v2(98.57,79.34) ; UH1.BA9 UH1.BA10 v2(98.58,79.97) UH1.BA11 v2(98.57,80.61) ; UH1.BA9 UH1.BA8 ; UH1.F15 v2(124.63,83.96) 124.63,84.03 UH1.G16 ; UH1.F15 v2(124.62,83.15) 124.62,83.09 UH1.G14 ; UH1.F15 v2(125.28,83.18) ; v2(92.73,85.54) 92.57,85.7 UH1.BJ18 UH1.BK18 ; UH1.BR36 88.12,99.05 UH1.BT36 v2(86.99,99.05) ; UH1.L33 121.74,97.11 v2(122.06,97.43) 121.73,97.76 UH1.L34 ; UH1.D16 126.91,83.7 UH1.C15 126.91,83.5 v2(127.24,83.17) ; UH1.BL35 90.77,98.41 v2(90.53,98.65) 90.53,98.64 UH1.BM35 ; UH1.BG37 93.39,99.71 v2(93.72,99.38) ; UH1.N10 UH1.N11 ; UH1.N10 120.19,79.6 v2(120.52,79.93) ; UH1.N10 120.04,79.58 120.04,78.97 UH1.N9 120.37,79.25 v2(120.51,79.25) 120.54,79.22 120.54,78.77 UH1.N8 UH1.N7 120.11,77.6 UH1.N6 ; UH1.N11 120.19,80.25 v2(120.52,80.58) ; UH1.N11 UH1.N12 ; UH1.AE34 UH1.AE33 v2(111.04,96.78) ; UH1.BE6 UH1.BF6 UH1.BG6 UH1.BH6 ; UH1.BE6 v2(95.36,76.66) ; UH1.BE6 95.37,77.4 UH1.BD7 UH1.BD8 v2(95.83,78.7) UH1.BD9 v2(95.83,79.34) UH1.BD10 v2(95.84,79.97) UH1.BD11 95.84,80.62 95.84,80.6 ; UV1.B10 UV1.C10 180.39,83.56 180.09,83.26 180.09,82.55 179.85,82.31 179.82,82.31 179.81,82.31 178.6,82.31 178.47,82.44 178.47,83.16 v2(178.47,83.16) ; UH1.BG13 UH1.BG14 93.41,82.2 93.1,81.89 v2(93.1,81.88) 93.1,81.87 92.77,82.2 UH1.BH14 ; UH1.J10 123.48,79.63 v2(123.17,79.93) ; UH1.F2 124.73,74.71 v2(124.66,74.71) 124.98,75.03 UH1.F3 125.05,75.27 124.95,75.37 UH1.F4 ; UH1.G10 124.63,79.3 v2(124.63,79.24) ; v2(89.85,95.54) 89.85,95.62 UH1.BN31 88.88,96.58 UH1.BP33 ; UH1.K1 122.7,73.73 123,74.03 v2(123.04,74.03) 122.69,74.38 UH1.K2 UH1.K3 122.53,75.12 122.53,75.6 UH1.K4 ; v2(86.82,85.66) 86.86,85.7 UH1.BT18 UH1.BR18 UH1.BP18 UH1.BN18 89.53,85.63 v2(89.86,85.3) 90.18,85.63 UH1.BM18 ; v2(120.52,80.58) 120.21,80.9 UH1.N12 ; v2(120.52,80.58) 120.84,80.9 UH1.M12 UH1.M13 UH1.M14 ; UH1.BH7 v2(93.09,77.97) ; UH1.BH7 UH1.BH8 ; UH1.BH7 UH1.BH6 ; UH1.F31 124.5,96.62 124.19,96.62 UH1.H32 ; UH1.G8 UH1.F8 124.96,78.12 v2(125.28,78.45) ; UH1.G8 124.31,77.59 v2(124.4,77.5) 124.26,77.37 UH1.G6 124.31,76.94 124.31,76.38 UH1.G5 ; UH1.G8 124.18,77.92 123.89,77.92 UH1.J7 123.43,77.47 122.83,77.47 UH1.K7 v2(123.14,77.94) 122.79,78.3 UH1.K8 122.79,78.35 122.79,78.89 UH1.K9 122.43,79.25 v2(122.33,79.25) 122.67,79.6 UH1.K10 122.84,79.6 v2(123.17,79.93) ; UH1.BG38 v2(93.72,100.68) ; UH1.C37 127.51,99.64 UH1.B37 128.07,99.64 UH1.A37 128.95,100.52 v2(129.81,100.52) ; RH113.2 181.65,33.26 180.48,32.1 v2(180.48,31.82) ; UH1.T12 117.49,80.9 v2(117.78,80.61) 117.95,80.61 UH1.R12 118.49,81.16 118.89,81.16 UH1.P12 119.37,81.11 119.85,81.11 UH1.N12 ; UH1.T12 UH1.T11 ; UH1.T12 117.15,81.06 116.57,81.06 UH1.V12 ; UH1.T12 UH1.T13 117.18,81.55 v2(116.88,81.85) 117.22,82.2 UH1.T14 ; v2(92,76.66) 92.33,76.34 UH1.BH5 UH1.BH4 UH1.BH3 ; v2(92,76.66) 91.68,76.99 UH1.BK6 UH1.BL6 ; v2(92,76.66) 92.12,76.66 UH1.BH6 ; UH1.BL13 91.17,82.1 ; 91.17,82.1 91.48,81.78 UH1.BK13 ; 91.17,82.1 91.48,82.41 UH1.BK14 91.48,82.55 91.12,82.91 v2(91.12,82.95) 91.12,82.97 91.48,83.33 UH1.BK15 UH1.BJ15 ; UH1.AG6 v2(109.58,77.35) ; UH1.AG6 UH1.AH6 UH1.AJ6 UH1.AJ5 UH1.AJ4 ; UH1.J4 123.79,76.01 123.87,76.01 124.19,76.34 UH1.G5 ; UH1.J4 123.38,75.69 v2(123.04,75.35) 123,75.35 122.66,75.69 UH1.K4 ; UH1.J4 123.5,75.69 123.84,75.35 v2(123.88,75.35) 124.22,75.69 UH1.G4 UH1.F4 ; 124.65,92.61 v2(124.66,92.61) ; 124.65,92.61 124.65,92.6 124.31,92.25 UH1.G26 ; 124.65,92.61 124.65,92.7 UH1.F27 ; v2(112.25,77.38) UH1.AD6 111.39,76.65 v2(111.31,76.65) 111.22,76.65 UH1.AE6 ; v2(112.25,77.38) UH1.AD7 UH1.AD8 ; v2(112.25,77.38) UH1.AC6 ; UH1.BN2 UH1.BM2 UH1.BM3 90.15,75.47 v2(90.32,75.81) 90.08,76.25 UH1.BM5 ; UH1.BH3 92.48,75 92.48,74.42 UH1.BH2 92.2,74.13 UH1.BH1 v2(92.2,73.21) ; UH1.BH3 92.05,74.7 v2(92.02,74.7) ; v2(103.17,99.38) 102.84,99.71 UH1.AR37 ; UH1.AJ4 UH1.AK4 106.51,75.55 106.05,75.55 UH1.AL4 ; UH1.AJ4 UH1.AJ3 107.42,75.03 v2(107.09,74.71) 107.18,74.71 107.51,74.38 UH1.AJ2 107.58,74.34 107.58,73.78 UH1.AJ1 107.44,73.73 v2(107.1,74.07) ; UV1.AL2 157.14,77.01 157.57,77.43 157.57,78.85 v2(157.47,78.95) 157.47,78.96 157.45,78.97 157.45,79.01 157.09,79.38 UV1.AL5 ; UH1.D3 126.48,75.06 v2(126.95,75.06) ; UH1.BR34 UH1.BP34 88.88,97.44 v2(89.21,97.11) 89.53,97.44 UH1.BN34 ; UH2.AV33 163.15,25.62 v2(163.5,25.84) UH2.AV31 ; UH1.BJ31 91.68,95.81 v2(91.35,95.48) 91.75,95.09 UH1.BJ30 91.88,94.97 UH1.BK29 91.27,94.36 UH1.BL29 UH1.BM29 ; UH2.BE40 159.37,21.81 159.37,21.48 v2(159.29,21.4) ; UH1.T11 117.51,80.25 v2(117.78,79.97) 117.7,79.97 UH1.T10 ; UH1.T11 UH1.T10 ; UH1.AU9 UH1.AU10 ; UH1.AU9 UH1.AU8 UH1.AU7 ; UH1.AU9 v2(101.38,78.63) ; UH1.AU10 v2(101.32,79.34) ; UH1.AN5 104.13,76.93 UH1.AN6 104.04,77.13 104.04,77.86 UH1.AP8 103.66,78.3 v2(104.06,78.7) ; UH1.BP21 88.94,88 89.47,88 UH1.BN21 ; UH1.AL7 UH1.AL8 106.4,78.3 v2(106.8,78.7) v2(106.8,79.34) 106.41,78.95 UH1.AL9 ; v2(126.95,75.06) 127.01,75.12 UH1.B3 127.64,74.99 UH1.A3 UH1.A4 ; v2(126.95,75.06) 126.95,74.54 UH1.C2 ; UH1.W12 115.49,80.93 115.05,81.37 115.05,81.83 v2(115.01,81.87) ; UH1.E9 125.61,78.77 v2(125.28,78.45) ; UH1.BJ29 92.24,94.23 v2(92.56,93.91) ; v2(110.46,82.51) 110.31,82.51 UH1.AF14 UH1.AF13 ; UH1.AW3 99.88,75.03 v2(99.55,74.71) ; UH1.AW3 100.03,75 100.03,74.42 UH1.AW2 100.02,74.36 100.02,73.76 UH1.AW1 99.87,73.73 v2(99.55,74.06) ; UH1.AW3 UH1.AW4 UH1.AW5 100.18,76.34 UH1.AU6 100.81,77.05 100.39,77.31 ; UH1.BM7 UH1.BN7 89.53,77.9 v2(89.2,78.23) 89.2,78.14 UH1.BP7 UH1.BR7 ; UH1.BM7 90.11,77.9 90.11,78.54 UH1.BM8 89.85,78.95 v2(89.85,79) 89.85,79.06 UH1.BM9 90.18,79.47 89.86,79.79 ; UH1.BM7 UH1.BL6 ; UH1.T10 UH1.T9 ; UH1.T10 117.58,79.34 v2(117.79,79.34) 117.4,78.95 UH1.T9 ; UH1.AD8 111.78,78.29 v2(111.38,78.62) ; UH1.AD8 111.86,78.32 111.86,78.92 UH1.AD9 ; UH1.AP9 103.85,78.7 v2(104.06,78.7) ; v2(95.83,82.52) 96.16,82.2 UH1.BC14 UH1.BC13 ; 126.31,78.89 126.38,78.96 126.38,79.51 UH1.D10 ; 126.31,78.89 UH1.D9 ; 126.31,78.89 126.86,78.89 UH1.C9 126.91,78.77 v2(127.24,78.45) ; UH1.BN21 89.53,88.13 v2(89.86,88.45) 90.18,88.13 UH1.BM21 ; UH1.BN21 UH1.BN20 89.37,87.11 89.37,86.64 UH1.BN19 ; UH1.A9 UH1.B9 127.56,78.77 v2(127.24,78.45) ; UH1.AC6 UH1.AB6 113.74,76.99 114.4,77.65 UH1.Y7 UH1.Y8 ; UH1.AC6 UH1.AC5 UH1.AC4 112.42,75.69 v2(112.12,75.39) 112.47,75.03 UH1.AC3 UH1.AC2 UH1.AC1 112.57,67.27 113.7,66.13 v2(114.42,66.13) ; v2(128.56,94.22) 128.56,94.15 UH1.A28 ; 89.86,79.79 90.18,80.12 UH1.BM11 v2(89.86,80.58) 89.86,80.65 UH1.BM12 ; 89.86,79.79 89.86,79.72 UH1.BN9 ; UH1.BN14 UH1.BP14 88.88,82.61 v2(88.56,82.94) 88.23,82.62 UH1.BR14 88.11,82.67 87.7,82.67 UH1.BT14 ; UH1.BM38 90.32,100.37 v2(90.69,100.74) 91.03,100.4 UH1.BL38 ; v2(165.4,21.32) 165.4,21.53 165.72,21.84 UH2.BE28 ; UH1.BL6 90.06,76.99 UH1.BM6 89.98,76.36 UH1.BM5 ; v2(114.64,74.73) UH1.W3 ; UH1.W3 UH1.W4 UH1.W5 115.73,76.99 UH1.V6 UH1.U6 116.76,77.08 UH1.T7 UH1.T8 UH1.T9 ; UH1.W3 115.11,75 115.11,74.42 UH1.W2 UH1.W1 115.08,73.25 v2(114.64,72.8) ; UH1.F11 124.96,80.35 v2(125.28,80.02) ; v2(105.08,73.2) 105.02,73.26 UH1.AM1 UH1.AM2 UH1.AM3 105.06,75.07 105.06,75.65 UH1.AM4 UH1.AM5 ; UH1.C25 126.91,91.58 UH1.D26 126.26,92.26 v2(126.6,92.6) ; UH1.A18 128.85,85.93 v2(128.85,86) ; v2(107.1,99.39) 107.43,99.71 UH1.AJ37 UH1.AJ38 ; 119.7,100.03 UH1.P38 ; 119.7,100.03 UH1.P37 ; 119.7,100.03 v2(119.67,100.03) ; UH1.AD9 112.21,79.32 v2(112.3,79.32) ; UH1.AD9 UH1.AD10 ; v2(121.29,95.49) 121.32,95.49 121.67,95.14 UH1.L30 UH1.L29 ; UH1.BM29 UH1.BN29 UH1.BP29 UH1.BR29 ; UH1.BM29 UH1.BM28 90.18,93.5 v2(90.51,93.18) 90.18,92.85 UH1.BM27 ; UH1.AD10 UH1.AD11 112.2,80.61 v2(112.29,80.61) v2(112.3,79.97) 112.21,79.97 UH1.AD10 ; UH1.AY34 98.9,97.76 v2(99.23,97.43) 98.91,97.11 UH1.AY33 ; UH1.AL34 105.86,97.76 v2(105.53,97.43) 105.85,97.11 UH1.AL33 ; v2(86.4,78.88) 86.37,78.91 86.37,79.11 86.67,79.41 87.57,79.41 UH1.BT9 ; UH1.F36 124.82,99.07 125.21,99.46 125.21,100.26 UH1.E38 125.31,100.72 125.36,100.77 125.36,101.29 v2(125.92,101.84) ; UH1.F36 124.68,99.06 UH1.H35 123.89,98.41 UH1.J36 ; UH1.F36 124.96,99.06 UH1.E35 125.66,98.36 125.66,97.78 UH1.E34 125.61,97.6 UH1.D33 126.57,96.64 v2(126.57,96.56) 126.57,96.5 UH1.C31 ; UH1.C27 126.91,93.05 126.58,93.38 v2(126.58,93.39) 126.58,93.48 UH1.D28 ; UH1.BA8 UH1.BA7 98.12,77.62 UH1.BB6 ; UH1.BA8 v2(98.57,78.7) ; UH1.A24 v2(128.85,90.65) ; v2(168.54,21.58) 168.44,21.58 168.03,21.99 UH2.BE23 ; v2(119.65,77.34) 119.3,76.99 UH1.P6 ; UH1.Y10 UH1.Y11 114.76,80.25 v2(115.04,79.97) 114.95,79.97 UH1.Y10 ; UH1.Y10 UH1.Y9 UH1.Y8 ; UH1.BH8 UH1.BH9 UH1.BH10 v2(93.09,79.97) UH1.BH11 ; UH1.BH8 v2(93.09,78.62) ; v2(159.25,100.72) 159.21,100.76 159.21,101.48 159.24,101.51 ; UH1.G5 124.8,76.34 UH1.F5 ; v2(96.87,98.08) 96.54,97.76 UH1.BC34 ; v2(124.63,79.24) 124.96,78.91 UH1.F9 124.96,78.77 v2(125.28,78.45) ; v2(124.63,79.24) 124.63,79.16 UH1.G9 ; v2(124.63,90.26) 124.63,90.19 UH1.G23 ; v2(124.63,90.26) 124.96,89.93 UH1.F23 125.28,89.54 v2(125.28,89.47) ; v2(124.63,90.26) 124.63,90.33 UH1.G24 ; UH1.AR13 103.01,81.87 v2(103.15,81.87) 102.82,82.2 UH1.AR14 102.56,82.2 v2(102.23,81.87) ; UH1.K11 123.04,79.93 v2(123.17,79.93) ; UH1.AR5 v2(102.07,75.97) UH1.AR4 UH1.AR3 UH1.AR2 UH1.AR1 102.51,73.61 101.76,72.86 101.76,72.46 v2(102.14,72.08) ; UH1.Y14 114.68,82.2 v2(115.01,81.87) ; UH1.A20 128.79,87.5 v2(128.9,87.6) ; v2(170.11,21.52) 170.11,21.52 170.11,21.6 170.27,21.75 UH2.BE18 ; UH1.AU7 100.82,77.65 100.39,77.29 100.39,77.31 ; UH1.AU7 101.52,76.99 UH1.AT6 ; UH1.AG10 109.47,79.97 v2(109.55,79.97) ; v2(122.05,100.75) 122.06,100.75 122.45,100.36 UH1.K38 ; UH1.K5 122.66,76.3 122.66,75.72 UH1.K4 ; v2(115.01,81.87) 114.68,81.55 UH1.Y13 ; v2(94.52,72.77) 94.96,73.22 UH1.BE1 UH1.BE2 UH1.BE3 ; v2(96.87,96.78) 96.54,97.11 UH1.BC33 ; v2(101.59,96.78) 101.26,97.11 UH1.AU33 ; UH1.BE3 v2(94.47,74.71) ; UH1.BE3 UH1.BE4 UH1.BE5 95.29,76.66 v2(95.36,76.66) ; UH1.T33 v2(118.13,97.43) 117.8,97.76 UH1.T34 ; UH1.BT32 87.22,97.02 v2(87.08,97.02) ; UH1.A6 128.07,77.28 127.7,76.9 127.33,76.9 UH1.C5 126.42,75.99 126.14,75.99 v2(126.1,75.94) ; UH1.J22 123.04,88.99 123.52,88.99 UH1.H22 123.64,89.04 124.28,89.04 UH1.G22 124.63,88.75 v2(124.63,88.68) 124.96,88.36 UH1.F21 125.28,87.96 v2(125.28,87.9) ; UH1.BM5 90,76.26 UH1.BN4 89.44,75.7 89.1,75.7 v2(89.08,75.67) 88.84,75.67 88.68,75.5 88.1,75.5 87.85,75.75 UH1.BT4 UH1.BT3 ; v2(125.28,84.75) 125.28,84.81 UH1.F17 124.96,85.21 v2(124.63,85.53) 124.63,85.6 UH1.G18 124.28,85.9 123.63,85.9 UH1.H18 UH1.J18 122.9,85.98 v2(122.41,85.98) ; v2(100.39,77.33) 100.39,77.31 ; UH1.F4 UH1.E4 ; UH1.BK25 UH1.BJ25 v2(92.71,91.21) ; v2(182.93,78.32) 182.69,78.56 UV1.B4 ; 159.24,101.51 157.54,101.51 UV1.AL32 ; 159.24,101.51 UV1.AH32 ; v2(104.07,79.97) 103.88,79.97 UH1.AP11 103.97,80.61 v2(104.06,80.61) 104.07,80.6 v2(104.07,79.97) ; v2(104.07,79.97) 104.06,79.97 v2(104.06,79.34) ; v2(91.35,96.78) 91.68,96.46 UH1.BJ32 ; UH1.H12 123.66,81.14 v2(123.98,80.81) ; v2(95.36,76.66) UH1.BD6 UH1.BC6 v2(97.06,76.66) ; v2(115.78,97.42) 115.43,97.76 UH1.W34 ; UH2.BE9 174.92,21.91 174.92,21.37 v2(175.05,21.24) ; UH1.D20 126.91,86.85 UH1.C19 126.91,86.65 v2(126.58,86.32) ; UH1.J25 UH1.H25 123.62,91.44 v2(123.99,91.07) ; v2(86.67,80.94) 86.71,80.97 UH1.BT12 UH1.BR12 UH1.BP12 88.93,80.92 89.48,80.92 UH1.BN12 ; UH1.Y8 114.95,78.67 v2(115.04,78.67) ; UH1.D22 126.91,88.43 UH1.C21 126.91,88.22 v2(127.24,87.9) ; v2(128.66,95.06) 128.66,95.13 UH1.A30 ; UH1.D6 126.91,77.92 UH1.C8 126.91,78.12 v2(127.24,78.45) ; UH1.AG11 109.41,80.57 v2(109.51,80.57) ; v2(92.69,88.9) 92.64,88.85 UH1.BJ22 UH1.BK22 ; UH1.BT5 86.68,76.55 v2(86.55,76.68) ; v2(172.14,104.13) UV1.N33 ; v2(103.17,100.68) 102.84,100.36 UH1.AR38 ; v2(125.28,91.05) 125.28,91.11 UH1.F25 ; UH1.AB34 v2(113.4,97.43) UH1.AB33 ; UH1.AH34 108.35,97.76 v2(108.68,97.43) 108.36,97.11 UH1.AH33 ; v2(127.24,89.47) 126.91,89.8 UH1.C23 126.91,90 UH1.D24 ; UH1.A22 v2(128.85,89.08) ; v2(104.06,79.34) 103.86,79.34 UH1.AP10 ; v2(104.06,79.34) v2(104.06,78.7) ; v2(97.06,76.66) 97.15,76.66 UH1.BB6 ; v2(97.06,76.66) 97.11,76.61 97.11,75.51 97.48,75.14 UH1.BB3 97.5,75.01 97.5,74.41 UH1.BB2 97.49,74.37 97.49,73.75 UH1.BB1 ; UH2.BE37 161.15,21.63 v2(161.25,21.53) ; v2(158.15,31.71) 158.16,31.71 158.3,31.58 UH2.AE42 ; v2(123.98,80.81) 123.98,80.74 UH1.H11 ; UV1.AH5 159.64,79.56 160.07,79.99 160.07,80.53 UV1.AH7 ; UH1.BR21 UH1.BT21 v2(86.72,88.06) ; UH1.D14 126.91,82.13 UH1.C13 126.91,81.92 v2(127.24,81.6) ; UH1.AV38 100.47,100.36 v2(100.8,100.03) 100.48,99.71 UH1.AV37 ; UH1.BB6 UH1.BA6 ; UH1.BB6 97.5,76.96 97.5,76.36 UH1.BB5 97.5,76.31 97.5,75.71 UH1.BB4 ; v2(98.44,99.38) 98.11,99.71 UH1.BA37 98.05,99.78 98.11,99.84 98.11,100.22 98.05,100.29 UH1.BA38 ; v2(164.47,24.81) 164.62,24.81 164.7,24.73 UH2.AW29 ; CE66.2 227.34,28.36 v2(227.34,28.13) ; UH1.BM26 90.51,91.67 v2(90.51,91.6) 90.51,91.53 UH1.BM25 ; UH1.A16 128.8,84.35 128.86,84.42 v2(128.86,84.38) ; UH1.BM23 90.18,89.7 v2(89.86,90.03) 89.53,90.35 UH1.BN24 89.48,90.47 88.94,90.47 UH1.BP24 88.86,90.45 88.26,90.45 UH1.BR24 UH1.BT24 ; v2(127.24,80.02) 126.91,80.35 UH1.C11 126.91,80.55 UH1.D12 ; UH1.U38 v2(117.34,100.03) UH1.U37 ; v2(127.87,92.62) 127.87,92.56 UH1.A26 ; UH1.A14 v2(128.77,82.78) ; 166.23,25.77 166.23,25.77 ; v2(156.63,24.17) 156.8,24.34 UH2.AY45 ; UH1.G20 124.63,87.18 v2(124.63,87.11) 124.96,86.78 UH1.F19 124.96,86.64 v2(124.64,86.32) ; UH1.BF34 94.18,97.76 v2(94.5,97.43) 94.18,97.11 UH1.BF33 ; v2(86.5,92.22) 86.72,92 UH1.BT26 UH1.BR26 UH1.BP26 ; v2(88.03,101.02) 88.03,100.51 UH1.BR38 ; UH1.W33 v2(115.76,96.78) ; UH1.AC37 v2(112.61,99.38) ; v2(127.24,84.75) 126.91,85.07 UH1.C17 126.91,85.28 UH1.D18 ; UH1.N6 UH1.N5 UH1.N4 120.02,75.69 v2(119.69,75.35) 120,75.03 UH1.N3 UH1.N2 UH1.N1 ; UH1.N6 UH1.M6 ; v2(101.59,98.08) 101.27,97.76 UH1.AU34 ; UH1.Y38 v2(114.98,100.03) UH1.Y37 ; UH1.AM38 105.2,100.36 v2(105.53,100.03) 105.21,99.71 UH1.AM37 ; UH2.AH1 v2(179.74,30.52) ; UH1.AC38 v2(112.61,100.68) ; v2(110.05,73.19) UH1.AF1 UH1.AF2 110.03,74.38 109.65,74.64 v2(109.64,74.71) 110.02,74.92 UH1.AF3 UH1.AF4 ; UH1.A12 v2(128.85,81.2)
  BOTTOM w0.254: UV9.M5 v2(201.86,98.99) UV9.L5 ; JNGFF1.37 v2(195.31,23.08) ; UV9.F10 v2(206.26,102.86) ; UV1.B22 181.45,93.56 181.61,93.72 182.68,93.72 v2(182.78,93.61) ; 96.16,26.26 v2(96.09,26.2) ; UV1.AB12 164.36,84.78 v2(164.49,84.78) 164.49,84.9 UV1.AA13 UV1.Y14 ; UV7.K14 v2(156.7,124.09) UV7.K13 ; 176.83,44.36 177.04,44.57 178.44,44.57 179.08,45.2 179.21,45.2 179.22,45.21 181.02,45.21 v2(181.54,45.74) 181.62,45.81 181.62,45.89 182.84,47.11 184.67,47.11 v2(185.05,46.73) 186.7,46.73 186.95,46.47 v2(186.95,44.82) 186.95,42.87 186.49,42.41 v2(185.05,42.41) 183.42,42.41 183.17,42.66 v2(182.2,42.66) 181.8,42.66 181.34,43.12 178.95,43.12 UH2.B1 ; v2(119.56,38.79) 119.42,38.79 119.07,39.15 119.07,39.62 118.65,40.03 JDIMM1.185 ; UV6.U12 v2(184,131.29) ; v2(209.57,107.29) 209.57,107.29 UV9.A14 ; 106.8,79.98 v2(106.8,79.34) ; 106.8,79.98 106.74,79.98 UH1.AL10 ; 106.8,79.98 v2(106.82,80) ; UV7.F10 v2(160.1,127.69) ; UV6.F10 v2(183.2,123.29) UV6.G10 ; PQ203.1 45.03,38.46 PR214.2 ; UV9.R14 v2(199.46,106.19) ; UT1.6 57.55,47.37 v2(57.81,47.11) ; v2(64.93,28.79) 64.7,28.57 63.9,28.57 63.45,29.01 JEDP1.11 ; UV7.H1 v2(166.3,126.49) UV7.H2 ; UV8.D10 v2(199.46,79.88) ; UV6.A12 184.4,118.89 184.03,118.52 v2(184.02,118.52) ; JDIMM2.102 95.91,19.1 95.67,18.86 v2(95.67,18.74) ; v2(206.89,76.56) 206.89,76.91 UV8.N14 ; UV7.R1 v2(166.3,120.89) ; UV8.R4 v2(209.06,85.48) UV8.R3 ; v2(186.35,128.88) 186.32,128.85 186.32,128.81 186.3,128.79 186.3,128.79 UV6.N14 ; JEDP1.30 v2(61.65,38.51) ; v2(266.94,19.78) 266.79,19.78 266.55,19.54 UA2.11 ; UV9.U14 v2(197.86,106.19) ; UH1.BC13 UH1.BC12 96.41,81.02 97.08,81.02 UH1.BB12 97.32,81.02 98,81.02 UH1.BA12 ; UV8.K1 v2(204.26,87.08) UV8.K2 ; v2(133.74,128.11) 133.85,128 PU1503.3 ; UV7.K2 v2(166.3,124.89) UV7.K1 ; UV1.AE2 162.07,76.91 v2(161.69,77.29) ; UV8.R12 v2(209.06,79.08) UV8.R11 ; UV7.N1 v2(166.3,122.49) ; PU500.15 101.15,9.38 v2(101.4,9.13) 101.43,9.1 101.43,8.37 PR505.2 102.19,7.56 102.35,7.56 PC507.2 ; UV8.L10 v2(205.06,80.68) ; UV1.AG11 160.62,84.41 v2(160.94,84.09) ; v2(131.33,125.24) 131.58,125.49 PU1503.10 ; UV8.U3 210.92,85.88 v2(210.98,85.94) ; UV7.U1 v2(166.3,119.29) ; v2(186.12,118.23) 186,118.34 UV6.A14 ; v2(264.09,35.84) 264.09,36.59 264.22,36.72 CM12.2 ; UV6.C12 v2(184,120.89) UV6.C11 ; v2(188.53,30.57) 188.53,30.57 188.53,30.57 188.56,30.54 JNGFF1.10 ; UV8.L5 v2(205.86,83.88) UV8.M5 ; v2(172.86,16.65) 172.86,15.26 173.14,14.98 v2(175.19,14.98) 176.92,14.98 177.17,15.23 177.17,16.35 v2(177.3,16.47) ; 206.47,37.23 206.99,37.23 207.4,36.82 JNGFF2.1 ; 206.47,37.23 v2(206.47,37.26) ; 206.47,37.23 206.44,37.2 206.44,37.02 207.14,36.32 JNGFF2.3 ; UV9.A1 v2(209.86,95.79) ; UV6.M5 v2(179.38,127.69) ; v2(161.71,98.21) 162.11,98.61 UV1.AE28 ; UV8.T5 v2(209.06,83.88) ; v2(127.23,94.17) 127.23,94.27 UH1.C29 126.91,94.65 v2(126.6,94.96) 126.26,95.3 UH1.D30 ; UV6.K14 v2(185.6,126.49) UV6.K13 ; JNGFF1.49 198.31,20.6 198.07,20.36 v2(197.34,20.36) ; UV1.AN10 155.49,83.57 v2(155.91,83.99) ; UV7.C3 v2(164.7,129.69) UV7.C4 ; v2(159.12,93.18) 159.19,93.18 159.57,93.56 UV1.AH22 ; UV9.N12 v2(201.06,104.59) ; UV1.T7 169.63,81.01 169.23,80.61 v2(169.23,80.58) ; UH1.A3 128.47,74.99 v2(128.71,74.74) ; JEDP1.39 63.59,43.01 v2(63.71,42.89) 63.71,43.2 63.4,43.51 JEDP1.40 ; UV6.R12 v2(184,129.69) UV6.R11 ; RA14.2 283.27,24.74 v2(283.28,24.76) ; JDIMM2.81 90.66,29.04 v2(91.2,29.58) ; UV6.E1 v2(176.01,122.49) ; v2(193.68,31.59) 193.68,31.21 193.06,30.58 JNGFF1.28 ; CH47.2 182.41,45.91 v2(182.25,45.76) ; UH1.BT35 86.99,98.23 v2(86.97,98.25) ; v2(185.63,131.28) 185.63,131.32 UV6.U14 ; JDIMM1.197 121.65,42.52 v2(122.08,42.94) 121.17,42.94 120.65,42.43 JDIMM1.193 ; v2(113.6,30.75) 113.74,30.75 114.16,30.34 JDIMM2.167 ; JNGFF1.25 192.31,21.05 192.62,20.74 193.56,20.74 193.81,21 JNGFF1.31 193.81,22.87 v2(193.94,23) ; v2(175.57,117.92) 175.57,118.86 UV6.A1 ; UV8.C1 v2(199.46,87.88) ; v2(163.41,89.87) 162.98,90.31 UV1.AC18 ; UV8.U12 210.22,78.68 209.87,78.33 v2(209.87,78.33) ; 199.45,79.09 v2(199.45,79.11) ; 199.45,79.09 199.45,79.07 UV8.C12 ; 199.45,79.09 UV8.C11 ; UV9.E3 v2(206.66,98.19) ; JDIMM2.175 116.16,29.3 v2(115.71,29.75) 115.16,29.2 JDIMM2.171 ; v2(155.9,129.71) 156.28,130.09 UV7.C14 ; UV9.R11 v2(199.46,104.59) UV9.R12 ; 211.59,63.06 211.17,63.48 PQ103.1 ; 211.59,63.06 v2(211.59,63.08) ; 211.59,63.06 212.13,63.06 212.47,62.71 PQ103.4 ; UV8.E1 v2(200.26,87.08) ; v2(197.95,83.84) 197.95,83.98 UV8.B5 ; UV7.F5 163.08,127.69 v2(162.94,127.55) ; UV7.R12 v2(158.3,120.89) UV7.R11 ; v2(264.91,35.02) 265.39,34.55 RM13.1 ; JEDP1.6 62.26,26.51 61.83,26.51 v2(61.71,26.63) ; JDIMM1.227 129.15,41.94 128.96,42.14 128.95,42.13 128.37,42.13 128.15,41.92 JDIMM1.223 128.15,38.78 v2(128.13,38.75) ; UV9.R1 v2(199.46,96.59) ; v2(128.92,97.92) 128.79,98.06 128.36,98.06 128.22,98.19 UH1.A34 ; v2(125.28,94.2) 125.26,94.22 125.26,94.3 124.97,94.59 UH1.F29 ; UV8.G10 201.91,79.93 v2(201.91,79.87) 201.88,79.9 201.83,79.9 UV8.F10 ; UV8.A12 197.06,78.28 v2(197.06,78.27) ; UV7.R4 v2(164.7,120.89) UV7.R3 ; UV8.E14 v2(201.06,77.48) ; JDIMM1.166 113.9,33.7 113.98,33.77 113.98,34.71 115.48,36.22 115.48,36.98 115.96,37.46 v2(116.21,37.46) ; UV9.A3 v2(209.86,98.19) ; v2(175.04,76.54) 174.67,76.91 UV1.K2 ; UV8.M10 206.26,80.73 v2(206.26,80.81) ; UV6.H1 v2(176,124.09) UV6.H2 ; v2(95.84,80.56) 95.84,80.6 95.54,80.9 UH1.BD12 95.26,81.02 94.58,81.02 UH1.BF12 ; UV7.T10 159.88,120.07 v2(159.88,120.08) ; v2(167.09,16.78) 167.09,16.63 167.41,16.31 UH7.3 ; v2(198.72,99) 198.65,99 UV9.T5 ; v2(281.19,46.85) v2(279.41,46.85) 278.22,46.85 277.12,45.76 277.12,44.95 v2(277.76,44.31) 277.76,42.54 278.14,42.15 v2(279.54,42.15) 279.92,41.77 280.81,41.77 v2(281.57,42.54) ; UV6.K2 v2(176,125.69) UV6.K1 ; UV8.N1 v2(207.06,88.02) ; JNGFF2.33 207.68,28.82 v2(207.35,29.15) ; UH1.BM13 UH1.BL13 ; JDIMM1.168 114.4,34.43 115.61,35.63 v2(116.2,35.63) ; UV6.D10 v2(183.2,120.89) ; UV9.F5 206.26,99.85 v2(206.19,99.92) ; UV7.U14 v2(156.7,119.29) ; UV6.E3 v2(177.6,122.49) ; JEDP1.33 v2(61.71,40.01) ; UV9.H13 UV9.H14 204.62,106.59 204.27,106.94 v2(204.26,106.94) ; PC1122.2 79.51,90.67 v2(80.02,91.18) 79.97,91.18 PC1121.2 ; UH1.AF12 110.3,81.19 v2(110.47,81.19) ; PQ200.4 46.55,42.9 PR213.2 ; UV7.U3 v2(164.66,118.45) ; UV9.L10 v2(201.86,102.99) UV9.M10 ; UV9.C12 v2(209.06,104.59) UV9.C11 ; UV6.B10 v2(183.2,119.29) ; v2(98.57,82.52) 98.9,82.2 UH1.AY14 ; UV7.M10 v2(159.9,123.29) UV7.L10 ; UV6.C14 v2(185.6,120.89) ; UV7.N3 v2(165.5,121.69) ; UV6.H14 v2(185.6,124.09) UV6.H13 ; CT81.2 v2(61.26,50.28) ; v2(196.63,23.21) 196.62,23.2 196.62,23.07 196.81,22.87 JNGFF1.43 ; UV9.U3 v2(197.06,98.19) ; UV7.R14 v2(156.7,120.89) ; v2(197.83,104.61) 197.83,104.63 UV9.U12 ; v2(166.73,98.25) 166.78,98.25 167.13,98.61 167.13,98.61 UV1.W28 ; v2(196.3,77.51) 197.03,77.51 UV8.A14 ; UV1.AL32 UV1.AL33 157.12,102.71 v2(156.71,103.11) ; UH1.J33 123.3,97.05 123.3,96.52 UH1.J32 123.6,96.1 v2(123.64,96.1) 123.67,96.1 UH1.H32 ; v2(177.07,118.3) 177.07,118.38 177.2,118.51 UV6.A3 ; v2(128.92,98.76) 128.81,98.87 128.38,98.87 128.25,99.01 UH1.A36 ; UH1.BN30 89.51,95.15 89.2,95.46 v2(89.2,95.53) ; UV9.K13 v2(202.66,106.19) UV9.K14 ; UH1.AL12 UH1.AM12 105.31,81.02 104.64,81.02 UH1.AN12 104.35,80.9 v2(104.06,80.61) ; UV6.T5 v2(179.2,130.49) ; CH48.2 182.28,43.22 v2(182.2,43.3) ; UV8.H13 v2(202.66,77.48) UV8.H14 ; UV9.A12 210.35,104.99 v2(210.72,104.62) ; v2(159.11,88.15) 159.19,88.15 UV1.AH16 ; UV8.F5 v2(201.86,84.68) ; UV9.E12 206.65,105.4 v2(206.65,105.42) ; UV9.G10 v2(205.06,102.99) ; UH1.AY12 UH1.AW12 100.09,80.9 v2(100.39,81.19) ; JEDP1.36 61.8,41.51 v2(61.71,41.42) ; JEDP1.27 v2(61.67,37.01) ; UV7.N14 v2(156.7,122.49) ; UV8.G5 v2(202.66,84.68) ; JNGFF1.55 199.81,20.76 v2(200.14,20.44) ; UV1.U12 169.62,83.58 v2(170.47,83.58) 170.47,83.89 UV1.R12 ; UV6.B5 v2(178.41,119.3) ; v2(163.89,120.13) 163.89,120.08 UV7.T5 ; UV1.AC13 162.57,84.99 v2(162.57,84.83) ; UV9.T10 v2(198.66,102.99) ; v2(108.62,81.19) 108.32,80.9 UH1.AH12 ; JDIMM1.27 77.15,39.54 76.41,38.8 v2(76.09,38.8) ; UV6.M10 182.35,127.69 v2(182.27,127.69) ; UV7.C1 v2(166.3,130.49) ; RA64.2 269.58,24.09 v2(269.68,24.2) ; UV9.C14 v2(209.06,106.19) ; UV7.L5 v2(163.9,123.29) UV7.M5 ; UV7.A3 v2(164.7,131.29) ; v2(167.29,96.25) 167.89,95.65 UV1.V23 UV1.U23 ; UV7.P10 v2(159.1,121.69) ; v2(210.06,87.99) 210.26,87.8 UV8.U1 ; UV1.B31 181.36,101.13 181.7,101.13 181.75,101.08 182.52,101.08 v2(182.62,100.98) ; UV9.G5 v2(205.06,99.79) ; v2(175.07,128.51) 175.09,128.49 UV6.N1 ; v2(156.69,97.29) 157.07,96.91 UV1.AL26 ; UV9.D10 v2(207.46,103.79) ; UV8.N12 v2(206.66,78.28) ; UV8.H2 v2(202.66,87.08) UV8.H1 ; JNGFF1.61 201.31,21.15 200.8,20.64 v2(200.8,20.44) ; UV9.E14 207.06,107.12 v2(207.02,107.16) ; UV7.B10 v2(159.1,130.49) ; v2(181.69,95.65) 181.69,95.66 UV1.B25 ; JEDP1.14 61.84,30.51 61.6,30.28 v2(61.6,30.09) 61.68,30.01 JEDP1.13 ; UV8.E3 v2(201.06,85.48) ; v2(103.15,80.56) 103.26,80.56 UH1.AP12 ; UV8.R1 v2(208.26,87.88) ; UV9.N14 v2(201.06,106.19) ; UV6.N3 v2(177.6,128.09) ; UV7.E14 156.01,128.49 v2(155.81,128.28) ; v2(264.93,35.83) 265.03,35.93 CM11.2 ; v2(182.46,126.48) 182.46,126.55 UV6.L10 ; UV9.C4 208.73,98.59 209.06,98.26 v2(209.06,98.2) 209.06,98.15 208.7,97.79 UV9.C3 ; JEDP1.8 62.03,27.51 61.77,27.26 ; v2(126.45,100.78) 126.45,100.7 UH1.D38 ; UV7.B5 v2(163.9,130.49) ; UV7.D10 v2(159.1,128.89) ; UV1.R16 170.89,88.11 v2(171.31,87.7) 171.5,87.7 UV1.P15 172.41,86.79 v2(172.6,86.79) ; UA2.4 263.28,22.17 v2(263.15,22.3) ; UV9.N3 v2(200.26,97.39) ; UV7.E12 v2(157.5,128.89) ; UV6.C3 v2(177.6,120.09) UV6.C4 ; UV6.R4 v2(177.6,130.49) UV6.R3 ; UV6.R14 186.32,129.77 186.32,129.68 v2(186.36,129.64) ; JDIMM1.167 114.15,40.06 116.15,38.07 v2(116.21,38.07) ; JEDP1.7 62.12,27.01 61.87,27.26 61.77,27.26 ; UV7.G10 v2(159.9,126.49) ; UV6.L5 179.16,126.53 v2(179.16,126.48) ; UV8.A1 v2(197.86,87.88) ; UV6.T10 v2(182.4,130.49) ; UV8.E12 200.29,78.31 v2(200.29,78.27) ; UV8.B10 v2(197.86,79.88) ; UV7.N12 v2(158.3,122.49) ; UA2.7 v2(264.78,22.25) ; PQ203.4 v2(48.64,39.76) ; UV6.E12 v2(184.8,121.69) ; 61.77,27.26 v2(61.73,27.26) ; UV9.K1 v2(203.46,96.59) UV9.K2 ; PH1104.2 128.53,121.83 128.56,121.86 128.61,121.86 128.64,121.83 v2(128.66,121.83) ; UV8.P10 v2(208.26,79.88) ; UH1.BG12 93.38,80.9 v2(93.09,80.61) 92.92,80.61 92.64,80.9 UH1.BH12 ; v2(155.77,130.94) 155.77,131.16 UV7.A14 ; UV6.E14 v2(185.6,122.49) ; UV7.G5 v2(163.9,126.49) ; UV8.K13 v2(205.06,77.48) UV8.K14 ; UV6.R1 v2(175.2,129.69) ; UV9.R4 v2(199.46,98.19) UV9.R3 ; UV7.E3 v2(164.7,128.09) ; UV9.U1 v2(197.86,96.59) ; UV9.H1 v2(205.06,96.59) UV9.H2 ; UV6.N12 184.69,128.78 184.69,128.83 v2(184.75,128.88) ; UV9.N1 v2(201.06,96.59) ; UV8.C3 v2(198.66,85.48) UV8.C4 ; UV7.H13 v2(156.7,126.49) UV7.H14 ; UV9.B10 v2(209.06,103.79) ; UV7.U12 v2(158.3,119.29) ; UV7.A12 v2(157.5,131.29) ; UV8.U14 210.26,77.09 v2(209.88,77.47) ; v2(165.06,102.31) 164.66,101.91 UV1.AB32 ; UV6.P10 v2(183.2,129.69) ; UV6.U3 v2(177.6,132.09) ; UV7.E1 v2(166.3,128.89) ; UV7.C12 v2(158.3,129.69) UV7.C11 ; JEDP1.24 63.41,35.51 v2(64.08,36.19) ; UZ9.5 136,100.91 v2(136.05,100.85) ; UV9.B5 v2(209.06,98.99) ; UV7.A1 v2(167.1,131.29) ; UV6.F5 v2(178.4,123.29) UV6.G5 ; UV8.C14 v2(198.66,77.48) ; v2(208.73,76.49) 208.66,76.57 UV8.R14 ; UV6.C1 v2(176.01,120.08) ; UV8.A3 v2(197.86,86.28) ; UV9.E1 v2(207.46,96.59) ; UV9.P10 v2(200.26,103.79) ; JDIMM2.44 v2(81.41,21.58) ; UV9.C1 v2(209.06,96.59) ; UV8.T10 v2(209.06,80.68) ; UV1.B1 v2(181.69,76.51) ; UV6.U1 v2(175.06,131.69) ; PH1100.1 v2(97.8,122.72)
  BOTTOM w0.279: UV1.AL23 UV1.AL24 157.09,95.3 156.77,95.62 v2(156.72,95.62) 156.72,95.67 156.33,96.06 UV1.AM25 UV1.AN25 ; v2(159.17,95.63) UV1.AH24
  BOTTOM w0.3: UV1.G13 177.19,85.96 ; UV1.D33 179.49,102.86 179.49,104.03 v2(179.63,104.17) ; v2(174.98,99.85) 174.64,100.19 UV1.K30
  BOTTOM w0.305: UV1.AN30 155.49,100.23 v2(155.09,100.63) ; v2(75.02,42.9) 75.47,42.9 76.15,42.21 JDIMM1.23 ; UH2.AL38 160.61,28.61 v2(160.26,28.26) 160.01,28.01 UH2.AN39 ; v2(137.97,31.89) 137.68,31.89 137.4,32.17 JDIMM1.260 ; JNGFF2.21 208.07,31.83 206.5,31.83 v2(206.41,31.92) ; v2(174.76,104.2) 174.71,104.15 174.71,102.77 UV1.K33 UV1.K32 ; JDIMM1.64 86.4,31.71 v2(86.75,31.36) ; JDIMM1.185 118.65,41.88 118.94,42.17 119.47,42.17 119.65,41.99 JDIMM1.189 ; v2(88.41,21.63) JDIMM2.72 v2(88.41,18.67) ; JDIMM1.18 74.9,34.1 v2(74.93,34.13) ; JNGFF1.15 189.81,21.14 190.18,20.77 190.66,20.77 v2(190.69,20.74) ; UV1.AH13 159.59,86 159.22,85.63 v2(159.22,85.61) ; JDIMM1.39 80.15,39.98 79.07,38.9 78.55,38.9 v2(78.52,38.93) ; JDIMM2.35 79.16,29.35 79.51,29.71 v2(80.25,29.71) ; v2(118.4,38.45) 118.4,38.45 118.4,38.98 117.65,39.72 JDIMM1.181 117.65,42.1 117.5,42.25 116.33,42.25 116.15,42.07 JDIMM1.175 ; v2(164.16,99.87) 164.6,100.31 UV1.AB30 ; UV1.G19 177.19,91.08 v2(176.79,91.48) ; v2(84.76,34.51) 84.4,34.16 JDIMM1.56 84.4,31.78 84.59,31.59 85.22,31.59 85.4,31.78 JDIMM1.60 ; v2(117.74,29.46) 118.38,29.46 118.66,29.18 JDIMM2.185 ; JDIMM2.69 87.66,29.17 87.97,29.48 v2(88.63,29.48) ; v2(128.86,18.69) 128.86,18.72 ; 128.86,18.72 128.11,18.72 127.91,18.92 JDIMM2.222 ; 128.86,18.72 128.87,18.72 128.91,18.75 JDIMM2.226 ; v2(94.88,26.66) 94.9,26.66 95.16,26.91 JDIMM2.99 ; UV1.N12 173.06,84.31 v2(173.66,83.71) 174.62,83.71 v2(174.81,83.9) ; UV1.N12 172.81,84.31 v2(172.35,84.77) 172.35,84.72 172.29,84.78 172.29,84.91 UV1.P13 UV1.R14 UV1.T15 UV1.U16 UV1.V16 167.79,88.31 v2(167.27,87.78) 166.89,87.41 UV1.W15 UV1.Y14 ; UV1.N12 172.42,83.84 171.39,83.84 170.92,84.31 UV1.R12 170.85,84.31 v2(170.38,84.78) 170.38,84.82 UV1.T13 UV1.U14 UV1.V14 v2(167.4,85.82) UV1.W13 ; JDIMM2.230 129.91,18.95 129.92,18.95 v2(130.2,18.67) 130.25,18.72 130.63,18.72 130.91,19 JDIMM2.234 ; UV1.AH2 159.7,76.91 v2(160.07,77.28) ; v2(161.95,103.95) 161.98,103.93 161.98,102.87 UV1.AE33 ; UV1.N23 172.69,95.31 v2(172.33,94.95) 171.89,94.51 UV1.P22 UV1.R21 170.89,93.22 170.42,92.75 v2(170.42,92.72) 170.3,92.72 UV1.T20 169.89,92.02 v2(169.66,91.8) 169.68,91.8 169.68,91.85 169.14,91.31 UV1.U19 UV1.V19 167.84,91.31 v2(167.32,91.83) 166.89,92.26 UV1.W20 UV1.Y21 UV1.AA22 UV1.AB23 163.85,95.31 v2(163.46,95.7) ; v2(101.55,126.8) 101.55,126.8 PU1402.23 ; JNGFF2.73 208.07,18.83 206.51,18.83 v2(206.22,19.12) 206.43,19.33 208.07,19.33 JNGFF2.71 ; UV1.AP2 UV1.AN1 155.49,76 155.7,75.79 155.7,75.49 v2(155.39,75.18) ; v2(209.71,34.56) 209.71,34.58 209.48,34.82 JNGFF2.9 ; PU1501.4 69.22,111.82 v2(69.19,111.85) ; v2(93.72,43.55) 93.1,43.55 91.65,42.1 JDIMM1.85 ; v2(88.19,38.01) 87.95,38.01 86.65,39.31 JDIMM1.65 ; v2(80.23,31.23) 80.02,31.23 79.4,31.85 JDIMM1.36 ; JDIMM1.247 134.15,39.4 135.41,38.15 v2(135.68,38.15) ; UV1.G7 176.77,80.58 v2(176.71,80.58) ; UV1.W32 167.16,101.91 167.57,102.32 v2(167.57,102.34) ; JDIMM2.252 135.41,19.06 v2(134.98,18.63) ; v2(91.26,126.8) 91.26,126.8 PU1500.23 ; v2(205.39,33.34) 205.5,33.44 206.23,33.44 206.35,33.33 208.07,33.33 JNGFF2.15 ; v2(116.21,18.66) 116.41,18.85 JDIMM2.176 ; JDIMM2.2 70.91,19.09 71.34,18.66 v2(71.53,18.66) 71.91,19.03 JDIMM2.6 ; JDIMM1.248 134.4,34.49 135.57,35.65 v2(135.71,35.65) ; v2(176.84,93.98) 176.87,93.96 176.87,93.95 177.19,93.63 UV1.G22 ; JDIMM1.107 97.15,41.9 v2(97.57,42.31) 97.31,42.56 96.88,42.56 96.15,41.83 JDIMM1.103 ; v2(176.79,88.98) 177.19,88.58 UV1.G16 ; RH148.1 123.8,69.6 122.21,68.01 119.83,68.01 v2(119.37,67.55) ; UV1.A33 182.09,102.97 182.61,103.49 182.61,103.83 v2(182.64,103.85) ; UV1.E7 178.89,81.01 v2(178.49,80.61) UV1.F7 ; v2(171.7,80.65) 172.06,81.01 UV1.N7 ; v2(88.62,31.49) 87.67,31.49 87.4,31.75 JDIMM1.68 ; JDIMM1.31 78.15,41.83 77.86,42.13 77.39,42.13 77.15,41.9 JDIMM1.27 ; JDIMM1.243 133.15,38.6 133.31,38.45 133.31,38.24 v2(133.31,38.24) ; v2(92.21,26.61) 92.11,26.61 91.66,27.06 JDIMM2.85 ; v2(82.39,26.76) 82.34,26.76 82.16,26.94 JDIMM2.47 82.16,29.12 81.85,29.43 81.44,29.43 81.16,29.15 JDIMM2.43 ; JDIMM1.81 90.65,41.87 90.25,42.28 v2(90.12,42.28) 89.96,42.28 89.65,41.98 JDIMM1.77 ; JDIMM2.209 124.66,29.9 v2(124.85,30.09) 125.66,29.28 JDIMM2.213 ; UV1.G32 UV1.G33 177.25,102.82 v2(177.25,103.26) ; JDIMM1.73 88.65,44.41 89.74,45.5 v2(90.13,45.5) ; PU1401.23 111.46,126.93 v2(111.45,126.93) ; JDIMM1.93 93.65,42.22 v2(93.72,42.28) ; JDIMM2.247 134.16,29.1 135.2,30.14 v2(135.89,30.14) ; v2(203.62,20.46) 203.46,20.46 202.81,21.12 JNGFF1.67 ; JDIMM2.93 93.66,29.5 v2(93.74,29.58) ; v2(118.37,18.69) 118.37,18.69 118.37,18.69 118.37,18.69 118.38,18.69 118.38,18.71 118.35,18.71 118.41,18.77 JDIMM2.184 ; UV1.K5 174.67,79.31 v2(175.06,78.91) ; UV1.U12 168.86,84.31 v2(168.39,84.78) 167.92,84.31 UV1.V12 167.42,83.84 166.36,83.84 UV1.Y12 ; UV1.AN34 155.49,103.76 v2(154.99,104.26) ; JDIMM2.98 94.91,21.14 94.64,21.4 94.21,21.4 94.14,21.33 v2(93.91,21.33) JDIMM2.94 ; JDIMM2.193 120.66,30.12 v2(121.39,30.84) ; JDIMM2.248 134.41,18.85 v2(134.25,18.69) ; UV1.AL28 157.09,98.58 v2(157.49,98.98) ; v2(171.74,78.93) 172.11,79.31 UV1.N5 ; v2(74.18,18.66) 73.91,18.93 JDIMM2.14 ; UV1.B28 UV1.C28 180.49,98.58 v2(180.08,98.98) ; JDIMM2.51 83.16,29.92 v2(83.95,30.71) ; v2(182.47,53.88) 182.47,53.88 182.13,53.53 PR1013.1 ; UV1.AK10 158.25,83.2 v2(158.34,83.2) ; UV1.G30 177.16,100.31 v2(177.56,100.71) ; v2(72.65,18.66) 72.91,18.91 JDIMM2.10 ; v2(77.94,18.72) 77.91,18.75 JDIMM2.30 77.91,21.24 78.21,21.55 v2(78.36,21.55) ; UV1.AM13 156.29,85.99 v2(156.64,85.63) 156.86,85.41 156.9,85.41 157.09,85.22 UV1.AL12 ; UV1.AM13 UV1.AN13 ; UV1.AM13 156.45,86.22 156.45,86.3 v2(156.68,86.53) 157,86.86 157.04,86.86 UV1.AL14 UV1.AL15 ; UH1.N33 120.03,97.11 119.7,97.45 119.67,97.45 ; v2(91.82,35.16) 91.79,35.13 91.79,35.09 90.9,34.2 JDIMM1.82 90.9,31.73 90.73,31.55 90.13,31.55 89.9,31.78 JDIMM1.78 ; UV1.E5 v2(179.29,78.91) ; UV1.AB12 164.23,83.97 164.23,83.85 164.37,83.72 164.37,83.71 v2(164.73,83.35) 165.09,83.71 165.29,83.71 UV1.Y12 ; v2(70.29,26.56) 70.29,26.61 70.66,26.98 JDIMM2.1 70.66,29.22 70.88,29.44 71.38,29.44 71.66,29.16 JDIMM2.5 ; v2(180.09,94) 180.49,93.6 UV1.C22 ; JDIMM1.244 133.4,31.9 132.99,31.49 v2(132.65,31.49) 132.18,31.49 131.9,31.76 JDIMM1.238 ; JDIMM2.181 117.66,27.27 118.34,26.59 v2(118.51,26.59) ; v2(77.16,26.76) JDIMM2.27 ; v2(92.17,80.57) 91.81,80.94 UH1.BJ12 ; UV1.G5 177.17,79.31 177.56,79.69 v2(177.56,79.75) ; JDIMM1.251 135.15,39.96 v2(135.67,39.44) ; JDIMM1.72 88.4,34.4 v2(88.27,34.53) ; JDIMM2.238 131.91,18.99 131.58,18.66 v2(131.33,18.66) ; JDIMM2.23 76.16,29.26 75.97,29.45 75.36,29.45 75.16,29.24 JDIMM2.19 v2(75.16,26.69) ; v2(80.64,26.61) 80.41,26.61 80.16,26.86 JDIMM2.39 ; v2(92.21,29.58) 92.66,29.13 JDIMM2.89 ; PU1402.4 v2(104.6,129.91) ; UH1.AC12 112.77,80.9 113.12,81.24 v2(113.22,81.24) 113.22,81.3 113.62,80.9 UH1.AA12 ; v2(92.62,18.65) 92.76,18.79 92.76,18.79 92.91,18.94 JDIMM2.90 ; v2(89.75,18.72) 89.91,18.87 JDIMM2.78 ; UV1.AP33 154.46,102.94 154.46,104.46 v2(154.94,104.94) ; JDIMM1.47 82.15,41.9 82.41,42.16 82.98,42.16 83.15,41.98 JDIMM1.51 83.21,40.92 83.21,39.17 83.37,39 83.37,38.96 v2(83.37,38.96) ; v2(93.74,34) 93.9,33.83 JDIMM1.94 ; v2(131.07,30.72) 130.73,30.72 129.9,31.55 JDIMM1.230 ; v2(176.79,83.98) 177.19,83.58 UV1.G10 ; v2(163.41,89.87) 162.89,89.35 UV1.AC17 162.78,89.31 162.39,88.92 162.39,87.81 UV1.AC15 ; UV1.Y12 166.02,84.31 166.46,84.75 v2(166.48,84.75) ; JDIMM2.31 78.16,26.82 v2(78.32,26.66) ; UV1.AN16 UV1.AM16 156.29,88.63 v2(156.68,89.02) 157.07,89.41 UV1.AL17 UV1.AL18 156.29,91.01 UV1.AM19 UV1.AN19 ; UV1.E22 179.28,93.17 v2(179.28,93.13) ; UV1.AN22 UV1.AM22 156.34,93.56 v2(156.71,93.19) 157.09,92.81 UV1.AL21 UV1.AL20 ; v2(164.21,98.21) 164.61,98.61 UV1.AB28 ; v2(182.48,76.44) 182.48,76.52 UV1.A2 ; JDIMM2.239 132.16,29.11 132.06,29.21 132.06,29.92 132.38,30.24 v2(132.66,30.24) 132.85,30.24 133.16,29.94 JDIMM2.243 ; JDIMM2.210 124.91,19.07 124.55,18.72 124.17,18.72 v2(124.14,18.69) 123.91,18.92 JDIMM2.206 ; JDIMM1.1 70.65,42.11 70.85,42.3 71.47,42.3 71.65,42.11 JDIMM1.5 71.65,39.83 v2(71.56,39.74) ; JDIMM1.106 96.9,31.9 96.59,31.59 96.14,31.59 95.9,31.82 JDIMM1.102 95.9,33.84 v2(95.69,34.05) ; 209.79,27.32 JNGFF2.39 ; 209.79,27.32 209.92,27.32 v2(210.88,28.28) ; 209.79,27.32 209.79,26.05 209.56,25.82 JNGFF2.45 ; JDIMM1.214 125.9,31.7 125.69,31.49 v2(124.85,31.49) ; UV1.N28 172.11,98.61 v2(171.71,98.21) ; JDIMM2.52 83.41,18.85 83.21,18.66 v2(82.61,18.66) ; v2(126.88,29.45) 126.66,29.23 JDIMM2.217 ; v2(163.47,91.73) 162.89,92.31 UV1.AC20 ; UV1.C16 180.49,88.51 180.86,88.14 v2(180.86,88.12) ; JDIMM2.57 84.66,29.27 v2(84,29.93) ; JDIMM1.209 124.65,42.03 v2(125.18,42.56) ; v2(178.45,96.4) 178.55,96.4 UV1.E25 ; v2(77.26,31.36) 76.9,31.72 JDIMM1.26 ; JNGFF2.57 206.8,22.82 206.23,23.38 206.23,23.89 v2(206.21,23.92) 206.23,23.92 206.64,24.32 JNGFF2.51 ; JDIMM1.235 131.15,42.29 131.1,42.34 v2(131.1,42.39) 131.06,42.39 131.04,42.41 130.46,42.41 130.15,42.1 JDIMM1.231 ; JDIMM1.234 130.9,31.53 v2(131.07,31.36) ; v2(174.95,99.13) 174.95,98.92 UV1.K28 ; JDIMM1.48 82.4,35.38 81.77,36.02 v2(81.5,36.02) ; JDIMM2.189 119.66,27.13 120.23,26.56 v2(120.33,26.56) ; v2(162.58,78.93) 162.21,79.31 UV1.AE5 ; JDIMM1.172 115.4,33.82 115.97,34.38 v2(116.22,34.38) ; v2(180.1,95.63) 180.49,96.02 UV1.C25 ; JDIMM2.202 122.91,18.69 v2(122.93,18.67) ; UV1.AC20 162.89,92.31 162.28,92.92 162.28,94.66 162.52,94.9 v2(162.52,94.91) 162.89,94.54 UV1.AC22 163.46,93.74 v2(163.46,93.71) 163.48,93.71 UV1.AB21 UV1.AA20 UV1.Y19 UV1.W18 166.74,90.15 166.74,89.65 166.89,89.5 UV1.W17 UV1.Y16 UV1.AA15 UV1.AB14 UV1.AC13 162.39,85.81 162.39,86.77 162.89,87.27 UV1.AC15 ; UV1.AC20 162.36,91.78 162.36,90.84 UV1.AC18 ; JDIMM1.98 94.9,34.18 95.39,34.66 v2(95.69,34.66) ; v2(118.42,34.89) 117.4,33.87 JDIMM1.180 ; PU1400.4 v2(124.66,130.04) ; JLPDE1.9 243.02,33.07 v2(243.09,33.14) ; v2(159.04,90.71) 159.24,90.71 UV1.AH19 ; v2(121.42,18.66) 121.45,18.69 121.45,18.71 121.41,18.75 JDIMM2.196 ; v2(79.28,18.72) 79.41,18.85 JDIMM2.36 ; v2(114.06,18.68) 113.91,18.84 JDIMM2.166 ; UV1.AH28 159.55,98.61 v2(159.18,98.98) 159.64,99.44 UV1.AH29 ; v2(125.18,42.56) 125.41,42.79 126.13,42.79 126.65,42.26 JDIMM1.217 ; v2(125.18,42.56) 125.65,42.08 JDIMM1.213 ; v2(125.21,43.88) 123.65,42.32 JDIMM1.205 ; JDIMM2.65 86.66,29.49 v2(86.75,29.58) 86.61,29.72 85.87,29.72 85.66,29.5 JDIMM2.61 ; v2(91.2,29.58) 90.98,29.79 90.06,29.79 89.66,29.39 JDIMM2.77 ; JDIMM1.14 73.9,31.79 74.43,31.27 v2(74.9,31.27) 75.51,31.27 75.9,31.66 JDIMM1.22 ; JDIMM2.227 129.16,29.21 v2(128.91,29.45) 128.85,29.39 128.44,29.39 128.16,29.1 JDIMM2.223 ; UV1.C7 180.49,81.02 v2(180.09,80.62) ; JDIMM2.68 87.41,18.85 87.28,18.72 v2(86.64,18.72) ; UV1.AC15 162.89,87.38 v2(163.41,87.9) 163.41,88.05 163.67,88.31 UV1.AB16 UV1.AA17 UV1.AA18 v2(164.4,90.8) UV1.AB19 ; UV1.G2 177.14,76.91 v2(176.72,77.33) 176.72,77.3 177.13,77.71 UV1.G3 ; UV1.T28 169.66,98.61 v2(170.06,98.21) ; JDIMM1.176 116.4,31.3 117.42,30.29 v2(117.69,30.29) 117.95,30.29 118.4,30.74 JDIMM1.184 ; v2(180.09,91.49) 180.49,91.09 UV1.C19 ; UV1.B34 181.38,103.51 v2(181.75,103.88) ; v2(174.91,80.51) 174.91,80.73 UV1.K7 ; UV1.M15 173.85,87.31 173.44,87.71 v2(173.44,87.7) 172.89,88.25 UV1.N16 172.84,88.31 172.38,88.76 v2(172.32,88.76) 172.32,88.82 171.89,89.26 UV1.P17 171.59,89.61 171.59,90.01 UV1.P18 171.89,90.46 v2(172.25,90.82) 172.73,91.31 UV1.N19 173.39,91.81 v2(173.62,91.81) 173.62,92.04 173.89,92.31 UV1.M20 ; UV1.M15 173.91,87.29 174.37,87.29 174.8,86.86 v2(174.8,86.36) 174.8,86.02 174.09,85.31 UV1.M13 UV1.N14 172.89,86.5 v2(172.6,86.79) ; UV1.M15 173.89,87.41 174.39,87.91 174.39,88.73 v2(174.34,88.78) 173.89,89.23 UV1.M17 UV1.M18 173.89,90.38 174.45,90.94 174.45,91.87 174.01,92.31 UV1.M20 ; UV1.AJ7 158.72,81.06 158.35,81.42 v2(158.35,81.47) 157.94,81.06 UV1.AK7 ; v2(80.65,43.91) 81.15,43.41 JDIMM1.43 ; UV1.M20 173.89,92.36 174.4,92.86 174.4,93.68 v2(174.23,93.85) 174.27,93.85 174.27,93.85 173.89,94.23 UV1.M22 UV1.N21 172.73,93.31 v2(172.25,92.83) 171.89,92.47 UV1.P20 UV1.R19 UV1.T18 ; JNGFF1.1 184.31,23.41 v2(184.52,23.61) ; UV1.N33 UV1.N32 ; UV1.AH7 159.59,81.08 v2(159.19,81.48) ; JDIMM2.172 115.41,19.03 115.03,18.66 v2(114.84,18.66) 114.41,19.09 JDIMM2.168 ; v2(75.02,42.26) 74.5,42.26 74.15,41.92 JDIMM1.15 ; 119.67,97.45 v2(119.68,97.43) ; 119.67,97.45 119.98,97.76 UH1.N34 ; JDIMM1.35 79.15,42.23 v2(78.97,42.41) ; JDIMM2.256 v2(136.41,21.22) ; v2(119.21,18.66) 119.21,18.71 119.41,18.91 JDIMM2.188 ; JDIMM1.167 114.15,42.11 114.34,42.3 114.94,42.3 115.15,42.09 JDIMM1.171 ; 177.19,85.96 v2(176.79,85.56) ; v2(86.12,81.4) 85.7,81.81 UC1.3 ; JDEG1.10 253.72,35.46 v2(253.5,35.68) ; v2(72.83,39.51) 72.65,39.69 JDIMM1.9 ; v2(121.4,31.52) JDIMM1.196 ; v2(74.89,29.81) 74.74,29.81 74.16,29.23 JDIMM2.15 ; v2(156.69,100.66) 157.09,100.26 UV1.AL30 ; v2(169.24,101.52) 169.63,101.91 UV1.T32 ; JDIMM2.56 84.41,18.92 84.61,18.72 v2(85.37,18.72) 85.41,18.75 JDIMM2.60 ; JDIMM1.44 81.4,31.85 81.15,31.59 80.65,31.59 80.4,31.84 JDIMM1.40 80.4,34.43 80.84,34.87 81.41,34.87 v2(81.47,34.81) ; v2(167.29,96.25) 166.83,96.25 v2(166.39,95.81) UV1.Y23 UV1.W22 166.89,94.23 v2(167.32,93.8) 167.4,93.8 UV1.V21 UV1.U21 UV1.T22 UV1.R23 170.39,95.81 v2(170.38,95.81) ; UV1.AE32 162.13,101.91 v2(161.71,101.49) ; v2(159.72,104.21) 159.5,103.99 159.5,102.84 UV1.AH33 ; UV1.T2 169.61,76.91 v2(169.19,76.48) ; UV8.N3 207.06,85.87 v2(206.69,85.5) ; JDIMM1.188 119.4,31.71 v2(119.25,31.55) 119.39,31.41 120.07,31.41 120.4,31.75 JDIMM1.192 ; v2(74.92,39.37) 75.15,39.6 JDIMM1.19 ; v2(112.29,80.61) 112,80.9 UH1.AD12 ; JDIMM2.192 v2(120.41,18.66) ; JDIMM2.180 117.41,18.84 v2(117.56,18.68) ; v2(72.9,34.29) JDIMM1.10 ; JDIMM2.73 88.66,27.25 89.21,26.7 v2(89.7,26.7) ; v2(154.93,78.81) 154.92,78.81 154.92,78.8 155.16,78.56 UV1.AN4 ; v2(88.19,39.32) 87.65,39.86 JDIMM1.69 ; JDIMM2.214 125.91,21.26 v2(125.94,21.3) ; JDIMM1.61 85.65,42.03 85.47,42.21 84.91,42.21 84.65,41.95 JDIMM1.57 84.65,39.69 v2(84.76,39.59) ; v2(169.23,80.58) 169.48,80.33 169.48,79.46 UV1.T5 ; JDIMM1.256 136.4,31.82 136.1,31.51 v2(135.93,31.51) ; v2(126.9,31.36) JDIMM1.218 ; UV1.AE30 162.11,100.31 v2(161.71,100.71) ; v2(132.94,21.69) 133.41,21.22 JDIMM2.244 ; JDIMM2.231 130.16,29.29 130.45,29.58 v2(131.07,29.58) 131.16,29.5 JDIMM2.235 ; v2(162.57,80.64) 162.51,80.64 UV1.AE7 ; v2(154.95,80.84) 155.17,81.06 UV1.AN7 ; v2(135.93,29.42) 135.89,29.38 135.39,29.38 135.16,29.14 JDIMM2.251 ; JDIMM1.30 77.9,31.22 77.45,30.77 v2(77.26,30.77) ; PU1500.4 v2(94.31,129.91) ; JDIMM1.89 92.65,42.09 93.48,42.92 v2(93.72,42.92) ; JDIMM2.107 97.16,27.26 96.16,26.26 JDIMM2.103 ; UV1.D31 179.71,101.11 v2(180.09,101.48) ; v2(123.66,30.71) JDIMM2.205 ; v2(121.61,126.93) 121.62,126.93 PU1400.23 ; v2(207.08,17.77) 207.08,18.02 207.38,18.32 JNGFF2.75 ; UV1.F28 178.04,98.61 v2(177.61,99.03) UV1.G28 ; JDIMM1.222 127.9,34.18 v2(128.08,34.36) ; v2(126.71,18.66) 126.91,18.85 JDIMM2.218 ; v2(95.91,36.58) 95.75,36.58 94.78,37.56 94.78,39.34 95.15,39.72 JDIMM1.99 ; v2(129.04,30.47) 128.9,30.61 JDIMM1.226 ; JDIMM2.197 121.66,26.98 121.91,26.73 v2(122.32,26.73) 122.66,27.06 JDIMM2.201 ; v2(164.23,78.95) 164.26,78.98 164.26,79 164.57,79.31 UV1.AB5 ; UV1.AH30 159.64,100.33 v2(159.25,100.72) ; v2(179.17,75.71) 179.28,75.82 179.28,76.55 UV1.D2 ; JDIMM1.201 122.65,40.01 122.44,39.79 121.96,39.79 121.65,40.1 JDIMM1.197 ; UV1.AB2 v2(164.25,77.3) ; v2(93.74,34.66) 93.48,34.66 92.9,34.08 JDIMM1.90 92.9,31.76 92.65,31.51 92.23,31.51 91.9,31.84 JDIMM1.86 ; v2(172.53,76.42) 172.35,76.6 172.35,76.7 UV1.N2 ; v2(135.89,30.85) 135.8,30.85 135.4,31.24 JDIMM1.252 ; v2(182.71,81.06) 182.59,80.93 181.42,80.93 UV1.B7 ; v2(131.1,43.05) 131.2,43.05 131.2,43.04 131.45,43.04 132.15,42.34 JDIMM1.239 ; v2(83.32,34.28) 83.4,34.2 JDIMM1.52 ; JNGFF1.7 v2(185.81,20.56) ; UV1.AB7 164.75,80.89 164.75,80.28 v2(164.29,79.81) ; JDIMM2.18 74.91,18.83 v2(75.02,18.72) ; JDIMM2.22 75.91,19.08 76.27,18.72 v2(76.55,18.72) 76.91,19.08 JDIMM2.26 ; JDIMM1.6 71.9,31.57 71.84,31.51 v2(71.84,31.46) 71.36,31.46 70.9,31.91 JDIMM1.2 ; JDIMM2.9 72.66,27.06 72.81,26.9 v2(72.81,26.85) ; UV1.G25 177.19,96.06 177.19,96.05 v2(177.61,95.63) ; JDIMM2.82 90.91,18.96 v2(91.15,18.72) 91.72,18.72 91.91,18.9 JDIMM2.86 ; UV1.AH10 159.6,83.56 v2(160,83.96) 159.59,84.38 UV1.AH11 ; v2(180.09,86.48) 180.49,86.08 UV1.C13 ; v2(126.23,34.86) 125.91,34.86 124.9,33.85 JDIMM1.210 ; UV1.E10 178.87,83.56 v2(178.47,83.16) ; UE6.3 239.13,25.24 238.87,24.98 v2(238.87,24.83) ; JDIMM1.202 122.9,31.68 123.23,31.36 v2(123.64,31.36) 123.65,31.36 123.9,31.61 JDIMM1.206 ; PU1401.4 v2(114.5,130.04) ; UV1.R16 UV1.T17 ; JDIMM2.106 v2(96.91,18.66) ; v2(72.45,108.73) 72.36,108.82 PU1501.23 ; v2(209.85,30.23) 209.77,30.32 JNGFF2.27 ; UV1.N30 v2(172.56,99.88)
  BOTTOM w0.33: v2(86.64,18.72) 86.41,18.95 JDIMM2.64 ; v2(81.05,18.72) 80.74,18.72 80.41,19.05 JDIMM2.40 ; v2(82.61,18.66) 82.41,18.85 JDIMM2.48
  BOTTOM w0.356: v2(164.73,83.35) v2(163.97,83.35) ; v2(166.48,84.75) 166.89,85.16 UV1.W13
  BOTTOM w0.381: QE23.4 14.85,21.37 14.77,21.45 v2(14.77,21.54) ; CE9.2 v2(147.53,13.88) ; RV62.2 151.13,82.16 149.49,82.16 149.18,82.46 149.18,84.29 149.32,84.43 v2(150.33,84.43) 150.95,84.43 RV63.2 ; v2(181.62,55.74) 181.37,55.49 181.06,55.49 PC1000.2 PC1008.2 ; PQ200.1 48.79,44.2 v2(48.59,44) ; CE69.2 220.35,30.04 v2(220.35,30.62) 220.35,31.11 221.32,32.07 CE84.1 ; QE21.4 17.06,15.93 17.23,15.76 17.23,15.3 v2(17.25,15.3) ; QE20.4 v2(14.25,15.27) ; v2(190.05,36.62) 189.95,36.62 189.37,36.03 RH95.1 ; v2(151.47,19.07) 151.19,18.79 CT79.2 ; RE22.2 223.66,29.66 222.74,28.74 CE12.2 ; QE20.1 12.95,17.39 v2(13.26,17.08) ; DI9.3 292.52,33.14 v2(292.74,33.37) ; DI7.3 v2(293.89,52.19) ; UV14.3 142.23,77.6 v2(141.74,78.1) 142.25,78.6 RV187.2 ; CE10.2 v2(144.78,15.23) ; QE21.1 15.74,18.29 16.15,18.7 QE23.1 16.15,19.66 v2(16.37,19.88) ; RH148.1 RH149.1
  BOTTOM w0.457: RL27.1 279.16,47.49 v2(279.41,47.74) 279.66,47.49 RL31.1 ; CE80.2 v2(150.7,13.52) ; PC204.2 50.38,38.85 50.8,39.28 v2(50.96,39.28) ; CL19.2 v2(283.87,49.57)
  BOTTOM w0.508: v2(189.82,13.82) 189.82,14.16 190.17,14.51 JHDD1.12 ; JTP.9 128.6,13.76 v2(127.9,13.76) 127.85,13.81 v3(127.85,14.57) ; CC27.2 v2(155.25,17.88) ; PC813.2 219.62,40.78 218.93,41.47 v2(218.93,41.95) ; v2(151.93,32.93) 151.93,32.69 CD33.2 150.76,31.74 v2(149.62,32.88) ; CE73.2 224.29,36.19 v2(224.39,36.29) ; v2(78.17,94.25) 78.55,93.87 PC1123.2 ; v2(179.64,72.86) CV71.1 178.9,72.84 YV1.2 ; v2(182.56,37.56) 181.65,37.56 181.26,37.18 CH179.2 ; CD69.2 96,17.64 96.48,18.13 96.71,18.13 96.91,18.33 v2(96.91,18.66) ; v2(227.14,25.14) 227.14,25.38 RE67.1 ; v2(37.6,16.25) 38.24,16.88 39.05,16.88 PC110.2 ; CA31.2 272.73,25.01 CA33.2 271.71,24.96 v2(271.54,25.14) ; PR607.2 250.63,11.09 v2(250.33,10.79) ; v2(68.08,47.49) 68.08,48.38 68.57,48.87 JDIMM1.261 ; v2(81.16,85.46) PC1111.2 ; PR214.2 v2(44.84,37.58) ; v3(143.98,108.65) 143.98,109.06 v2(144.36,109.44) PR902.1 ; RH185.2 v2(83.73,85.97) ; PC311.2 26.31,33.7 26.31,32.51 26.04,32.25 v2(26.04,32.12) ; DE4.2 v2(146.28,9.39) ; QA1.3 258.09,28.73 RM21.1 256.3,29.63 CA67.2 256.12,28.87 256.17,28.82 256.17,28.77 v2(256.14,28.74) ; v2(98.81,15.91) 98.81,15.56 98.74,15.48 PC518.2 ; v2(178.55,57.52) 178.9,57.88 179.73,57.88 179.86,58 179.87,58 PC1009.2 ; v2(197.34,20.36) 197.34,20 198.1,19.24 198.89,19.24 CS12.2 ; v2(96.5,15.87) 96.5,14.93 96.43,14.85 95.54,14.85 95.54,15.87 v2(95.56,15.89) ; v2(203.62,20.46) 203.64,20.49 203.64,22.38 JNGFF1.69 ; PC906.2 142.12,110.1 v2(142.63,109.59) ; v2(149.87,106.42) 150.33,106.42 CV151.2 ; PC612.2 PR604.2 253.48,11.6 253.86,11.22 v2(253.86,10.96) ; RV515.2 RV514.2 RV510.2 RV511.2 170.99,72.29 171.41,71.87 v2(171.79,71.87) ; PC1380.2 v2(120.47,102.01) ; CD95.2 RA66.2 v2(265.44,24.63) ; v2(77,93.39) 76.59,92.98 PC1120.2 PR1135.2 ; PR1014.1 PC1046.2 171,54.12 v2(170.75,53.86) ; JHDD1.9 191.67,13.13 191.71,13.17 v2(191.71,13.8) ; v2(65.57,69.76) 64.73,70.6 PC700.2 ; CV584.2 v2(232.23,47.73) ; PC400.2 56.32,22.22 v2(56.3,22.24) ; CL33.2 287.7,98.57 v2(286.53,98.57) ; RE22.2 223.91,29.78 v2(223.91,30.47) ; PR406.2 54.49,26.25 v2(54.16,26.58) ; v2(249.83,20.26) 249.83,19.74 249.95,19.63 PC601.2 ; v2(126.45,13.76) 124.27,11.57 JBL1.5 ; JBL1.6 v2(117.42,10.18) ; v2(174.81,83.9) 174.81,84.31 173.89,85.23 UV1.M13 ; CH50.1 179.38,18.35 v2(179.66,18.07) ; CD11.2 v2(84.08,15.48) ; PR213.2 v2(45.45,42.59) ; PC421.2 v2(48.52,23.64) ; CM24.2 CM25.2 v2(267.73,28.74) ; RH77.2 170.58,14.51 v2(170.58,14.52) ; PR807.2 PC812.2 227.59,38.85 v2(227.97,38.47) ; RH166.1 83.73,93.34 v2(83.7,93.36) ; PC1523.2 131.25,125.31 v2(131.33,125.24) ; CA61.2 294.46,17.31 294.97,17.82 v2(294.97,17.9) ; v2(200.8,20.44) 200.8,19.62 CS14.2 200.94,19.48 CS15.2 ; CL15.2 CL43.2 v2(291.22,46.98) ; v2(60.49,40.41) 59.54,39.46 JEDP1.43 v2(57.14,39.46) ; PD401.1 v2(53.1,28.06) ; CM13.2 CM10.2 265.85,39.46 v2(265.41,39.03) ; CM28.2 CM30.2 v2(260.28,38.34) ; v2(83.7,87.75) RH188.2 RH57.1 RH59.2 RH58.1 ; CV600.1 295.46,71.54 v2(293.89,69.97) ; v2(239.94,30.6) 240.42,30.11 JLPDE1.12 ; v2(293.74,68.32) CV598.2 ; RV58.1 140.22,77.64 141.21,78.63 v2(141.28,78.63) ; PC1116.2 78.19,89.14 v2(78.22,89.17) ; PC1044.2 154.31,45.58 v2(154.7,45.2) ; PR405.1 55.38,17.11 v2(55.31,17.03) ; PC1408.2 v2(128.53,132.83) ; JDIMM1.262 137.83,44.27 v2(137.37,43.8) ; PC1400.2 120.53,126.09 v2(120.53,125.9) ; PD102.1 v2(25.41,15.87) ; v2(66.43,82.39) PC1100.1 PR1100.1 ; JNGFF2.76 209.83,37.92 210.41,37.35 v2(210.41,36.96) ; RA62.2 269.35,21.45 269.52,21.29 269.72,21.29 v2(269.81,21.2) ; v2(173.64,72.08) 173.64,72.53 172.77,73.4 RV27.1 ; v2(260.23,35.04) 260.49,34.79 CM33.2 CM29.2 ; v2(292.96,23.02) 293.38,22.6 DA4.1 ; v2(49.92,27.55) 49.63,27.55 49.12,27.04 PC407.2 49.25,26.91 v2(49.92,26.91) ; PC1418.2 v2(100.26,126.41) ; v2(76.08,82.29) 75.83,82.54 PR1115.2 ; UV17.2 294.54,65.62 v2(295.41,65.62) ; PQ202.3 49.28,45.7 49.54,45.95 v2(49.54,46.35) 49.62,46.27 PR211.2 ; v2(283.8,39.08) 283.35,39.54 CL42.2 284.31,39.79 CL35.2 ; v2(83.7,91.28) 83.73,91.3 RH61.1 ; PC1124.2 63.43,92.7 v2(63.05,93.08) ; JDIMM2.262 67.29,32.07 v2(67.95,32.73) ; PC1501.1 93.74,132.32 v2(93.39,132.67) 93.39,133.1 v3(93.2,133.29) ; PC415.2 36.1,37.81 35.7,38.22 v2(35.7,38.85) ; PC415.2 v2(36.33,38.85) ; PC415.2 36.69,37.81 36.97,38.09 v2(36.97,38.85) ; v2(25.37,42.78) 25.68,42.47 PR323.2 ; PC1136.2 PR1143.2 v2(67.07,96.46) ; v2(271.08,32.28) 270.66,31.87 CM2.2 ; PC1103.2 v2(73.42,82.29) ; JCAM1.1 v2(241.8,43.51) ; v2(98.66,6.62) PR506.2 ; v2(57.29,28.06) JEDP1.44 59.36,28.06 v2(59.67,28.37) ; JRTC.3 156.72,9.24 155.85,8.37 v2(155.85,8.14) ; PC1102.2 v2(71.76,82.29) PC1101.2 ; CA32.2 276.59,24.83 v2(276.69,24.93) ; v2(59.22,20.16) 60.57,21.51 JEDP1.42 ; v2(185.98,44.57) 185.9,44.5 YH2.2 ; CM8.2 v2(272.63,37.46) ; v2(281.38,49.46) 281.2,49.65 UL2.2 ; JNGFF1.68 v2(183.21,24.52) ; PC1114.2 v2(64.96,89.65) ; CM22.2 262.26,31.18 v2(261.55,31.18) RM12.1 CM3.2 ; RH60.1 v2(81.32,95.49) ; v2(22.67,13.05) 22.55,13.16 PD101.1 ; v2(176.82,12.58) 176.82,12.84 175.8,13.86 CLRP1.2 ; v2(62.56,46.01) JEDP1.41 59.32,44.76 v2(59.32,43.45) ; v2(224.7,38.52) 224.5,38.73 223.83,38.73 223.53,39.03 223.53,39.41 PR810.2 PR808.2 ; CZ44.2 231.61,44.97 v2(231.28,44.64) ; PC309.1 23.84,35.84 v2(23.57,35.58) ; CM41.2 264.3,40.45 v2(264.3,41.52) ; CM1.2 268.56,28.72 v2(268.46,28.72) ; PC1410.2 110.32,126.53 v2(110.12,126.74) ; v2(295.54,78.98) 295.46,78.91 CV601.1 ; CV212.2 v2(145.29,77.87) ; PC322.1 PR329.2 v2(30.49,42.92) ; CL37.2 282.13,43.22 v2(282.46,43.55) ; PC1389.2 120.61,104.13 v2(121.19,104.71) ; CM31.2 CM32.2 260.36,36.57 v2(260.23,36.69) ; PR510.2 97.5,15.88 v2(97.5,15.88) ; v2(104.23,7.5) 104.22,7.51 PC506.2 PC507.2 ; v2(110.83,8.28) 110.33,8.28 PC504.2 ; v2(265.69,35.04) 265.82,34.92 CM4.2 ; CV70.1 175.98,72.86 v2(175.57,72.46) ; v2(175.65,60.56) 176.03,60.18 PC1020.2 ; RH150.1 121.46,69.51 v2(120.71,70.26) ; PR201.2 34.17,42.43 34.81,43.07 v2(34.93,43.07) ; CM34.2 272.34,34.72 v2(272.91,34.15) 273.24,34.48 CM37.2 ; v2(48.71,24.69) 48.85,24.83 PC405.2 ; EC5205.2 v2(240.67,35.22) ; v2(207.08,17.77) 207.27,17.58 208.49,17.58 JNGFF2.77 ; v2(78.27,86.35) 78.14,86.22 PR1123.2 PR1113.2 ; v2(177.77,69.93) YV1.4 ; RL30.2 286.04,37.23 286.04,36.54 v2(285.86,36.36) ; v2(173.75,18.98) 173.7,18.93 CH46.2 ; v2(235.39,30.6) 235.39,29.84 CE77.2 235.39,29.33 CE85.2 ; CM27.2 259.94,39.49 v2(259.72,39.7) ; JHDD1.14 JHDD1.13 v2(197.44,12.21) ; PR1144.2 68.84,98.03 v2(69.1,98.29) ; v2(113.42,132.71) 113.62,132.5 113.62,132.18 113.67,132.13 PC1411.1 ; PR605.2 v2(249.69,10.91) ; v2(250.23,30.47) 249.72,30.47 249.12,29.88 JLPDE1.11 ; v2(254.9,36.95) 255.31,36.95 JDEG1.12 ; v2(64.07,85.13) 64.2,85 PR1105.1 PC1104.1 ; v2(264.3,24.63) 264.17,24.63 264.12,24.58 264.11,24.58 263.89,24.35 263.89,24.35 263.66,24.12 CD94.2 RA67.2 ; PC602.2 250.83,20.1 250.66,20.28 v2(250.66,20.23) ; PC1139.2 69.73,98.03 v2(70.11,98.42) 70.62,97.91 PC1138.2 70.78,97.6 71.28,97.1 71.28,96.08 71.51,95.85 PC1135.2 ; v2(148.73,99.43) RV50.1 ; v2(142.45,25.67) 143.1,25.67 PC1803.2 ; RH41.2 v2(116.63,104.78) ; CL34.2 v2(285.25,39.11) ; PC1500.2 90.08,126.41 89.49,125.82 v2(89.49,125.62) ; JUART.5 v2(215.61,59.22) 215.33,59.5 JUART.4 v2(213.3,59.5) ; PR1115.2 PR1114.2 ; PR1115.2 PR1116.2 ; JHDMI1.22 307.44,82.7 v2(306.59,83.56) ; CD93.2 260.03,22.67 v2(260.36,22.34) ; PC811.2 219.92,41.7 v2(219.59,42.03) ; v2(234.3,17.47) 234.48,17.64 CE68.2 ; v2(218.26,17.78) 218.49,18 CD40.2 CD38.2 ; JCAM1.15 v2(242.32,43.02) ; v2(200.14,20.44) 200.03,20.34 CS13.2 ; CM26.2 262.28,42.2 v2(262.7,41.79) ; YH2.4 184.2,46.07 183.69,46.57 v2(183.25,46.57) ; v2(273.01,48.61) 274.55,48.61 CL39.2 ; v2(221.62,24) 221.14,23.52 CE79.2 221.27,23.36 221.96,23.36 222.5,22.81 CE91.2 RE35.2 ; PC1401.1 124.34,132.27 v2(124.34,132.71) ; CZ43.2 208.14,51.35 v2(207.68,51.35) ; RA16.2 278.93,16.51 279.87,15.57 v2(279.87,14.9) ; v2(295.41,66.26) 294.97,66.7 CV597.2 ; 231.18,20.61 231.51,20.95 CE82.2 ; 231.18,20.61 v2(231.15,20.61) ; 231.18,20.61 231.86,19.93 RE23.2 ; EC5206.2 v2(241.69,35.17) ; v2(237.45,42.28) 237.02,42.71 JCAM1.5 ; v2(290.66,39.36) 290.66,38.37 DI10.1 ; v2(76.97,99.28) 77.43,98.82 PC1130.2 ; PC313.1 28.24,30.88 29.07,30.88 v2(29.22,30.72) ; v2(230.01,17.41) 229.75,17.16 CE71.2 CE72.2 ; RV579.2 148.3,83.27 UV11.3 147.47,83.41 v2(147.08,83.81) ; v2(141.74,38.28) 141.74,36.11 JDIMM2.261 ; RV104.1 181.01,71.67 v2(181.85,72.51) ; PC1407.2 v2(127.64,132.83) ; PC1424.2 v2(107.58,132.58) ; v2(224.98,14.75) 224.98,15.26 225.38,15.66 CE67.2 ; YL2.4 v2(277.76,45.67) ; CM35.2 CM39.2 269.96,37.66 v2(270.27,37.35) ; PC1520.1 132.85,130.62 v2(132.6,130.88) 132.32,131.16 v3(132.32,131.61) ; PC1108.1 v2(63.05,88.76) ; v2(234.67,25.2) 234.99,24.88 CE62.2 CE86.2 RE27.1 ; JRTC.2 v2(152.92,11.85) ; JTP.10 143.74,12.6 v2(144.41,11.93) ; RH186.2 v2(84.39,84.24) ; PR403.1 58.35,19.09 v2(58.68,19.41) ; v2(247.91,10.94) PC611.2 ; PC420.2 48.32,19.75 v2(48.4,19.68) ; CH197.2 v2(80.49,83.81) ; CH45.2 176.77,18.07 177.28,17.56 v2(177.28,17.16) ; PC613.2 v2(248.8,10.94) ; v2(245.37,38.32) 246.24,37.46 JDEG1.11 ; RD10.1 205.11,20.21 204.85,20.48 v2(204.85,20.5) ; DA5.1 293.66,12.16 v2(293.15,12.66) 292.19,12.66 RA12.2 ; CL36.2 v2(281.82,46.6) ; v2(24.32,39.69) 24.32,39.79 25.22,40.69 PC323.2 ; CM5.2 269.58,34.03 CM36.2 CM38.2 268.23,34.08 v2(268.06,34.25) ; v2(295.21,60.54) 295.46,60.79 RV561.2 CV599.1 ; PR318.2 24.42,38.29 v2(24.37,38.24) ; UH8.4 182.15,7.74 182.47,7.42 v2(182.47,7.06) ; CM23.2 266.19,29.26 v2(266.84,28.62) ; QE24.4 287.42,59.21 287.61,59.4 287.61,59.88 288.24,60.51 QE24.1 288.87,60.51 290,61.64 v2(290,61.84) ; v2(57.24,23.79) 56.8,23.36 PR404.2 ; JUART.6 v2(215.61,64.2) ; PC321.2 27.82,42.85 v2(27.91,42.94) ; PC1508.2 v2(72.4,106.29) ; RH187.2 v2(83.73,86.86) ; CZ86.2 129.9,99.73 128.93,98.76 v2(128.92,98.76) ; PC1309.2 v2(93.99,110.61) ; JTP.5 v2(135.76,14.62) ; CL24.2 282.46,39.39 v2(282.76,39.08) ; v2(57.3,27.19) 56.88,27.19 PC422.2 ; v2(239.96,44.64) 240.02,44.59 JCAM1.2 ; SW5.4 v2(288.82,65.13) ; JCAM1.16 228.73,40.98 v2(229.64,41.89) ; PC1420.1 v2(104.02,132.58) ; RH29.2 RH33.2 108.05,104.27 v2(108.24,104.46) ; PR411.2 v2(52.71,26.66) ; RA9.2 278.77,22.85 279.28,22.85 v2(279.35,22.79) ; CM9.2 270.91,37.65 v2(270.8,37.76) ; JBAT10.12 v2(47.24,10.38) ; PC1509.1 v2(66.56,111.24) ; PU1800.8 147.5,24.95 147.96,25.42 PR1804.2 148.16,25.83 v2(148.63,26.3) ; PC1312.2 v2(95.77,110.61) ; JRTC.4 v2(150.37,8.12) ; DI8.1 v2(289.57,56.89) ; YL2.2 v2(280.51,42.41) ; PR907.2 v2(138.57,110.1) ; JHDD1.6 193.17,14.55 193.58,14.15 v2(193.58,13.8) ; DI3.1 v2(62.09,18.86) ; v2(210.12,57.6) 209.81,57.29 PR115.2 ; DV12.1 234.57,36.38 234.12,35.93 231.72,35.93 v2(231.51,36.15) ; JCAM1.8 v2(234.02,42.36) ; RM18.2 v2(270.01,42.54) ; PQ201.3 v2(45.6,45.98) ; PC1514.2 v2(66.71,114.8) ; PR204.1 v2(50.94,45.41)
  vias: v2(0.49,42.41) v2(0.49,40.68) v2(0.49,38.95) v2(0.49,37.23) v2(0.49,35.5) v2(0.49,33.77) v2(0.49,32.04) v2(0.49,30.32) v2(0.49,28.59) v2(0.49,26.86) v2(0.49,25.14) v2(0.49,23.41) v2(0.49,21.68) v2(0.49,19.95) v2(0.49,18.23) v2(0.49,16.5) v2(0.49,14.77) v2(0.49,13.05) v2(1.99,43.6) v2(2.3,18.57) v2(2.25,12.08) v2(3.72,43.6) v2(3.87,19.52) v2(3.97,12.08) v2(4.28,18.57) v2(4.72,39.35) v2(4.91,32.64) v2(5.01,32.02) v2(5,31.25) v2(5.45,43.6) v2(5.7,12.08) v2(5.9,19.52) v2(6.6,19.52) v2(7.17,43.6) v2(7.25,23.23) v2(7.43,12.08) v2(7.76,22.47) v2(8.39,21.96) v2(8.9,43.6) v2(8.95,29.05) v2(9,27.25) v2(9,25.75) v2(9.15,12.08) v2(10.63,43.6) v2(10.88,12.08) v2(12.35,43.6) v2(12.61,12.08) v2(14.01,10.76) v2(14.01,9.03) v2(14.01,7.31) v2(14.08,43.6) v2(14.31,39.61) v2(14.26,5.83) v2(14.82,39.18) v2(15.81,43.6) v2(16.52,25.77) v2(17.41,33.39) v2(17.41,32.76) v2(17.41,32.12) v2(17.41,31.23) v2(17.41,30.6) v2(17.41,29.58) v2(17.41,28.95) v2(17.41,27.8) v2(17.41,27.17) v2(17.76,43.6) v2(18.04,27.17) v2(18.42,27.68) v2(18.81,27.17) v2(19.19,27.68) v2(19.59,43.6) v2(20.58,26.15) v2(20.58,23.61) v2(21.22,26.15) v2(21.22,25.52) v2(21.22,24.88) v2(21.22,24.25) v2(21.22,23.61) v2(21.5,43.6) v2(21.85,26.15) v2(21.85,25.52) v2(21.85,24.88) v2(21.98,24.25) v2(21.98,23.61) v2(22.62,24.25) v2(22.62,23.61) v2(23.4,43.6) v2(24.7,5.76) v2(25.38,43.65) v2(26.43,5.76) v2(27.26,43.81) v2(28.15,5.76) v2(28.8,38.41) v2(28.8,36.27) v2(29.35,44.08) v2(29.8,13.88) v2(29.87,37.34) v2(29.88,5.76) v2(30.06,14.44) v2(30.44,13.88) v2(30.69,14.47) v2(30.94,38.41) v2(31,44.39) v2(31.07,13.88) v2(31.33,14.42) v2(31.51,32.22) v2(31.63,34.79) v2(31.61,5.76) v2(31.71,13.86) v2(31.94,33.52) v2(31.94,31.79) v2(31.94,31.21) v2(31.95,32.93) v2(31.96,14.39) v2(32.32,13.88) v2(32.52,31.79) v2(32.52,31.21) v2(32.52,30.62) v2(32.6,14.42) v2(32.88,44.82) v2(32.95,13.91) v2(33.28,14.39) v2(33.33,5.76) v2(33.64,13.91) v2(33.94,14.44) v2(34.22,13.91) v2(34.66,45.33) v2(35.06,5.76) v2(36.59,45.99) v2(36.79,5.76) v2(38.52,5.76) v2(38.54,46.75) v2(40.24,5.76) v2(40.35,47.59) v2(41.97,5.76) v2(42.07,48.5) v2(43.7,5.76) v2(43.82,49.52) v2(44.45,18.43) v2(44.45,17.67) v2(45.43,5.76) v2(45.5,50.66) v2(45.86,36.95) v2(45.86,36.31) v2(45.86,35.68) v2(45.86,35.04) v2(46.03,17.87) v2(46.03,17.24) v2(46.49,36.95) v2(46.49,36.31) v2(46.49,35.68) v2(46.49,35.04) v2(47.13,36.95) v2(47.13,36.31) v2(47.13,35.68) v2(47.13,35.04) v2(47.15,51.68) v2(47.15,5.76) v2(47.61,16.7) v2(47.76,36.95) v2(47.76,36.31) v2(47.76,35.68) v2(47.76,35.04) v2(47.79,16.12) v2(48.4,36.95) v2(48.4,36.31) v2(48.4,35.68) v2(48.4,35.04) v2(48.88,5.76) v2(49.21,51.76) v2(50.17,8.63) v2(50.61,5.76) v2(50.81,8.63) v2(50.94,38.57) v2(51.14,40.35) v2(51.43,36.81) v2(51.44,51.45) v2(51.71,21.55) v2(51.91,39.23) v2(51.95,33.8) v2(52.06,41.55) v2(52.15,42.85) v2(52.15,35.8) v2(52.34,22.18) v2(52.34,20.93) v2(52.33,5.76) v2(52.96,21.55) v2(53.3,52.36) v2(53.27,8.63) v2(53.86,8.63) v2(54.06,5.76) v2(55.1,57.32) v2(55.79,5.76) v2(55.86,55.67) v2(55.99,59.09) v2(56.68,62.78) v2(57.51,59.73) v2(57.52,5.76) v2(57.54,55.24) v2(57.62,13.87) v2(57.67,64.58) v2(58.43,66.16) v2(58.94,56.12) v2(59.19,67.88) v2(59.16,59.09) v2(59.24,14.82) v2(59.24,5.76) v2(59.45,57.39) v2(59.9,69.84) v2(60.46,71.62) v2(60.92,73.37) v2(60.97,5.76) v2(61.58,76.67) v2(61.68,9.41) v2(61.68,8.83) v2(61.78,78.27) v2(62.01,123.56) v2(62.01,121.83) v2(62.01,120.11) v2(62.01,118.38) v2(62.01,116.65) v2(62.01,114.93) v2(62.01,113.2) v2(62.01,111.47) v2(62.01,109.74) v2(62.01,108.02) v2(62.01,106.29) v2(62.01,104.56) v2(62.01,102.83) v2(62.01,101.11) v2(62.01,99.38) v2(62.01,97.65) v2(62.01,95.93) v2(62.01,94.2) v2(62.01,92.47) v2(62.01,90.74) v2(62.01,89.02) v2(62.01,87.29) v2(62.01,85.56) v2(62.01,83.84) v2(62.01,82.11) v2(62.09,125.31) v2(62.27,9.41) v2(62.27,8.83) v2(62.7,5.76) v2(62.85,9.41) v2(62.85,8.83) v2(63.13,76.83) v2(63.43,9.41) v2(63.43,8.83) v2(63.73,66.52) v2(63.76,125.49) v2(63.79,78.59) v2(63.76,75.3) v2(63.81,65.85) v2(64.02,8.83) v2(64.08,66.99) v2(64.04,9.41) v2(64.26,66.27) v2(64.41,65.7) v2(64.42,5.76) v2(64.5,67.4) v2(64.62,66.76) v2(64.84,66.22) v2(65.03,67.81) v2(65.03,67.17) v2(65.31,74.66) v2(65.41,79.11) v2(65.49,125.49) v2(66.15,5.76) v2(66.83,75.29) v2(66.94,78.35) v2(67.22,125.49) v2(67.47,76.82) v2(67.5,67.49) v2(67.88,5.76) v2(68.95,125.49) v2(69.53,22.73) v2(69.61,5.76) v2(69.77,91.53) v2(69.77,89.57) v2(69.77,87.6) v2(69.86,61.84) v2(70.49,62.6) v2(70.49,61.97) v2(70.58,21.39) v2(70.67,125.49) v2(71.16,62.58) v2(71.33,5.76) v2(71.43,111.32) v2(71.43,110.74) v2(71.54,38.52) v2(71.54,37.28) v2(71.67,21.86) v2(71.74,91.53) v2(71.74,89.57) v2(71.74,87.6) v2(72.27,67.43) v2(72.27,66.79) v2(72.27,66.16) v2(72.27,65.52) v2(72.27,63.62) v2(72.4,125.49) v2(72.53,119.62) v2(72.53,118.99) v2(72.53,118.35) v2(72.53,117.72) v2(72.53,117.08) v2(72.53,116.45) v2(72.53,115.69) v2(72.57,113.99) v2(72.57,112.57) v2(72.83,37.68) v2(72.83,36.51) v2(72.81,24.95) v2(72.83,23.71) v2(73.03,48.43) v2(73.03,47.64) v2(73.06,5.76) v2(73.16,119.62) v2(73.16,118.99) v2(73.16,118.35) v2(73.16,117.72) v2(73.16,115.43) v2(73.35,113.99) v2(73.35,112.57) v2(73.44,111.13) v2(73.44,110.55) v2(73.71,91.53) v2(73.71,89.57) v2(73.71,87.6) v2(73.8,119.62) v2(73.8,118.99) v2(73.8,118.35) v2(73.8,117.72) v2(74.13,125.49) v2(74.13,113.99) v2(74.13,112.57) v2(74.43,119.62) v2(74.43,118.99) v2(74.43,118.35) v2(74.43,117.72) v2(74.43,117.08) v2(74.43,116.45) v2(74.43,115.81) v2(74.79,5.76) v2(74.93,35.43) v2(74.94,38.1) v2(75.07,119.62) v2(75.07,118.99) v2(75.07,118.35) v2(75.07,117.72) v2(75.07,117.08) v2(75.07,116.45) v2(75.07,115.86) v2(75.14,25.47) v2(75.14,24.3) v2(75.14,23.13) v2(75.7,119.62) v2(75.7,118.99) v2(75.7,118.35) v2(75.7,117.72) v2(75.7,117.08) v2(75.85,125.49) v2(76.12,37.63) v2(76.11,36.43) v2(76.34,119.62) v2(76.34,118.99) v2(76.34,118.35) v2(76.34,117.72) v2(76.34,117.08) v2(76.51,5.76) v2(77.12,25.47) v2(77.1,24.3) v2(77.1,23) v2(77.58,125.49) v2(78.03,108.45) v2(78.03,70.08) v2(77.99,8.91) v2(78.24,5.76) v2(78.43,23.54) v2(78.5,110.29) v2(78.51,107.29) v2(78.51,71.91) v2(78.51,37.73) v2(78.57,68.84) v2(78.55,36.55) v2(78.55,34.55) v2(78.62,8.91) v2(79.19,63.47) v2(79.31,125.49) v2(79.38,8.91) v2(79.61,111.13) v2(79.58,72.7) v2(79.8,68.02) v2(79.84,106.42) v2(80,64.35) v2(79.97,5.76) v2(80.72,65.87) v2(80.67,25.37) v2(80.67,24.1) v2(80.67,22.83) v2(80.93,125.82) v2(81.2,75.48) v2(81.32,111.15) v2(81.32,72.74) v2(81.42,115.99) v2(81.42,115.35) v2(81.42,114.67) v2(81.49,133.04) v2(81.49,129.58) v2(81.5,39.13) v2(81.51,37.92) v2(81.48,37.33) v2(81.59,106.58) v2(81.54,68.15) v2(81.7,5.76) v2(81.8,134.25) v2(82.26,66.52) v2(82.48,110.26) v2(82.51,107.37) v2(82.48,75.49) v2(82.45,68.85) v2(82.49,25.49) v2(82.48,23.59) v2(82.49,22.3) v2(82.57,71.73) v2(82.8,128.82) v2(82.95,108.52) v2(82.97,70.09) v2(83.07,114.54) v2(83.31,5.76) v2(83.37,37.1) v2(83.45,15.48) v2(83.55,134.28) v2(83.56,127.17) v2(83.69,130.59) v2(84.41,79.01) v2(84.59,24.36) v2(84.57,22.42) v2(84.76,38.32) v2(84.74,37.07) v2(84.76,35.78) v2(85.21,131.23) v2(85.21,126.66) v2(85.28,134.28) v2(85.33,77.44) v2(85.73,80.23) v2(85.8,25.9) v2(85.79,24.58) v2(85.79,23.31) v2(86.62,127.37) v2(86.84,72.98) v2(86.86,130.59) v2(86.87,71.23) v2(87,134.28) v2(87.26,128.77) v2(87.81,26.02) v2(87.82,24.78) v2(87.82,23.51) v2(87.98,71.9) v2(88.21,37.39) v2(88.26,35.81) v2(88.73,134.28) v2(89.42,68.04) v2(89.42,66.28) v2(89.85,23.65) v2(89.85,21.9) v2(90.11,71.43) v2(90.46,134.28) v2(90.51,38.52) v2(90.51,36.92) v2(90.51,34.98) v2(91.27,80.51) v2(91.74,36.46) v2(91.77,38.38) v2(92.19,134.28) v2(92.19,25.34) v2(92.19,24.07) v2(92.19,22.8) v2(93.04,125.73) v2(93.23,127.74) v2(93.62,125.73) v2(93.81,127.74) v2(93.91,134.28) v2(93.96,12.88) v2(93.99,5.76) v2(94.26,12.28) v2(94.41,70.96) v2(94.53,95.48) v2(94.57,12.87) v2(94.88,12.31) v2(95.06,126.6) v2(95.06,125.81) v2(95.06,125.03) v2(95.21,12.87) v2(95.29,95.49) v2(95.51,12.31) v2(95.51,5.76) v2(95.64,134.28) v2(95.92,37.88) v2(95.84,12.87) v2(96.28,69.86) v2(96.29,67.97) v2(96.35,72.35) v2(96.42,22.47) v2(96.48,126.6) v2(96.48,125.81) v2(96.48,125.03) v2(96.54,23.79) v2(96.48,12.87) v2(96.87,95.49) v2(97.01,124.09) v2(97.14,35.85) v2(97.11,12.87) v2(97.14,38.22) v2(97.14,37.05) v2(97.24,5.76) v2(97.37,134.28) v2(97.62,124.09) v2(97.64,95.5) v2(97.75,12.87) v2(97.88,126.25) v2(97.88,125.62) v2(97.93,119.12) v2(97.93,118.48) v2(97.93,117.85) v2(98.1,125.06) v2(98.1,124.42) v2(98.06,24.7) v2(98.18,126.8) v2(98.46,125.76) v2(98.56,119.12) v2(98.56,118.48) v2(98.56,117.85) v2(98.71,125.21) v2(98.71,124.6) v2(98.97,5.76) v2(99.1,134.28) v2(99.1,125.76) v2(99.07,124.07) v2(99.07,123.48) v2(99.1,122.34) v2(99.2,119.12) v2(99.2,118.48) v2(99.2,117.85) v2(99.2,95.49) v2(99.35,125.21) v2(99.35,124.6) v2(99.4,122.98) v2(99.54,68.46) v2(99.44,21.96) v2(99.51,11.89) v2(99.56,72.11) v2(99.56,70.32) v2(99.57,15.89) v2(99.7,124.07) v2(99.7,123.48) v2(99.7,122.37) v2(99.83,119.12) v2(99.83,118.48) v2(99.83,117.85) v2(99.93,125.16) v2(100.04,125.75) v2(100.01,124.58) v2(99.98,122.95) v2(100.02,95.49) v2(100.09,11.89) v2(100.31,124.04) v2(100.29,123.46) v2(100.31,122.37) v2(100.24,24.17) v2(100.47,119.12) v2(100.47,118.48) v2(100.47,117.85) v2(100.57,124.75) v2(100.62,122.9) v2(100.62,17.57) v2(100.59,14.11) v2(100.7,5.76) v2(100.82,134.28) v2(100.9,123.94) v2(100.92,122.34) v2(101.13,124.5) v2(101.1,119.12) v2(101.1,118.48) v2(101.1,117.85) v2(101.2,17.57) v2(101.25,123.43) v2(101.25,122.85) v2(101.61,95.49) v2(101.64,34.81) v2(101.65,38.7) v2(101.65,37.53) v2(101.65,36.36) v2(101.75,24.79) v2(101.79,17.57) v2(102.12,68.85) v2(102.14,70.32) v2(102.15,66.94) v2(102.22,65.02) v2(102.36,95.5) v2(102.37,17.57) v2(102.42,5.76) v2(102.55,134.28) v2(102.71,22.17) v2(103.33,125.73) v2(103.52,127.74) v2(103.62,35.29) v2(103.72,110.56) v2(103.72,109.92) v2(103.72,109.29) v2(103.64,37.68) v2(103.64,36.48) v2(103.82,23.93) v2(103.91,125.73) v2(103.95,95.49) v2(104.1,127.74) v2(104.15,5.76) v2(104.28,134.28) v2(104.72,95.48) v2(105.35,126.6) v2(105.35,125.81) v2(105.35,125.03) v2(105.42,38.81) v2(105.41,36.88) v2(105.57,24.52) v2(105.67,23.29) v2(105.7,21.54) v2(105.88,5.76) v2(106,134.28) v2(106.32,95.49) v2(106.72,15.87) v2(106.77,126.6) v2(106.77,125.81) v2(106.77,125.03) v2(106.94,110.67) v2(106.94,110.04) v2(106.94,109.4) v2(107.07,95.49) v2(107.07,71.59) v2(107.07,69.61) v2(107.07,67.67) v2(107.1,65.86) v2(107.2,18.66) v2(107.32,15.89) v2(107.6,5.76) v2(107.73,134.28) v2(107.64,110.73) v2(107.64,110.1) v2(107.64,109.46) v2(107.83,18.66) v2(107.93,15.87) v2(108.31,37.52) v2(108.32,36.2) v2(108.32,34.99) v2(108.47,126.8) v2(108.47,125.21) v2(108.47,124.58) v2(108.47,123.97) v2(108.47,123.34) v2(108.47,122.7) v2(108.47,122.04) v2(108.47,121.4) v2(108.47,120.77) v2(108.47,120.13) v2(108.47,119.5) v2(108.59,115.05) v2(108.59,114.42) v2(108.59,113.78) v2(108.59,113.15) v2(108.54,15.87) v2(108.98,24.75) v2(109,23.53) v2(108.97,22.05) v2(109.1,126.8) v2(109.1,125.21) v2(109.1,124.58) v2(109.1,123.97) v2(109.1,123.34) v2(109.1,122.7) v2(109.1,122.04) v2(109.1,121.4) v2(109.1,120.77) v2(109.1,120.13) v2(109.1,119.5) v2(109.15,15.87) v2(109.33,5.76) v2(109.46,134.28) v2(109.74,125.21) v2(109.74,124.58) v2(109.74,123.97) v2(109.74,123.34) v2(109.74,122.7) v2(109.74,122.04) v2(109.74,121.4) v2(109.74,120.77) v2(109.74,120.13) v2(109.74,119.5) v2(110.08,71.97) v2(110.37,124.58) v2(110.37,123.94) v2(110.37,123.31) v2(110.37,122.7) v2(110.37,122.04) v2(110.37,121.4) v2(110.37,120.77) v2(110.37,120.13) v2(110.37,119.5) v2(110.8,110.1) v2(110.8,109.46) v2(110.8,108.83) v2(110.78,38.74) v2(110.78,37.14) v2(110.84,35.95) v2(110.88,85.56) v2(110.91,34.27) v2(110.97,23.58) v2(111.06,5.76) v2(111.19,134.28) v2(111.29,70.47) v2(111.64,8.26) v2(111.82,95.48) v2(111.87,86.91) v2(111.9,85.61) v2(112.28,114.93) v2(112.28,114.29) v2(112.28,113.66) v2(112.28,113.02) v2(112.3,8.26) v2(112.79,5.76) v2(112.91,134.28) v2(112.89,8.26) v2(113.23,125.85) v2(113.16,62.82) v2(113.15,61.38) v2(113.14,60.03) v2(113.42,127.87) v2(113.41,95.49) v2(113.45,38.32) v2(113.47,37.07) v2(113.44,35.9) v2(113.45,34.7) v2(113.52,8.26) v2(113.82,125.85) v2(114.01,127.87) v2(113.95,24.27) v2(113.95,23.03) v2(114.19,95.49) v2(114.51,5.76) v2(114.64,134.28) v2(114.72,22.1) v2(115.25,126.72) v2(115.25,125.94) v2(115.25,125.16) v2(115.31,24.24) v2(115.29,23.6) v2(115.27,22.32) v2(115.75,95.49) v2(115.79,64.8) v2(115.99,90.72) v2(115.99,90.08) v2(115.99,89.45) v2(115.99,88.81) v2(116.2,36.84) v2(116.24,5.76) v2(116.37,134.28) v2(116.39,70.5) v2(116.56,95.5) v2(116.68,126.72) v2(116.68,125.94) v2(116.68,125.16) v2(116.83,79.27) v2(117.07,63.6) v2(117.29,69.66) v2(117.61,24.37) v2(117.62,23.1) v2(117.97,5.76) v2(118.09,134.28) v2(118.06,126.16) v2(118.15,95.5) v2(118.3,126.94) v2(118.37,125.34) v2(118.37,124.7) v2(118.37,124.07) v2(118.37,123.43) v2(118.37,122.8) v2(118.37,122.16) v2(118.37,121.53) v2(118.37,120.89) v2(118.37,120.26) v2(118.37,119.62) v2(118.4,36.7) v2(118.51,68.4) v2(118.5,24.67) v2(118.63,126.43) v2(118.68,125.85) v2(119.01,125.34) v2(119.01,124.7) v2(119.01,124.07) v2(119.01,123.43) v2(119.01,122.8) v2(119.01,122.16) v2(119.01,121.53) v2(119.01,120.89) v2(119.01,120.26) v2(119.01,119.62) v2(119.03,71.99) v2(119.56,37.53) v2(119.54,36.31) v2(119.64,125.34) v2(119.64,124.7) v2(119.64,124.07) v2(119.64,123.43) v2(119.64,122.8) v2(119.64,122.16) v2(119.64,121.53) v2(119.64,120.89) v2(119.64,120.26) v2(119.64,119.62) v2(119.69,5.76) v2(119.82,134.28) v2(119.86,71.13) v2(120.15,72.71) v2(120.17,66.66) v2(120.28,124.7) v2(120.28,124.07) v2(120.28,123.43) v2(120.28,122.8) v2(120.28,122.16) v2(120.28,121.53) v2(120.28,120.89) v2(120.28,120.26) v2(120.33,25.31) v2(120.33,24.09) v2(120.33,22.85) v2(121.05,38.53) v2(121.1,34.41) v2(121.38,71.46) v2(121.42,5.76) v2(121.55,134.28) v2(122.31,36.82) v2(122.31,34.84) v2(122.27,25.48) v2(122.27,24.29) v2(122.27,23.02) v2(122.84,103.04) v2(123.15,5.76) v2(123.28,134.28) v2(123.39,125.85) v2(123.49,21.55) v2(123.58,127.87) v2(123.98,125.85) v2(123.97,72.55) v2(123.99,38.99) v2(123.99,37.75) v2(123.99,36.48) v2(124.04,24.44) v2(124.03,22.5) v2(124.17,127.87) v2(124.55,101.49) v2(124.62,84.72) v2(124.88,5.76) v2(125,134.28) v2(125.09,24.44) v2(125.1,23.18) v2(125.41,126.72) v2(125.41,125.94) v2(125.41,125.16) v2(126.03,35.69) v2(126.16,39.02) v2(126.15,37.75) v2(126.35,23.73) v2(126.5,114.49) v2(126.5,113.91) v2(126.5,113.27) v2(126.5,112.64) v2(126.6,5.76) v2(126.73,134.28) v2(126.84,126.72) v2(126.84,125.94) v2(126.84,125.16) v2(127.9,119.62) v2(127.9,118.99) v2(128.13,36.81) v2(128.22,126.16) v2(128.15,35.61) v2(128.18,24.37) v2(128.18,23.21) v2(128.33,5.76) v2(128.46,134.28) v2(128.53,126.93) v2(128.53,125.34) v2(128.53,124.7) v2(128.53,124.07) v2(128.53,120.89) v2(128.53,120.26) v2(128.53,119.62) v2(128.53,118.99) v2(128.66,108.83) v2(129.07,115.08) v2(129.09,113.2) v2(129.09,112.61) v2(129.09,112) v2(129.17,126.93) v2(129.17,125.34) v2(129.17,124.7) v2(129.17,124.07) v2(129.17,123.43) v2(129.17,122.8) v2(129.17,122.16) v2(129.17,121.53) v2(129.17,120.89) v2(129.17,120.26) v2(129.17,119.62) v2(129.17,118.99) v2(129.52,111.12) v2(129.52,110.48) v2(129.52,109.85) v2(129.52,109.21) v2(129.51,21.7) v2(129.58,26.07) v2(129.57,24.22) v2(129.55,23) v2(129.8,126.93) v2(129.8,125.34) v2(129.8,124.7) v2(129.8,124.07) v2(129.8,123.43) v2(129.8,122.8) v2(129.8,122.16) v2(129.8,121.53) v2(129.8,120.89) v2(129.8,120.26) v2(129.8,119.62) v2(129.8,118.99) v2(130.06,5.76) v2(130.18,134.28) v2(130.39,122.88) v2(130.39,122.24) v2(130.44,121.53) v2(130.44,120.89) v2(130.44,120.26) v2(130.44,119.62) v2(130.44,118.99) v2(130.7,38.72) v2(130.71,37.49) v2(131.38,25.53) v2(131.35,24.23) v2(131.53,21.96) v2(131.71,38.97) v2(131.71,37.73) v2(131.74,36.44) v2(131.76,34.91) v2(131.79,5.76) v2(131.91,134.28) v2(132.47,123.82) v2(132.7,26.04) v2(132.7,24.82) v2(132.93,23.56) v2(133.44,125.93) v2(133.36,36.29) v2(133.51,5.76) v2(133.64,134.28) v2(133.68,124.88) v2(134.38,22.09) v2(134.48,124.88) v2(135.24,5.76) v2(135.27,124.88) v2(135.27,123.82) v2(135.37,134.28) v2(135.35,23.99) v2(135.71,36.92) v2(135.84,25.12) v2(136,96.56) v2(136.06,95.45) v2(136.74,125.54) v2(136.79,108.58) v2(136.87,123.97) v2(136.89,123.38) v2(136.97,5.76) v2(137.09,134.28) v2(137.04,111.37) v2(137.04,110.73) v2(137.04,109.97) v2(137.04,109.34) v2(137.17,113.66) v2(137.17,113.02) v2(137.17,62.8) v2(137.15,58.98) v2(137.14,56.91) v2(137.17,55.06) v2(137.3,119.47) v2(137.34,104.23) v2(137.34,70.69) v2(137.37,125.54) v2(137.42,123.69) v2(137.35,123) v2(137.35,122.39) v2(137.35,121.81) v2(137.35,121.22) v2(137.35,120.64) v2(137.35,120.06) v2(137.55,112.39) v2(137.83,106.06) v2(137.83,103.01) v2(137.83,72.52) v2(137.83,69.47) v2(137.93,124.02) v2(137.93,123.38) v2(137.93,122.77) v2(137.91,122.11) v2(137.91,121.53) v2(137.93,120.49) v2(137.93,119.9) v2(137.91,119.32) v2(138.03,125.54) v2(138.21,121.02) v2(138.44,123.69) v2(138.47,123.08) v2(138.47,122.34) v2(138.49,121.76) v2(138.59,124.35) v2(138.59,95.84) v2(138.57,93.91) v2(138.69,5.76) v2(138.82,134.28) v2(138.77,121.2) v2(138.9,106.85) v2(138.9,73.31) v2(139.03,123.69) v2(139.1,122.49) v2(139.13,121.91) v2(139.11,102.17) v2(139.14,68.61) v2(139.48,120.59) v2(139.48,120.01) v2(139.48,119.42) v2(139.71,122.29) v2(139.71,113.63) v2(139.71,112.44) v2(140.32,19.98) v2(140.42,5.76) v2(140.55,134.28) v2(140.59,106.91) v2(140.61,73.35) v2(140.68,113.03) v2(140.85,102.33) v2(140.88,68.76) v2(140.9,19.98) v2(141.65,113.63) v2(141.65,112.44) v2(141.81,105.98) v2(141.75,103.04) v2(141.81,72.44) v2(141.75,69.5) v2(142.12,54.79) v2(142.12,54.16) v2(142.12,53.52) v2(142.12,52.89) v2(142.12,52.25) v2(142.12,51.62) v2(142.12,50.98) v2(142.12,50.35) v2(142.12,49.71) v2(142.12,49.08) v2(142.12,48.44) v2(142.12,47.81) v2(142.24,104.22) v2(142.24,70.68) v2(142.15,5.76) v2(142.28,134.28) v2(142.69,55.11) v2(142.69,54.47) v2(142.69,53.84) v2(142.69,53.2) v2(142.69,52.57) v2(142.69,51.93) v2(142.69,51.3) v2(142.69,50.66) v2(142.69,50.03) v2(142.69,49.39) v2(142.69,48.76) v2(142.69,48.12) v2(142.69,47.49) v2(143.33,55.36) v2(143.33,54.73) v2(143.33,54.09) v2(143.33,53.46) v2(143.33,52.82) v2(143.33,52.19) v2(143.33,51.55) v2(143.33,50.92) v2(143.33,50.28) v2(143.33,49.65) v2(143.33,49.01) v2(143.33,48.38) v2(143.33,47.74) v2(143.33,47.11) v2(143.33,46.47) v2(143.9,55.11) v2(143.9,54.47) v2(143.9,53.84) v2(143.9,53.2) v2(143.9,52.57) v2(143.9,51.93) v2(143.9,51.3) v2(143.9,50.66) v2(143.9,50.03) v2(143.9,49.39) v2(143.9,48.76) v2(143.9,48.12) v2(143.9,47.49) v2(143.9,46.85) v2(143.9,46.22) v2(143.88,5.76) v2(144,134.28) v2(144.05,16.63) v2(144.66,16.63) v2(144.79,68.44) v2(145.04,70.86) v2(145.04,60.06) v2(145.42,68.44) v2(145.55,116.07) v2(145.59,21.55) v2(145.6,5.76) v2(145.73,134.28) v2(145.68,70.86) v2(145.68,60.06) v2(146.06,112.26) v2(146.19,116.07) v2(146.31,60.06) v2(146.31,38.85) v2(146.31,38.22) v2(146.69,112.26) v2(146.82,116.07) v2(147.33,5.76) v2(147.46,134.28) v2(149.06,5.76) v2(149.18,134.28) v2(150.78,5.76) v2(150.91,134.28) v2(151.52,106.16) v2(151.52,105.53) v2(151.52,104.51) v2(151.52,103.88) v2(151.52,102.51) v2(151.52,101.84) v2(151.52,100.96) v2(151.52,100.32) v2(152.51,5.76) v2(152.64,134.28) v2(154.24,5.76) v2(154.37,134.28) v2(155.97,5.76) v2(156.09,134.28) v2(156.14,50.78) v2(156.6,51.15) v2(156.73,43.42) v2(156.7,19.17) v2(157.06,50.54) v2(157.06,21.83) v2(157.19,51.12) v2(157.34,50.02) v2(157.64,50.54) v2(157.69,5.76) v2(157.82,134.28) v2(157.77,51.12) v2(157.95,50.02) v2(158.23,85.64) v2(158.23,50.54) v2(158.21,38.5) v2(158.35,51.12) v2(158.52,107.76) v2(158.52,107.18) v2(158.52,106.59) v2(158.59,50.03) v2(158.86,50.82) v2(158.91,39.54) v2(158.96,93.92) v2(159.09,40.6) v2(159.09,36.36) v2(159.17,94.73) v2(159.34,42.54) v2(159.37,38.5) v2(159.47,34.18) v2(159.55,134.28) v2(160.23,35.04) v2(160.23,34.18) v2(160.19,26.23) v2(160.44,38.34) v2(160.61,40.05) v2(160.56,25.09) v2(160.79,89.8) v2(160.74,88.99) v2(160.89,90.85) v2(160.89,77.28) v2(160.94,30.57) v2(161.05,56.12) v2(161.05,55.49) v2(161.05,54.85) v2(161.05,54.22) v2(161.05,53.58) v2(161.05,52.95) v2(161.05,52.31) v2(161.12,50.44) v2(161.04,36.45) v2(161.2,40.05) v2(161.27,134.28) v2(161.51,106.19) v2(161.58,55.77) v2(161.55,55.17) v2(161.55,54.54) v2(161.55,53.9) v2(161.55,53.27) v2(161.55,52.63) v2(161.55,52) v2(161.55,51.4) v2(161.61,50.78) v2(161.58,50.08) v2(161.68,31.69) v2(161.81,29.42) v2(161.76,26.21) v2(161.84,45.25) v2(162.06,54.85) v2(162.06,54.22) v2(162.06,53.58) v2(162.06,52.95) v2(162.06,52.31) v2(162.06,51.68) v2(162.11,51.09) v2(162.06,50.41) v2(162.32,42.6) v2(162.34,41.24) v2(162.44,38.47) v2(162.57,50.73) v2(162.57,50.08) v2(162.7,37.37) v2(163,134.28) v2(163.08,51.04) v2(163.08,50.41) v2(163.13,30.57) v2(163.23,35.03) v2(163.15,31.69) v2(163.34,37.37) v2(163.71,51.04) v2(163.71,50.41) v2(163.89,32.96) v2(164.1,35.16) v2(164.04,30.5) v2(164.22,81.42) v2(164.2,80.65) v2(164.22,50.73) v2(164.22,50.09) v2(164.25,103.77) v2(164.41,42.6) v2(164.36,37.4) v2(164.45,106.49) v2(164.53,39.9) v2(164.73,134.28) v2(164.73,51.04) v2(164.73,50.41) v2(165.24,50.73) v2(165.24,50.09) v2(165.28,33.96) v2(165.26,32.46) v2(165.29,30.11) v2(165.74,51.04) v2(165.74,50.41) v2(165.77,39.86) v2(165.77,28.03) v2(165.9,44.8) v2(166.03,106.35) v2(166.06,33.97) v2(166.05,30.07) v2(166.25,50.73) v2(166.25,50.09) v2(166.46,134.28) v2(166.63,28.12) v2(166.75,51.03) v2(166.81,42.59) v2(166.79,39.51) v2(166.77,28.83) v2(166.79,25.9) v2(166.88,105.5) v2(166.87,34.74) v2(166.85,30.09) v2(166.99,44.76) v2(167.35,50.99) v2(167.61,34.74) v2(167.61,33.19) v2(167.86,105.77) v2(168.03,40.1) v2(168.06,40.71) v2(168.18,134.28) v2(168.34,37.52) v2(168.38,34.75) v2(168.4,33.92) v2(168.39,33.18) v2(168.39,32.43) v2(168.49,45.48) v2(169.03,104.97) v2(169.22,42.57) v2(169.17,40.63) v2(169.19,39.86) v2(169.18,34.71) v2(169.18,34) v2(169.18,33.16) v2(169.15,32.4) v2(169.3,58.54) v2(169.28,37.49) v2(169.65,45.24) v2(169.91,134.28) v2(169.89,105.05) v2(169.91,30.09) v2(170.32,58.54) v2(170.32,40.5) v2(170.27,28.81) v2(170.7,35.51) v2(170.71,30.15) v2(170.77,105.01) v2(170.95,5.76) v2(171.33,58.54) v2(171.31,42.57) v2(171.64,134.28) v2(171.64,68.93) v2(171.73,99.88) v2(171.74,46.16) v2(171.71,36.9) v2(171.79,29.15) v2(172.3,44.52) v2(172.52,29.11) v2(172.55,28.29) v2(172.68,5.76) v2(172.87,31.6) v2(172.96,37.66) v2(173.21,45.1) v2(173.3,63.46) v2(173.31,27.22) v2(173.36,134.28) v2(173.4,69.03) v2(173.39,68.44) v2(173.4,29.12) v2(173.42,28.29) v2(173.49,30.44) v2(173.57,45.79) v2(173.54,25.09) v2(173.69,42.59) v2(173.79,39.36) v2(173.94,63.43) v2(174.19,62.79) v2(174.21,38.77) v2(174.24,37.3) v2(174.31,36.42) v2(174.41,5.76) v2(174.57,63.36) v2(174.79,45.18) v2(174.89,62.79) v2(174.87,41.41) v2(174.98,55.94) v2(174.98,53.88) v2(175.09,134.28) v2(175.06,36.4) v2(175.07,33.99) v2(175.59,45.92) v2(175.58,40.4) v2(175.73,39.26) v2(175.82,33.99) v2(176.01,54.91) v2(176.13,5.76) v2(176.16,68.85) v2(176.16,68.21) v2(176.16,41.77) v2(176.17,41.12) v2(176.38,38.43) v2(176.53,40.43) v2(176.62,42.64) v2(176.54,39.26) v2(176.58,33.99) v2(176.69,42.03) v2(176.82,134.28) v2(176.77,68.85) v2(176.77,68.21) v2(176.9,25.85) v2(177.04,55.94) v2(177.04,53.88) v2(177.4,68.85) v2(177.4,68.21) v2(177.66,45.08) v2(177.84,40.76) v2(177.78,34.03) v2(177.79,31.66) v2(177.78,27.12) v2(177.86,5.76) v2(178.55,134.28) v2(179.48,23.19) v2(179.59,5.76) v2(180.06,23.25) v2(180.27,134.28) v2(180.32,33.8) v2(180.47,34.92) v2(181.32,40.05) v2(181.32,5.76) v2(181.65,39.53) v2(182,134.28) v2(182.93,86.12) v2(183.04,5.76) v2(183.6,17.12) v2(183.73,134.28) v2(184.17,87.71) v2(184.77,5.76) v2(184.96,90.3) v2(185.08,94.65) v2(185.23,7.36) v2(185.29,30.88) v2(185.37,17.12) v2(185.46,134.28) v2(185.92,96.04) v2(185.94,91.53) v2(186.04,9.34) v2(186.79,91.52) v2(186.75,29.5) v2(187.18,134.28) v2(187.84,72.13) v2(188.27,9.52) v2(188.48,72.13) v2(188.7,43.42) v2(188.82,45.04) v2(188.79,41.79) v2(188.91,134.28) v2(190.12,43.46) v2(190.15,45.1) v2(190.15,41.76) v2(190.26,33.19) v2(190.38,9.52) v2(190.64,134.28) v2(191.7,128.82) v2(191.73,9.52) v2(192.19,33.19) v2(192.36,134.28) v2(192.46,127.17) v2(192.59,130.59) v2(193.21,44.07) v2(193.3,42) v2(193.33,40.05) v2(193.46,9.52) v2(193.99,27.53) v2(194.09,134.28) v2(194.11,131.23) v2(194.11,126.66) v2(195.08,71.49) v2(195.08,70.86) v2(195.08,70.22) v2(195.08,69.59) v2(195.08,59.05) v2(195.13,42) v2(195.13,40.12) v2(195.18,9.52) v2(195.63,127.29) v2(195.59,39.72) v2(195.72,71.49) v2(195.72,70.86) v2(195.72,70.22) v2(195.72,69.59) v2(195.73,41.41) v2(195.67,31.61) v2(195.82,134.28) v2(195.76,130.59) v2(195.79,27.55) v2(195.84,59.05) v2(196.27,128.82) v2(196.35,71.49) v2(196.35,70.86) v2(196.35,70.22) v2(196.35,69.59) v2(196.73,58.99) v2(196.91,9.52) v2(196.99,71.49) v2(196.99,70.86) v2(196.99,70.22) v2(196.99,69.59) v2(197.55,134.28) v2(197.62,71.49) v2(197.62,70.86) v2(197.62,70.22) v2(197.62,69.59) v2(197.62,58.99) v2(197.88,40.81) v2(198.08,133.16) v2(198.26,71.49) v2(198.26,70.86) v2(198.26,70.22) v2(198.26,69.59) v2(198.51,58.99) v2(198.64,125.85) v2(198.71,26.94) v2(198.89,71.49) v2(198.89,70.86) v2(198.89,70.22) v2(199.15,59.02) v2(199.3,40.6) v2(199.3,26.96) v2(199.53,71.49) v2(199.53,70.86) v2(199.53,70.22) v2(199.53,31.23) v2(199.78,59.02) v2(200.16,71.49) v2(200.16,70.86) v2(200.16,70.22) v2(200.16,31.23) v2(200.41,33.72) v2(200.8,71.49) v2(200.8,70.86) v2(200.8,70.22) v2(200.85,125.49) v2(201.01,40.72) v2(201.09,30.62) v2(201.43,71.49) v2(201.43,70.86) v2(201.43,70.22) v2(201.43,69.59) v2(201.38,33.26) v2(201.76,40.79) v2(202.07,71.49) v2(202.07,70.86) v2(202.07,70.22) v2(202.07,69.59) v2(202.57,125.49) v2(202.7,71.49) v2(202.7,70.86) v2(202.7,70.22) v2(202.7,69.59) v2(203.13,39.23) v2(203.34,71.49) v2(203.34,70.86) v2(203.34,70.22) v2(203.34,69.59) v2(203.57,40.28) v2(203.69,56.35) v2(203.97,70.86) v2(203.97,70.22) v2(203.97,69.59) v2(204.3,125.49) v2(204.98,39.14) v2(206.03,125.49) v2(207.68,13.58) v2(207.76,125.49) v2(209.2,9.52) v2(209.48,125.49) v2(209.76,13.5) v2(210.36,13.52) v2(210.93,9.52) v2(211.21,125.49) v2(211.62,29.81) v2(211.97,53.08) v2(212.64,54.79) v2(212.61,51.43) v2(212.66,9.52) v2(212.99,125.31) v2(213.09,123.59) v2(213.09,121.86) v2(213.09,120.13) v2(213.09,118.4) v2(213.09,116.68) v2(213.09,114.95) v2(213.09,113.22) v2(213.09,111.5) v2(213.09,109.77) v2(213.09,108.04) v2(213.09,106.31) v2(213.09,104.59) v2(213.09,102.86) v2(213.09,101.13) v2(213.09,99.41) v2(213.09,97.68) v2(213.09,95.95) v2(213.09,94.22) v2(213.09,92.5) v2(213.09,90.77) v2(213.09,89.04) v2(213.09,87.32) v2(213.09,85.59) v2(213.09,83.86) v2(213.09,82.13) v2(213.14,80.51) v2(213.34,78.04) v2(213.55,76.39) v2(214.08,73.6) v2(214.13,10.91) v2(214.16,50.86) v2(214.26,55.36) v2(214.39,9.52) v2(214.67,71.47) v2(214.77,10.91) v2(215.33,69.36) v2(215.68,51.49) v2(215.71,43.68) v2(215.71,43.07) v2(215.71,42.46) v2(215.78,54.6) v2(216.11,9.52) v2(216.19,67.17) v2(216.29,43.68) v2(216.29,43.07) v2(216.29,42.46) v2(216.42,52.95) v2(216.88,43.68) v2(216.88,43.07) v2(217.08,65.29) v2(217.84,9.52) v2(217.97,63.57) v2(219.01,61.79) v2(218.96,36.77) v2(219.13,33.66) v2(219.54,36.77) v2(219.57,9.52) v2(219.72,33.67) v2(220.23,59.96) v2(220.53,55.92) v2(220.61,53.66) v2(220.99,57.95) v2(221.29,9.52) v2(222.11,51.88) v2(223.02,9.52) v2(223.16,43.65) v2(224.32,51.43) v2(224.75,9.52) v2(225.61,44.72) v2(225.61,44.08) v2(226.25,44.69) v2(226.25,44.08) v2(226.48,9.52) v2(226.55,51.96) v2(226.83,47.36) v2(226.83,46.73) v2(226.83,44.67) v2(226.83,44.08) v2(228.2,9.52) v2(228.31,51.53) v2(228.55,36.37) v2(229.93,50.41) v2(229.93,9.52) v2(231.68,49.29) v2(231.66,9.52) v2(233.39,9.52) v2(233.72,48.12) v2(235.11,9.52) v2(235.34,11.17) v2(235.47,47.23) v2(235.98,11.17) v2(236.84,9.52) v2(237.47,46.37) v2(237.75,16.44) v2(237.75,15.86) v2(237.75,11.17) v2(238.39,11.17) v2(238.59,16.88) v2(238.57,9.52) v2(239.23,16.88) v2(239.63,45.58) v2(240.29,9.52) v2(241.84,44.92) v2(242.02,9.52) v2(243.65,44.49) v2(243.75,9.52) v2(245.3,44.16) v2(245.48,9.52) v2(246.97,43.91) v2(247.2,9.52) v2(248.85,43.7) v2(248.93,9.52) v2(250.45,15.61) v2(250.56,43.6) v2(250.66,9.52) v2(250.89,35.65) v2(252.28,43.58) v2(252.38,9.52) v2(252.82,35.68) v2(252.82,15.99) v2(252.79,15.41) v2(252.82,14.82) v2(253.12,14.21) v2(253.4,15.41) v2(253.4,14.82) v2(253.48,16.58) v2(253.45,15.99) v2(253.76,17.11) v2(253.76,14.21) v2(253.98,15.41) v2(253.98,14.82) v2(254.06,43.65) v2(254.11,9.52) v2(254.34,17.14) v2(254.86,39.93) v2(254.84,38.83) v2(255.84,9.52) v2(256.02,43.81) v2(257.11,39.36) v2(257.13,38.31) v2(257.24,18.63) v2(257.24,18.02) v2(257.24,17.41) v2(257.24,16.83) v2(257.57,9.52) v2(257.74,44.03) v2(259.18,36.98) v2(259.16,36.33) v2(259.18,35.21) v2(259.29,38.28) v2(259.29,9.52) v2(259.55,44.34) v2(260.79,15.56) v2(261.02,9.52) v2(261.27,44.74) v2(261.38,15.59) v2(262.09,20.23) v2(262.09,18.79) v2(262.09,17.34) v2(262.75,9.52) v2(263.08,45.25) v2(263.53,20.23) v2(263.53,18.79) v2(263.53,17.34) v2(263.53,15.48) v2(263.51,14.9) v2(264.47,9.52) v2(264.78,45.79) v2(264.98,20.23) v2(264.98,18.79) v2(264.98,17.34) v2(265.69,15.48) v2(266.2,9.52) v2(266.33,15.48) v2(266.43,46.42) v2(267.93,9.52) v2(268.21,47.18) v2(269.66,9.52) v2(269.8,17.57) v2(270.09,48.12) v2(270.42,17.57) v2(271.21,22.22) v2(271.38,9.52) v2(271.87,22.06) v2(271.94,49.16) v2(272.69,22.37) v2(273.11,9.52) v2(273.39,20.36) v2(273.95,50.46) v2(274.84,9.52) v2(275.93,51.91) v2(275.98,38.85) v2(276.57,9.52) v2(276.69,40.24) v2(277.89,53.56) v2(278.22,33.09) v2(278.29,9.52) v2(278.85,33.06) v2(279.44,33.06) v2(279.35,26.72) v2(279.35,24.76) v2(279.59,36.24) v2(279.59,35.14) v2(279.71,55.34) v2(280.02,9.52) v2(280.91,33.09) v2(281.31,26.72) v2(281.31,22.79) v2(281.34,57.11) v2(282.09,35.75) v2(282.69,36.35) v2(282.69,35.16) v2(282.79,58.89) v2(283.12,103.44) v2(283.28,35.75) v2(283.28,26.72) v2(283.28,22.79) v2(283.5,107.82) v2(283.75,111.7) v2(284.03,60.65) v2(284.17,109.53) v2(284.26,106.16) v2(284.29,101.77) v2(284.41,112.99) v2(284.62,52.77) v2(284.62,50.84) v2(284.9,45.81) v2(285,62.14) v2(285.05,114.11) v2(285.38,100.04) v2(285.4,49.69) v2(285.61,34.89) v2(285.91,110.23) v2(285.89,105.59) v2(286.01,115.94) v2(286.01,44.69) v2(286.01,43.58) v2(286.12,64.13) v2(286.3,54.05) v2(286.56,48.77) v2(286.65,52.24) v2(286.98,65.83) v2(287.13,45.81) v2(287.13,44.69) v2(287.13,43.58) v2(287.16,56.22) v2(287.16,54.14) v2(287.18,39.06) v2(287.36,35.12) v2(287.56,109.59) v2(287.55,106.21) v2(287.83,96.8) v2(287.82,67.68) v2(287.89,116.78) v2(288.03,48.82) v2(288.21,107.88) v2(288.53,42.76) v2(288.59,94.8) v2(288.66,69.93) v2(288.71,39.18) v2(289.2,92.78) v2(289.16,71.64) v2(289.62,73.35) v2(289.65,91.13) v2(289.67,42.76) v2(290.04,89.06) v2(290,75.02) v2(289.95,49.85) v2(290.28,117.27) v2(290.27,87.51) v2(290.28,76.7) v2(290.46,85.89) v2(290.51,78.63) v2(290.52,48.37) v2(290.56,84.41) v2(290.69,122.82) v2(290.69,121.1) v2(290.69,119.37) v2(290.66,82.26) v2(290.66,80.38) v2(290.84,9.44) v2(291.22,43.12) v2(291.25,42.43) v2(291.4,123.43) v2(291.78,48.55) v2(291.78,47.95) v2(291.81,47.36) v2(292.02,44.29) v2(291.96,28.06) v2(292.01,27.42) v2(292.01,26.84) v2(292.42,81.23) v2(293.05,7.43) v2(293.35,123.43) v2(293.55,81.22) v2(293.91,58.23) v2(294.01,55.62) v2(293.96,38.89) v2(293.96,37.04) v2(294.8,5.68) v2(295.08,81.27) v2(295.23,69.46) v2(295.54,123.43) v2(295.69,4.82) v2(296.55,3.93) v2(296.89,81.27) v2(297.14,36.74) v2(297.11,24.93) v2(297.16,69.48) v2(297.16,57.85) v2(297.47,1.62) v2(297.57,123.43) v2(298,85.33) v2(298.33,64.58) v2(299.6,123.43) v2(299.65,64.63) v2(299.92,85.33) v2(299.88,22.62) v2(300.01,58.66) v2(300.11,38.47) v2(300.26,1.51) v2(300.92,85.33) v2(301,23.15) v2(301.05,44.16) v2(301.25,123.43) v2(301.3,38.47) v2(301.74,58.66) v2(301.69,22.29) v2(301.99,1.51) v2(302.4,119.12) v2(302.57,38.47) v2(302.65,79.85) v2(302.65,77.69) v2(302.65,75.66) v2(302.65,73.73) v2(302.65,71.77) v2(302.65,69.38) v2(302.65,68.01) v2(302.73,65.34) v2(302.73,23.15) v2(302.78,44.16) v2(302.85,85.33) v2(303.16,117.47) v2(303.29,120.89) v2(303.46,58.66) v2(303.72,1.51) v2(304.17,81.91) v2(304.56,123.48) v2(304.73,41.49) v2(304.81,121.53) v2(304.81,116.96) v2(304.78,65.42) v2(304.76,40.55) v2(305.44,1.51) v2(305.8,81.91) v2(306.33,117.59) v2(306.46,120.89) v2(306.49,40.27) v2(306.56,42.2) v2(306.97,119.12) v2(307.22,60.7) v2(307.22,58.69) v2(307.27,62.5) v2(307.48,91.58) v2(307.5,90.77) v2(307.5,89.04) v2(307.5,87.32) v2(307.5,85.59) v2(307.63,83.86) v2(307.93,63.82) v2(307.88,5.88) v2(307.88,4.74) v2(307.88,3.24) v2(307.88,1.51) v2(307.98,122.11) v2(308.75,114.7) v3(9.08,23.66) v3(35.37,14.65) v3(48.04,34.41) v3(62.72,67.11) v3(83.58,16.83) v3(89.49,120.08) v3(112.18,124.53) v3(113.17,7.7) v3(121.8,124.62) v3(126.12,126.23) v3(133.89,124.04) v3(142.38,66.54) v3(150.3,101.11) v3(159.34,107.99) v3(174.97,16.37) v3(177.3,57.24) v3(184.03,44.49) v3(187.13,29.98) v3(187.33,79.16) v3(200.43,59.01) v3(201.89,73.09) v3(216.52,41.27) v3(223.07,37.35) v3(228.36,48.45) v3(254.9,14.52) v3(266.61,42.1) v3(272.65,21.25) v3(280.31,46.88) v3(296.91,41.19)
