# Allegro board Dell Inspiron 15 Gaming 7566 Compal LA-D991P BCV00 Rev1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEG_HTX_GRX_N13: length 8.1
  BOTTOM w0.076: UH1.A23 127.94,89.86 127.85,89.78 127.85,89.65 127.94,89.56 128.42,89.56 128.57,89.72 129.16,89.72 129.18,89.73 129.19,89.73
  BOTTOM w0.102: 129.19,89.73 129.45,89.73 129.57,89.86 v4(130.34,89.86) 131.65,89.86 132.18,90.39 132.22,90.39 132.97,91.14 134.41,91.14 CH10.1
PEG_HTX_GRX_N14: length 10.6
  BOTTOM w0.076: 128.76,90.26 128.74,90.26 128.72,90.24 128.51,90.24 128.4,90.35 128.1,90.35 127.92,90.53 127.92,90.68 127.67,90.93 127.19,90.93 UH1.C24
  BOTTOM w0.102: 128.76,90.26 129.08,90.26 129.37,90.55 131.26,90.55 v4(132.34,91.63) 132.86,92.15 133.37,92.15 133.39,92.18 133.99,92.18 134.01,92.15 135.94,92.15 CH8.1
PEG_HTX_GRX_N15: length 8.3
  BOTTOM w0.076: 129.4,91.27 129.38,91.27 129.36,91.25 128.5,91.25 128.39,91.14 127.94,91.14 127.85,91.23 127.85,91.35 127.94,91.44 UH1.A25
  BOTTOM w0.102: 129.4,91.27 130.33,91.27 130.74,91.68 130.77,91.68 132.26,93.17 v4(133.23,93.17) 134.41,93.17 CH6.1
PEG_HTX_GRX_P0: length 10.2
  BOTTOM w0.076: 129.18,79.04 129.17,79.04 129.15,79.06 128.54,79.06 128.43,79.16 127.22,79.16 127.04,79.35 127.04,79.51 126.92,79.63 UH1.C10
  BOTTOM w0.102: 129.18,79.04 130.01,79.04 130.04,79.01 130.64,79.01 130.66,79.04 132.18,79.04 133.4,77.82 134.68,77.82 134.79,77.71 v4(135.32,77.71) 135.95,77.71 CH35.1
PEG_HTX_GRX_P1: length 8
  BOTTOM w0.076: 129.01,80.18 128.99,80.18 128.97,80.17 128.54,80.17 128.48,80.1 127.95,80.1 127.85,80.2 127.85,80.33 127.94,80.41 UH1.A11
  BOTTOM w0.102: 129.01,80.18 132.39,80.18 v4(132.74,79.83) 133.6,78.97 134.44,78.97 CH33.1
PEG_HTX_GRX_P2: length 10
  BOTTOM w0.076: 129.04,80.62 129.02,80.62 129,80.64 128.53,80.64 128.43,80.74 127.22,80.74 127.04,80.92 127.04,81.08 126.92,81.2 UH1.C12
  BOTTOM w0.102: CH31.1 135.94,79.76 133.54,79.76 132.69,80.62 v4(131.66,80.62) 130.53,80.62 130.51,80.59 129.91,80.59 129.89,80.62 129.04,80.62
PEG_HTX_GRX_P3: length 7.8
  BOTTOM w0.076: UH1.A13 127.94,81.99 127.85,81.9 127.85,81.78 127.96,81.67 128.47,81.67 128.54,81.74 129.3,81.74 129.32,81.76 129.34,81.76
  BOTTOM w0.102: 129.34,81.76 130.75,81.76 130.77,81.74 v4(132.39,81.74) 133,81.74 133.39,81.35 133.43,81.35 133.77,81 134.44,81 CH29.1
PEG_HTX_GRX_P4: length 9.9
  BOTTOM w0.076: UH1.C14 126.92,82.78 127.04,82.66 127.04,82.5 127.22,82.31 128.41,82.31 128.52,82.19 129.41,82.19 129.43,82.17 129.45,82.17
  BOTTOM w0.102: CH27.1 135.94,81.79 133.77,81.79 133.39,82.17 131.6,82.17 131.57,82.15 130.93,82.15 130.9,82.17 v4(129.89,82.17) 129.45,82.17
PEG_HTX_GRX_P5: length 7.6
  BOTTOM w0.076: UH1.A15 127.94,83.56 127.85,83.48 127.85,83.35 127.97,83.24 128.41,83.24 128.57,83.39 129.12,83.39 129.14,83.41 129.16,83.41
  BOTTOM w0.102: 129.16,83.41 133.63,83.41 133.66,83.38 133.68,83.38 134.01,83.05 134.45,83.05 CH25.1
PEG_HTX_GRX_P6: length 9.7
  BOTTOM w0.076: 129.11,83.77 129.09,83.77 129.07,83.78 128.53,83.78 128.46,83.86 127.25,83.86 127.04,84.07 127.04,84.23 126.92,84.35 UH1.C16
  BOTTOM w0.102: 129.11,83.77 130.14,83.77 130.23,83.86 v4(130.9,83.86) 132.66,83.86 132.68,83.84 133.44,83.84 133.46,83.86 133.86,83.86 133.9,83.82 135.94,83.82 CH23.1
PEG_HTX_GRX_P7: length 7.5
  BOTTOM w0.076: 129.21,84.93 129.19,84.93 129.18,84.91 128.49,84.91 128.39,84.81 127.97,84.81 127.85,84.93 127.85,85.05 127.94,85.14 UH1.A17
  BOTTOM w0.102: CH21.1 134.41,85.04 133.55,85.04 133.44,84.93 131.06,84.93 131.06,84.93 v4(129.96,84.93) 129.21,84.93
PEG_HTX_GRX_P8: length 10
  BOTTOM w0.076: 129.42,85.36 129.41,85.36 129.39,85.38 128.62,85.38 128.53,85.47 128.03,85.47 127.88,85.61 127.29,85.61 127.19,85.71 127.19,85.89 127.31,86 127.48,86 UH1.B18
  BOTTOM w0.102: CH19.1 135.94,85.85 133.43,85.85 v4(133.12,85.55) 132.94,85.36 131.85,85.36 131.83,85.34 131.23,85.34 131.21,85.36 129.42,85.36
PEG_HTX_GRX_P9: length 7.7
  BOTTOM w0.076: UH1.B19 127.57,86.71 127.69,86.59 127.69,86.43 127.87,86.25 128.56,86.25 128.67,86.36 129.18,86.36 129.19,86.34 129.21,86.34
  BOTTOM w0.102: CH17.1 134.43,86.86 133.43,86.86 133.01,86.43 132.97,86.43 132.88,86.34 v4(130.31,86.34) 129.21,86.34
PEG_HTX_GRX_P10: length 10
  BOTTOM w0.076: 129.04,87.19 129.02,87.19 129,87.18 127.32,87.18 127.2,87.29 127.2,87.41 127.29,87.5 UH1.B20
  BOTTOM w0.102: 129.04,87.19 129.93,87.19 130.18,87.44 v4(131.53,87.44) 132.34,87.44 132.99,88.09 133.49,88.09 133.52,88.12 134.12,88.12 134.14,88.09 135.94,88.09 CH15.1
PEG_HTX_GRX_P11: length 7.9
  BOTTOM w0.076: UH1.B21 127.57,88.29 127.69,88.17 127.69,88.01 127.9,87.8 128.46,87.8 128.64,87.98 129.68,87.98 129.7,87.96 129.72,87.96
  BOTTOM w0.102: 129.72,87.96 129.99,87.96 130.01,87.93 130.61,87.93 130.64,87.96 132.11,87.96 v4(132.72,88.56) 133.05,88.89 134.43,88.89 CH13.1
PEG_HTX_GRX_P12: length 10.2
  BOTTOM w0.076: 129.31,88.72 129.3,88.72 129.28,88.7 128.6,88.7 128.53,88.78 127.29,88.78 127.2,88.86 127.2,88.99 127.29,89.08 UH1.B22
  BOTTOM w0.102: 129.31,88.72 129.47,88.72 129.9,89.14 131.08,89.14 131.11,89.17 131.7,89.17 131.73,89.14 131.99,89.14 132.97,90.12 v4(133.61,90.12) 135.94,90.12 CH11.1
PEG_HTX_GRX_P13: length 8.1
  BOTTOM w0.076: UH1.B23 127.57,89.86 127.69,89.74 127.69,89.58 127.87,89.4 128.49,89.4 128.64,89.55 129.16,89.55 129.18,89.53 129.19,89.53
  BOTTOM w0.102: CH9.1 134.26,90.72 134.05,90.93 133.05,90.93 v4(132.13,90.02) 131.77,89.65 130.66,89.65 130.64,89.63 130.04,89.63 130.01,89.65 129.65,89.65 129.53,89.53 129.19,89.53
PEG_HTX_GRX_P14: length 10.6
  BOTTOM w0.076: 128.76,90.06 128.75,90.06 128.73,90.08 128.44,90.08 128.33,90.19 128.04,90.19 127.82,90.4 127.72,90.4 127.56,90.24 127.34,90.24 127.22,90.36 127.22,90.52 127.35,90.65 UH1.B24
  BOTTOM w0.102: CH7.1 135.94,91.95 v4(133.69,91.95) 132.95,91.95 132.72,91.72 132.72,91.68 132.29,91.26 132.26,91.26 131.34,90.35 129.46,90.35 129.17,90.06 128.76,90.06
PEG_HTX_GRX_P15: length 8.3
  BOTTOM w0.076: 129.4,91.07 129.38,91.07 129.36,91.08 128.57,91.08 128.46,90.97 127.87,90.97 127.69,91.16 127.69,91.32 127.57,91.44 UH1.B25
  BOTTOM w0.102: 129.4,91.07 130.45,91.07 v4(130.69,91.31) 132.35,92.97 132.91,92.97 132.93,92.94 133.53,92.94 133.56,92.97 134.41,92.97 CH5.1
PEG_RCOMP: length 8.6
  BOTTOM w0.203: UH1.G2 124.44,74.21 124.7,74.21 125.01,73.89 125.01,73.61 125.3,73.33 125.96,73.33
  BOTTOM w0.254: 125.96,73.33 126.74,72.55 126.74,69.7 v1(125.75,68.71) RH24.2
PEX_TERMP: length 4.7
  BOTTOM w0.102: RV50.2 150.7,99.05 v1(152.26,99.05) 154.33,99.05 UV1.AP29
PEX_TSTCLK_OUT: length 2.7
  TOP w0.102: v2(158.28,96.54) 158.28,96.74 157.85,97.17 157.85,97.98 RV47.2
  BOTTOM w0.102: v2(158.28,96.54) 158.65,96.91 UV1.AJ26
PEX_TSTCLK_OUT#: length 2
  TOP w0.102: v2(158.33,97.27) 158.15,97.27 158.05,97.37 158.05,97.89 RV47.1
  BOTTOM w0.102: UV1.AK26 157.96,96.91 v2(158.33,97.27)
PG_+1.05VSP: length 7.2
  TOP w0.254: v2(229.47,42.51) 229.5,42.53 229.5,42.84 PR801.1 230.18,42.92 PR800.1
  BOTTOM w0.203: v2(229.47,42.51) 229.21,42.24 226.51,42.24 v1(225.77,42.99) 225.56,43.2 PU800.9
PIRQA#: length 6.8
  BOTTOM w0.076: UH2.AW17 171.31,24.27 171.6,24.27 171.84,24.03 171.84,23.57 171.76,23.49 171.76,21.9 171.32,21.46 171.32,20.68 171.69,20.31 171.69,19.78 171.46,19.55 RH90.1
PLTRST_CPU#: length 188.4
  IN2 w0.127: v2(86.34,98.29) 86.37,98.31 86.37,101.89 90.14,105.67 100.8,105.67 101.6,104.87 104.96,104.87 105.67,105.58 131.3,105.58 134.53,102.35 134.53,101.25 139.84,95.94 139.84,84.46 146.01,78.29 146.01,73.11 146.8,72.33 146.8,70.99 146.52,70.71 146.52,63.34 140.4,57.22 140.4,47 142.82,44.57 147.72,44.57 150.36,47.21 170.12,47.21 170.93,48.02 177.8,48.02 181.27,44.55 181.27,42.03 185.71,37.6 185.71,35.52 184.95,34.76 183.88,34.76 182.53,33.42 v2(182.53,31.94)
  BOTTOM w0.076: 181.46,30.63 181.37,30.53 181.37,30.27 181.24,30.14 180.87,30.14 179.88,29.16 178.76,29.16 178.64,29.28 178.64,29.28 178.62,29.29 178.62,29.29 178.43,29.48 UH2.AK2
  BOTTOM w0.102: UH1.BP35 88.88,98.26 88.52,97.89 87.93,97.89 87.87,97.83 86.65,97.83 86.34,98.14 v2(86.34,98.29) ; v2(182.53,31.94) 182.53,31.7 181.46,30.63
POWER_SW#_MB: length 179.6
  TOP w0.102: JAPS.11 178.18,12.42 178.06,12.54 v2(178.06,12.59) v3(178.06,13.43) ; JPW.3 203.1,34.1 203.23,33.98 204.41,33.98 204.8,34.36 204.82,34.36 204.89,34.43 205.66,34.43 206.1,34.43 206.25,34.28 206.69,34.28 v2(206.93,34.53)
  IN2 w0.127: 222.13,28.18 221.7,28.62 221.35,28.62 220.32,27.58 220.32,24.94 216.49,21.11 214.65,21.11 213.04,22.72 207.91,22.72 207.4,22.22 199.83,22.22 197.55,19.93 195.21,19.93 194.57,19.29 192.07,19.29 191.49,18.71 187.93,18.71 186.93,17.71 183.59,17.71 180.78,14.9 180.73,14.9 178.42,12.59 v2(178.06,12.59) ; 222.13,28.18 222.13,28.26 222.56,28.69 239.95,28.69 240.7,29.44 247.67,29.44 247.67,29.44 247.79,29.44 250.34,31.99 258.18,31.99 258.65,31.53 258.65,31.11 258.92,30.83 259.58,30.83 260.75,31.99 268.03,31.99 274.15,38.12 278.47,38.12 280.17,39.82 287.33,39.82 288.3,40.78 289.46,40.78 290.63,41.95 290.63,45 292.69,47.06 292.69,48.43 291.58,49.55 291.58,57.27 290.28,58.56 290.28,60.67 291.17,61.56 v2(291.17,62.8) ; 222.13,28.18 v2(222.13,28.13)
  IN3 w0.127: v2(222.13,28.13) 222.13,28.39 221.55,28.97 220.17,28.97 219.96,28.97 218.79,30.14 218.45,30.14 216.64,31.94 209.51,31.94 209.51,31.95 v2(206.93,34.53)
  BOTTOM w0.102: v2(291.17,62.8) 291.7,62.27 SW5.1 ; v2(222.13,28.13) 221.75,28.51 RE47.2
POWER_SW_IN#: length 6.1
  TOP w0.102: v2(222.39,30.47) 222.25,30.61 UE1.127 222.25,32.54 221.7,33.09 v1(221.09,33.09)
  BOTTOM w0.102: RE47.1 CE12.1 222.64,30.22 v2(222.39,30.47) 222.51,30.6 RE31.2
PQ703_S:
  vias: v2(34.93,18.53) v2(34.93,17.9) v2(34.93,17.26) v2(35.57,18.53) v2(35.57,17.9) v2(35.57,17.26) v2(36.2,18.53) v2(36.2,17.9) v2(36.2,17.26) v2(36.84,18.53) v2(36.84,17.9) v2(36.87,17.24) v2(37.47,18.53) v2(37.47,17.9)
PROC_DETECT#: length 3.4
  TOP w0.102: RH89.1 155.05,35.21 155.48,34.79 156.17,34.79 156.68,34.28 v2(157.03,34.28)
  BOTTOM w0.102: v2(157.03,34.28) 157.15,34.16 157.3,34.16 UH2.Y44
PS_ID: length 247
  TOP w0.102: v2(14.64,14.39) 14.74,14.5 14.74,16.7 v3(15.29,17.25) 17.03,18.99 17.03,26.23 PR101.2 16.72,27.42 PR102.2 ; v2(223.56,14.52) 223.56,14.72 223.05,15.23 UE1.36
  IN2 w0.127: v2(60.21,17.07) 60.62,16.66 61.67,16.66 63.23,18.23 92.52,18.23 94.13,16.62 109.49,16.62 111.41,14.69 117.04,14.69 118.43,16.09 119.59,16.09 120.09,16.59 143.23,16.59 143.84,17.2 145.5,17.2 148.39,14.31 150.66,14.31 152.22,12.75 152.22,11.86 153.72,10.36 158.95,10.36 161.02,12.44 166.91,12.44 171.81,7.53 180.58,7.53 182.39,9.34 183.38,9.34 186.59,12.55 187.7,12.55 187.92,12.78 187.92,13.38 188.1,13.55 188.44,13.55 190.11,15.22 192.96,15.22 193.4,15.65 198.32,15.65 199.27,16.6 208.73,16.6 210.06,15.27 215.22,15.27 216.51,16.55 222.06,16.55 223.56,15.05 v2(223.56,14.52)
  IN3 w0.127: v2(14.64,14.39) 14.77,14.53 15.32,14.53 15.57,14.29 15.57,14.05 16.32,13.3 16.97,13.3 18.34,11.93 21.47,11.93 24.77,8.63 48.46,8.63 50.01,10.18 50.01,10.18 55.25,15.41 58.04,15.41 59.28,16.65 59.79,16.65 v2(60.21,17.07)
PSID: length 6.1
  TOP w0.102: PR114.1 12.97,34.15 v2(12.96,34.14) v3(12.27,34.14)
  BOTTOM w0.102: v2(12.96,34.14) 12.8,34.14 12.03,34.91 JADP10.4
PSID-1: length 3.2
  TOP w0.102: v1(11.62,27.61) PR103.2 11.62,25.67 PR105.1 11.88,25.41 PQ101.2
PSID-2: length 5.9
  TOP w0.102: PQ100.2 PR104.1 13.4,25.76 PQ101.1 14.4,23.4 v1(13.95,22.95)
PTP_DIS#: length 132.5
  TOP w0.102: v2(140.98,18.15) 140.98,17.78 RE123.2 v3(142.63,17.34) ; RE57.2 239.35,26.99 240.4,25.95 240.4,25.44 240.56,25.28 241.55,25.28 v2(241.82,25.01)
  IN2 w0.127: v2(140.98,18.15) 141.53,17.6 142.72,17.6 143.33,18.21 147.08,18.21 149.81,15.48 151.27,15.48 154.95,11.8 158.35,11.8 160,13.45 166.44,13.45 167.33,13.45 170.12,10.66 172.22,10.66 174.18,8.7 180.15,8.7 181.24,9.79 181.24,11.24 182.81,12.82 185.25,12.82 187,14.57 188.02,14.57 189.74,16.28 192.49,16.28 192.98,16.78 198.01,16.78 199.64,18.41 206.58,18.41 206.77,18.6 207.59,18.6 208.16,18.02 209.92,18.02 211.66,16.28 213.66,16.28 214.97,17.59 215.58,17.59 216.2,18.21 220.75,18.21 221.4,17.57 224.05,17.57 225.06,16.56 227.98,16.56 233.56,22.14 234.53,22.14 236.29,20.38 238.06,20.38 238.72,21.04 238.72,22.21 239.65,23.14 240.45,23.14 241.46,24.15 241.46,24.66 v2(241.82,25.01)
  BOTTOM w0.102: JTP.3 137.76,18.26 138.14,18.63 140.5,18.63 v2(140.98,18.15)
PTP_DIS#_R: length 2.7
  TOP w0.102: RE57.1 238.19,27.8 v1(237.5,27.8) 236.85,27.8 236.79,27.74 UE1.90
PTP_INT#: length 111.8
  TOP w0.102: DH1.1 168.28,20.13 v2(168.31,20.11) ; QE13.1 135.98,17.26 137.17,18.46 139.19,18.46 139.29,18.56 140.3,18.56 141.53,19.79 v2(141.53,19.97) ; v2(211.8,25.03) 211.8,21.86 212.3,21.35 212.3,20.95 211.8,20.44 211.8,19.89 211.62,19.72 211.62,17.69 212.86,16.45 213.29,16.45 214.23,15.51 217.61,15.51 218.22,16.12 219.32,16.12 219.8,16.6 220.71,16.6 221.27,16.04 221.27,13.81 RE61.1
  IN2 w0.127: v2(211.8,25.03) 203.3,25.03 202.33,24.07 193.51,24.07 192.49,23.05 190.28,23.05 188.4,21.17 185.46,21.17 184.16,19.88 182.2,19.88 179.95,17.62 178.58,17.62 177.65,18.56 173.57,18.56 172.75,19.38 170.1,19.38 169.38,20.11 v2(168.31,20.11)
  IN3 w0.127: v2(168.31,20.11) 168.31,20.41 168.01,20.72 168.01,21.33 167.55,21.78 163.76,21.78 163.14,21.16 163.14,20.85 162.84,20.54 160.67,20.54 160.34,20.21 158.77,20.21 158.43,20.55 156.49,20.55 155.2,21.83 154.63,21.83 153.63,22.84 153.63,23.04 153.63,23.04 153.63,24.45 152.54,25.54 150.61,25.54 145.04,19.97 v2(141.53,19.97)
PTP_INT#_EC: length 4.4
  TOP w0.102: RE61.2 221.83,12.44 222.62,13.22 RE53.1 222.62,14.29 v1(222.37,14.53) 221.85,15.05 UE1.33
PTP_INT#_R: length 13.6
  TOP w0.102: QE13.3 v3(132.04,16.61) 131.66,16.61 131.05,16.01 v2(131.05,15.45) 131.04,15.43 131.04,14.76 131.79,14.01 RE87.2
  BOTTOM w0.102: v2(131.05,15.45) 131.05,16.23 131.84,17.01 136.28,17.01 136.76,16.53 JTP.4
PWM1_GT: length 68.3
  IN3 w0.254: v2(68.29,92.29) 68.18,92.29 64.88,95.6 64.88,105.4 63.08,107.2 63.08,123.47 64.16,124.55 84.8,124.55 88,127.75 88,130.44 90.15,132.6 90.97,132.6 v2(91.07,132.71)
  BOTTOM w0.203: PU1100.12 68.29,92.2 v2(68.29,92.29)
  BOTTOM w0.254: PR1501.1 v2(91.07,132.71)
PWM1_VCORE: length 97.3
  IN3 w0.254: v2(75.63,94.05) 75.57,94.1 75.57,94.58 74.48,95.67 69.89,95.67 68.49,97.07 68.49,106.86 67.68,107.67 67.68,112.59 70.04,114.95 70.04,120.72 71.3,121.99 85.89,121.99 89.04,125.14 89.72,125.14 90.76,126.18 90.76,127.6 93.23,130.06 93.63,130.06 95.38,131.82 101.5,131.82 101.68,131.64 104,131.64 105.45,133.09 109.92,133.09 111.13,131.87 121.42,131.87 v2(122.29,132.73)
  BOTTOM w0.102: v2(75.63,94.05) v1(76.08,94.5)
  BOTTOM w0.203: PU1100.25 74.77,92.78 75.63,93.64 v2(75.63,94.05)
  BOTTOM w0.254: PR1401.1 121.42,132.02 122.1,132.71 122.26,132.71 v2(122.29,132.73)
PWM2_GT: length 19.6
  BOTTOM w0.203: PU1100.13 69.31,92.83 68.67,92.83
  BOTTOM w0.254: 68.67,92.83 68.03,92.83 66.43,94.43 v1(66.43,97.55) 66.43,99.84 67.38,100.79 67.38,101.13 68.78,102.53 68.78,106.36 67.37,107.77 PR1513.1
PWM2_VCORE: length 87.1
  IN3 w0.254: v2(75.27,92.52) 75.22,92.52 74.79,92.95 74.79,94.5 74.23,95.06 69.22,95.06 67.98,96.31 67.98,106.64 67.17,107.46 67.17,112.8 69.53,115.16 69.53,120.93 71.09,122.49 85.68,122.49 90.03,126.84 90.03,129.2 90.54,129.71 90.89,129.71 91.75,130.57 93.42,130.57 95.17,132.32 101.71,132.32 101.89,132.15 102.37,132.15 102.65,132.43 102.65,132.86 103.39,133.59 110.25,133.59 v2(111.01,132.83)
  BOTTOM w0.203: PU1100.26 75.16,91.37 75.45,91.66 75.45,91.89 75.27,92.07 v2(75.27,92.52)
  BOTTOM w0.254: PR1415.1 v2(111.01,132.83)
PWM3_VCORE: length 80.3
  IN3 w0.254: v2(75.8,92.22) 75.52,91.94 74.18,91.94 73.82,92.29 69.78,92.29 65.41,96.66 65.41,112.49 68.51,115.59 68.51,121.35 70.67,123.51 85.26,123.51 89.01,127.26 89.01,130.02 90.58,131.59 93,131.59 v2(94.19,132.78)
  BOTTOM w0.203: v2(75.8,92.22) 75.83,92.19 75.83,91.56 75.24,90.97 PU1100.27
  BOTTOM w0.254: PR1429.1 100.47,132.78 98.59,132.78 98.26,133.11 94.52,133.11 v2(94.19,132.78)
PWM_SA: length 113.1
  IN3 w0.254: v2(130.69,128.9) 131.25,129.45 131.25,130.5 130.79,130.95 130.24,130.95 129.33,131.87 123.28,131.87 122.77,131.36 110.92,131.36 110.19,132.1 105.17,132.1 104.21,131.13 101.47,131.13 101.29,131.31 95.59,131.31 95.01,130.72 95.01,129.48 94.68,129.15 93.03,129.15 91.86,127.98 91.86,126.55 89.93,124.63 89.25,124.63 86.1,121.48 71.51,121.48 70.55,120.51 70.55,114.74 68.18,112.38 68.18,107.88 69,107.07 69,104.61 70.49,103.11 70.49,98.89 71.86,97.53 73.92,97.53 76.36,95.08 76.36,92.05 75.04,90.73 75.04,87.98 75.42,87.59 v2(75.63,87.59)
  BOTTOM w0.102: v2(130.69,128.9) 130.18,129.4 v1(130.18,130.7)
  BOTTOM w0.203: v2(75.63,87.59) 75.45,87.77 PU1100.35
  BOTTOM w0.254: PR1532.2 v2(130.69,128.9)
REGN_CHG: length 35
  TOP w0.254: v2(46.54,41.47) 46.54,41.56 PR205.1
  IN1 w0.508: v2(26.58,39.77) 26.98,39.77 27.8,38.95 27.8,36.06 28.38,35.47 29.47,35.47 30.19,34.76 30.19,33.9 30.52,33.57 v2(30.52,32.25)
  IN2 w0.254: v2(26.58,39.77) 26.73,39.61 38.06,39.61 39.53,38.14 43.53,38.14 46.24,40.85 46.24,41.16 v2(46.54,41.47)
  BOTTOM w0.254: v2(26.58,39.77) 25.59,39.77 25.08,39.26 PR316.1
REMOTE1+: length 120
  TOP w0.254: v2(138.21,77.26) 138.31,77.16 142.04,77.16 145.22,80.33 CT83.1 146.63,80.52 QT1.2 148.3,79.87 QT1.1
  BOTTOM w0.254: UT1.2 62.87,49.26 63.15,49.54 63.3,49.54 63.74,49.98 CT82.1 64.03,49.71 64.5,49.71 67.76,52.97 136.18,52.97 137.98,54.78 137.98,62.77 133.23,67.52 133.23,73.78 133.61,74.16 133.61,75.73 134.9,77.02 137.15,77.02 137.29,77.16 138.11,77.16 v2(138.21,77.26)
REMOTE1-: length 117.4
  TOP w0.254: v2(138.21,76.67) 138.31,76.77 142.2,76.77 144.84,79.42 CT83.2 146.63,79.22 QT1.3
  BOTTOM w0.254: UT1.3 63.08,48.76 63.39,49.06 CT82.2 64.03,49.33 64.66,49.33 67.92,52.59 136.34,52.59 138.36,54.62 138.36,62.93 133.61,67.68 133.61,73.62 133.99,74 133.99,75.57 135.06,76.64 137.31,76.64 137.45,76.77 138.11,76.77 v2(138.21,76.67)
REMOTE2+: length 190.5
  IN1 w0.254: v2(210.02,21.63) 210.02,21.66 209.81,21.45 199.88,21.45 199.2,20.77 198.56,20.77 197.67,19.88 194.45,19.88 193.96,19.4 186.82,19.4 186.59,19.17 179.38,19.17 178.69,19.86 175.62,19.86 175.27,20.21 173.15,20.21 172.87,19.93 171.81,19.93 171.43,19.55 170.12,19.55 168.68,20.99 168.45,20.99 168.06,21.38 168.06,21.67 167.54,22.19 162.67,22.19 161.37,20.89 156.77,20.89 155.43,19.55 154.38,19.55 153.36,18.53 151.08,18.53 150.24,19.37 143.63,19.37 142.14,20.87 139.63,20.87 139.18,20.42 101.3,20.42 101.04,20.16 98.87,20.16 98.47,20.56 71.59,20.56 71.28,20.87 70.14,20.87 69.61,21.4 69.61,21.96 68.41,23.15 68.41,26.76 67.12,28.06 67.12,37.92 65.62,39.42 65.62,44.59 v2(65.72,44.69)
  BOTTOM w0.254: v2(210.02,21.63) 210.02,21.35 210.24,21.13 210.24,19.3 210.24,19.29 210.25,19.29 211.78,17.75 211.78,15.46 CT84.1 213.82,14.36 QT3.2 214.68,14.81 QT3.1 ; UT1.4 62.89,48.26 63.01,48.14 63.7,48.14 CT85.1 64.03,47.93 65.1,47.93 65.62,47.42 65.62,44.82 65.72,44.72 v2(65.72,44.69)
REMOTE2-: length 188.1
  IN1 w0.254: v2(210.6,21.63) 210.6,21.53 210.14,21.07 200.03,21.07 199.33,20.36 198.69,20.36 197.83,19.5 194.6,19.5 194.12,19.01 186.98,19.01 186.75,18.79 179.23,18.79 178.53,19.48 175.46,19.48 175.11,19.83 173.31,19.83 173.03,19.55 171.97,19.55 171.59,19.17 169.96,19.17 168.52,20.61 168.29,20.61 167.68,21.22 167.68,21.52 167.38,21.81 162.82,21.81 161.53,20.51 156.93,20.51 155.58,19.17 154.54,19.17 153.52,18.15 150.92,18.15 150.08,18.99 143.48,18.99 141.98,20.49 139.79,20.49 139.34,20.04 101.45,20.04 101.19,19.78 98.71,19.78 98.31,20.18 71.43,20.18 71.12,20.49 69.98,20.49 69.22,21.24 69.22,21.8 68.03,23 68.03,26.6 66.74,27.9 66.74,37.76 65.24,39.26 65.24,44.57 v2(65.11,44.69)
  BOTTOM w0.254: v2(65.11,44.69) 65.24,44.82 65.24,47.26 64.95,47.55 64.03,47.55 CT85.2 63.29,47.76 UT1.5 ; v2(210.6,21.63) 210.63,21.61 210.63,19.45 212.16,17.91 212.16,15.99 CT84.2 213.85,15.28 QT3.3
RF_+1.35VS_VGAP: length 3.3
  BOTTOM w0.102: PR905.1 v1(138.06,109.79)
  BOTTOM w0.254: PU900.5 139.68,111.08 139.46,110.86 138.69,110.86 138.64,110.91 PR905.1
RING2: length 8.9
  TOP w0.203: v2(280.3,19.8) 280.55,20.06 280.55,20.84 280.71,21.01 HDA1.17
  IN1 w1.016: 282.15,18.71 282.86,19.42 288.73,19.42
  vias: v2(280.3,19.19) v2(289.37,18.91) v2(289.75,19.4)
RING2_R: length 16.2
  TOP w0.102: v3(307.97,19.5) 308.44,19.03 JHP1.3
  BOTTOM w1.016: 295.16,19.9 295.97,19.9 296.76,20.69 305.87,20.69 JHP1.3
ROM_CS: length 1.2
  TOP w0.102: T97.1 176.39,79.34 v2(176.72,79.67)
  BOTTOM w0.102: UV1.H6 176.29,80.1 v2(176.72,79.67)
ROM_SCLK: length 17.6
  TOP w0.102: RV159.1 v2(189.99,75.05) RV162.2 v1(191.09,75.73)
  IN2 w0.127: v2(176.71,78.08) 176.9,78.08 178.09,76.89 178.63,76.89 179.84,75.68 189.36,75.68 v2(189.99,75.05)
  BOTTOM w0.102: v2(176.71,78.08) 176.29,78.5 UV1.H4
ROM_SI: length 13.3
  TOP w0.102: RV157.1 RV160.2 184.86,76.29 184.86,78.03 183.55,79.34 v3(180.91,79.34) 177.17,79.34 176.75,78.92 v2(176.74,78.92)
  BOTTOM w0.102: v2(176.74,78.92) 176.35,79.31 UV1.H5
ROM_SO: length 16.1
  TOP w0.102: v2(175.9,81.44) 176.26,81.08 176.26,80.43 176.54,80.15 176.89,80.15 176.9,80.15 178.93,80.15 179.33,79.75 183.9,79.75 v3(184.46,79.18) 185.93,77.71 185.93,76.24 RV161.2 RV158.1
  BOTTOM w0.102: UV1.H7 175.9,81.4 v2(175.9,81.44)
RUNPWROK: length 4
  TOP w0.102: UE1.48 227.85,15.31 227.59,15.05 227.24,15.05 v2(226.93,14.75)
  BOTTOM w0.102: v2(226.93,14.75) 226.4,14.21 RE62.2 v1(226.4,12.89)
SATA_LED_EN: length 240.2
  TOP w0.102: RE108.2 217.46,17.34 218.4,17.34 219.01,17.94 219.01,18.18 219.37,18.54 UE1.30 220.98,18.54 221.37,18.15 221.37,17.14 221.5,17.01 221.5,14.72 v2(221.7,14.52)
  IN2 w0.127: v2(221.7,14.52) 221.4,14.82 219.97,14.82 219.14,15.66 216.88,15.66 215.59,14.38 209.69,14.38 208.38,15.69 199.61,15.69 198.55,14.62 197.7,14.62 195.69,12.6 190.98,12.6 188.73,10.35 185.79,10.35 184.39,8.96 184.39,7.58 183.4,6.59 171.46,6.59 166.55,11.51 161.67,11.51 157.57,7.41 155.09,7.41 149.74,12.75 149.74,13.77 149.46,14.05 148.29,14.05 146.35,15.99 142.69,15.99 142.35,16.33 126.03,16.33 125.1,15.41 124.13,15.41 123.71,15.83 118.54,15.83 117.09,14.38 111.37,14.38 109.4,16.35 94.04,16.35 92.42,17.97 63.34,17.97 61.77,16.41 60.24,16.41 v2(59.57,17.07)
  IN3 w0.127: v2(59.57,17.07) 59.34,17.07 57.93,15.67 55.14,15.67 49.9,10.43 48.35,8.88 24.87,8.88 21.57,12.18 18.44,12.18 16.64,13.99 v2(16.29,13.99)
  BOTTOM w0.102: v2(16.29,13.99) 16.39,14.09 QE21.5 QE21.6
SATA_PRX_DTX_N1B: length 57.4
  TOP w0.102: v2(194.32,31.59) 194.57,31.34 194.57,31.22 193.28,29.94 193.28,19.63 192.59,18.95 192.59,17.45 CS25.1
  IN1 w0.114: v2(194.32,31.59) 194.32,31.61 194.58,31.35 194.58,31.2 194.46,31.07 192.19,31.07 191.27,31.99 189.82,31.99 186.55,35.27 184.85,35.27 183.7,36.41 181.87,36.41 181.43,36.86 178.37,36.86 178.1,37.12 177.07,37.12 172.09,42.11 161.16,42.11 160.87,41.82 160.23,41.82 159.96,41.55 159.96,41.24 v2(159.78,41.06)
  BOTTOM w0.102: v2(159.78,41.06) 159.82,41.06 159.99,41.23 159.99,41.46 160.3,41.78 160.3,41.92 UH2.D39
SATA_PRX_DTX_N1B_RC: length 4.2
  TOP w0.102: v2(192.34,13.8) 192.68,14.14 192.68,14.85 192.66,14.87 192.66,15.5 192.68,15.52 192.68,15.7 CS25.2
  BOTTOM w0.102: v2(192.34,13.8) 192.17,13.97 JHDD1.8
SATA_PRX_DTX_P1B: length 57.5
  TOP w0.102: v2(195.08,31.59) 194.77,31.28 194.77,31.14 193.48,29.85 193.48,19.55 192.8,18.86 192.8,17.39 CS26.1
  IN1 w0.114: v2(195.08,31.59) 195.08,31.61 194.8,31.33 194.8,31.11 194.55,30.85 192.1,30.85 191.18,31.77 189.73,31.77 186.46,35.04 184.76,35.04 183.61,36.19 181.78,36.19 181.34,36.63 178.28,36.63 178.01,36.9 176.98,36.9 171.99,41.89 161.26,41.89 160.96,41.59 160.32,41.59 160.18,41.46 160.18,41.24 v2(160.36,41.06)
  BOTTOM w0.102: v2(160.36,41.06) 160.19,41.23 160.19,41.38 160.64,41.82 160.89,41.82 UH2.E37
SATA_PRX_DTX_P1B_RC: length 4.2
  TOP w0.102: v2(192.94,13.8) 192.88,13.86 v4(192.88,15.15) 192.88,15.94 CS26.2
  BOTTOM w0.102: JHDD1.7 192.67,13.17 192.67,13.53 v2(192.94,13.8)
SATA_PRX_SSDTX_N0A: length 58.1
  IN3 w0.076: v2(163.44,40.53) 163.44,40.31 163.55,40.21 163.87,40.21 164.06,40.02 164.06,38.21 164.26,38 164.77,38 164.96,37.82 165.63,37.82 165.68,37.86 165.69,37.86
  IN3 w0.127: 165.69,37.86 166.02,37.86 167.04,38.87 169.99,38.87 170.09,38.77 173.06,38.77 173.69,38.14 173.69,36.21 174.28,35.62 177.68,35.62 178.37,36.31 180.05,36.31 181.77,34.58 198.69,34.58 199.22,34.05 199.22,33.39 199.83,32.78 200.16,32.78 200.39,33.01 200.39,33.14 200.26,33.26 v2(200.03,33.26)
  BOTTOM w0.101: v2(163.44,40.53) 163.89,40.95 UH2.G31
  BOTTOM w0.102: v2(200.03,33.26) 200.23,33.07 200.23,32.8 200.51,32.53 201.53,32.53 203.67,30.39 203.67,29.58 205.37,27.88 205.37,27.23 205.56,27.03 205.56,27 205.99,26.58 206.02,26.58 206.28,26.32 JNGFF2.43
SATA_PRX_SSDTX_P0A: length 58
  IN3 w0.076: 165.69,37.61 165.68,37.61 165.63,37.65 164.89,37.65 164.7,37.84 164.2,37.84 163.89,38.14 163.89,39.95 163.8,40.04 163.69,40.04 v2(163.46,39.81)
  IN3 w0.127: 165.69,37.61 166.13,37.61 167.14,38.62 169.88,38.62 169.98,38.52 172.96,38.52 173.44,38.04 173.44,36.11 174.18,35.37 177.78,35.37 178.47,36.06 179.94,36.06 181.67,34.33 198.58,34.33 198.97,33.95 198.97,33.29 199.73,32.53 200.26,32.53 200.64,32.9 200.64,33.11 v2(200.8,33.26)
  BOTTOM w0.101: v2(163.46,39.81) 163.87,40.19 UH2.H31
  BOTTOM w0.102: v2(200.8,33.26) 200.55,33.26 200.44,33.15 200.44,32.89 200.59,32.73 201.61,32.73 203.87,30.47 203.87,29.67 205.57,27.96 205.57,27.31 v4(205.94,26.95) 206.36,26.52 207.47,26.52 207.76,26.82 JNGFF2.41
SATA_PTX_DRX_N1B: length 55.2
  TOP w0.102: CS27.1 190.89,17.44 190.89,18.67 192.87,20.65 192.87,30.6 192.74,30.73 192.74,31.28 v2(193.05,31.59)
  IN1 w0.114: v2(159.97,42.58) 160.16,42.78 160.16,42.93 160.63,43.4 170.52,43.4 170.65,43.27 172.09,43.27 175.42,39.94 177.04,39.94 177.31,39.68 179.08,39.68 180.97,37.79 181.44,37.79 182.16,37.07 185.69,37.07 190.1,32.65 192.35,32.65 192.92,32.08 192.92,31.72 v2(193.05,31.59)
  BOTTOM w0.089: UH2.B38 160.61,43.16 160.02,42.58 v2(159.97,42.58)
SATA_PTX_DRX_N1B_RC: length 4.2
  TOP w0.102: v2(191.09,13.79) 190.68,14.21 190.68,14.37 190.88,14.57 v4(190.88,15.18) 190.88,15.79 CS27.2
  BOTTOM w0.102: JHDD1.10 191.17,13.87 v2(191.09,13.79)
SATA_PTX_DRX_P1B: length 55.1
  TOP w0.102: v2(192.29,31.59) 192.54,31.34 192.54,30.65 192.67,30.51 192.67,20.73 190.69,18.75 190.69,17.4 CS28.1
  IN1 w0.114: v2(192.29,31.59) 192.47,31.59 192.7,31.82 192.7,31.99 192.25,32.43 190.01,32.43 185.6,36.85 182.07,36.85 181.34,37.57 180.87,37.57 178.99,39.45 177.21,39.45 176.95,39.72 175.33,39.72 172,43.05 170.55,43.05 170.43,43.18 160.72,43.18 160.39,42.84 160.39,42.35 160.5,42.24 v2(160.68,42.24)
  BOTTOM w0.089: v2(160.68,42.24) 160.62,42.17 160.47,42.17 160.38,42.26 160.38,42.51 160.56,42.69 UH2.C38
SATA_PTX_DRX_P1B_RC: length 4.3
  TOP w0.102: CS28.2 190.68,15.85 190.68,15.5 190.65,15.47 190.65,14.89 190.68,14.86 190.68,14.65 190.47,14.45 v2(190.47,13.82)
  BOTTOM w0.102: v2(190.47,13.82) 190.67,13.62 JHDD1.11
SATA_PTX_SSDRX_N0A: length 50.4
  IN1 w0.114: v2(196.13,40.98) 195.81,40.98 195.69,40.87 195.69,40.72 195.87,40.53 196.42,40.53 196.6,40.71 196.6,41.52 196.18,41.93 196.18,43.03 192.43,46.78 189.38,46.78 187.5,48.66 181.9,48.66 180.7,47.46 176.51,47.46 176.35,47.62 171.7,47.62 170.48,46.4 168.85,46.4 168.36,45.91 163.92,45.91 163.59,45.58 163.59,45.43 v2(163.92,45.1)
  BOTTOM w0.076: v2(163.92,45.1) 163.92,44.83 164.01,44.74 164.01,43.89 164.26,43.64 164.26,43.12 163.94,42.8 UH2.C31
  BOTTOM w0.102: CD53.1 199.06,36.26 199.06,37.7 197.04,39.72 197.04,40.43 196.69,40.78 196.33,40.78 v2(196.13,40.98)
SATA_PTX_SSDRX_N0A_C: length 17.1
  BOTTOM w0.102: CD53.2 199.09,35 198.97,34.87 198.97,34.47 198.99,34.45 198.99,32.76 199.7,32.04 200.24,32.04 200.27,32.07 200.87,32.07 200.89,32.04 201.43,32.04 203.26,30.22 203.26,29.39 204.94,27.71 204.94,25.95 205.81,25.08 v4(206.36,25.08) 207.47,25.08 207.71,25.32 JNGFF2.47
SATA_PTX_SSDRX_P0A: length 50.4
  IN1 w0.114: v2(196.05,40.12) 196.24,40.31 196.51,40.31 196.82,40.62 196.82,41.61 196.4,42.03 196.4,43.12 192.52,47 189.47,47 187.59,48.88 181.81,48.88 180.61,47.68 176.6,47.68 176.44,47.84 171.6,47.84 170.39,46.63 168.76,46.63 168.27,46.14 163.83,46.14 163.36,45.67 163.36,45.13 v2(163.33,45.1)
  BOTTOM w0.076: UH2.B31 163.96,43.11 164.02,43.11 164.09,43.19 164.09,43.57 163.84,43.82 163.84,44.68 163.79,44.72 163.62,44.72 163.33,45.02 v2(163.33,45.1)
  BOTTOM w0.102: CD51.1 198.85,36.26 198.85,37.62 196.83,39.64 196.83,40.35 196.61,40.58 196.24,40.58 196.05,40.39 v2(196.05,40.12)
SATA_PTX_SSDRX_P0A_C: length 17.1
  BOTTOM w0.102: CD51.2 198.76,34.74 198.76,34.39 198.79,34.36 198.79,32.67 199.62,31.84 v4(200.57,31.84) 201.35,31.84 203.06,30.13 203.06,29.3 204.73,27.63 204.73,25.86 205.73,24.87 206.04,24.87 206.06,24.85 206.66,24.85 206.68,24.87 207.62,24.87 207.67,24.82 JNGFF2.49
SDZ_MUTE#: length 25
  TOP w0.102: v2(269.88,25.34) 269.88,25.21 270.09,25.01 270.09,23.54 270.16,23.46 270.16,22.62 269.28,21.73 269.28,20.87 267.77,19.37 266.69,19.37 266.34,19.72 266.34,20.3 265.92,20.72 260.44,20.72 260.11,21.05 v2(259.39,21.05)
  BOTTOM w0.102: D2.1 272.65,27.09 271.44,25.87 270.39,25.87 269.88,25.36 v2(269.88,25.34) ; RA74.2 259.24,20.89 v2(259.39,21.05) 259.57,21.05 259.98,20.64 259.98,20.03 260.16,19.85 260.16,19.52 260.64,19.04 UA2.29
SIO_EXT_SCI#: length 91.2
  TOP w0.076: 162.72,23.54 162.8,23.61 162.8,24.04 162.72,24.12 162.72,24.78 162.14,25.36 162.14,26.1 162.82,26.79 162.87,26.79 163.2,27.12 163.74,27.12 163.94,26.91 163.94,26.79 v2(164.42,26.3)
  TOP w0.102: 162.72,23.54 162.72,22.82 161.66,21.76 161.66,21.36 161.42,21.12 161.27,21.12 v1(160.37,20.22) RH10.2 ; UE1.66 234.99,18.14 234.44,18.69 234.44,19.39 234.03,19.8 233.69,19.8 232.75,20.74 232.75,21.66 232.01,22.39 v2(232.01,23.15)
  IN1 w0.114: v2(164.42,26.3) 165.31,25.42 166.31,25.42 166.38,25.49 166.97,25.49 167.8,24.65 168.18,24.65 169.5,23.33 170.95,23.33 171.08,23.46 171.49,23.46 171.52,23.49 173.87,23.49 174.38,22.98 178.19,22.98 178.5,22.67 180.2,22.67 180.28,22.59 185.22,22.59 185.57,22.94 192.49,22.94 193.43,23.88 197.95,23.88 198.64,24.57 212.4,24.57 212.47,24.65 219.51,24.65 221.1,23.05 230.34,23.05 230.64,23.35 231.82,23.35 v2(232.01,23.15)
  BOTTOM w0.089: UH2.AV29 165.05,25.68 v2(164.42,26.3)
SIO_EXT_SMI#: length 80.6
  TOP w0.102: RH110.1 155.08,32.42 155.61,31.89 156.35,31.89 156.58,31.66 v1(156.91,31.66) 157.6,30.97 159.24,30.97 v2(159.62,30.58) ; v2(216.32,28.21) 217.05,28.21 217.71,27.55 218.32,27.55 219.33,26.54 UE1.10
  IN2 w0.127: v2(216.32,28.21) 213.93,28.21 211.11,25.39 203.21,25.39 202.16,24.34 193.38,24.34 192.36,23.33 189.92,23.33 188.11,21.53 185.46,21.53 184.06,20.13 181.62,20.13 180.63,19.14 179.89,19.14 179.7,18.95 174.37,18.95 173.9,19.42 173.07,19.42 172.85,19.64 170.36,19.64 169.45,20.54 168.28,20.54 167.4,21.43 166.79,21.43 166.05,22.17 164.7,22.17 163.74,23.13 163.74,24.6 163.1,25.24 162.39,25.24 161.85,25.77 161.6,25.77 161.3,26.08 161.3,26.46 160.9,26.86 159.4,26.86 159.09,27.17 159.09,27.63 159.32,27.85 159.32,28.59 158.84,29.07 158.84,29.53 159.55,30.24 159.55,30.51 v2(159.62,30.58)
  BOTTOM w0.089: UH2.AF41 159.13,31.08 159.36,30.66 v2(159.62,30.58)
SIO_EXT_WAKE#: length 91.5
  TOP w0.102: UE1.116 226.65,32.89 v2(226.48,33.06) 226.48,33.47 v1(226.96,33.95)
  IN2 w0.127: v2(226.48,33.06) 225.84,32.43 223,32.43 221.62,31.05 216.76,31.05 216.72,31.02 216.72,30.53 216.66,30.53 216.4,30.27 216.4,29.9 216.77,29.52 216.77,27.98 214.82,26.03 214.17,26.03 212.36,24.22 211.24,24.22 210.7,24.76 203.47,24.76 202.51,23.79 193.66,23.79 192.64,22.77 190.36,22.77 188.51,20.92 186.8,20.92 185.48,19.6 182.89,19.6 180.66,17.37 178.44,17.37 177.64,18.18 173.53,18.18 172.58,19.13 169.98,19.13 169.56,19.55 167.21,19.55 166.88,19.88 166.88,20.17 166.48,20.56 166.48,21.38 165.94,21.91 164.59,21.91 162.85,23.66 162.85,24.81 162.67,24.98 162.28,24.98 161.75,25.52 161.42,25.52 161.27,25.67 160.08,25.67 159.57,26.18 159.57,26.33 158.03,27.87 156.03,27.87 v2(155.64,28.26)
  BOTTOM w0.102: RH91.2 155,28.9 v2(155.64,28.26) 156.14,28.26 156.76,27.64 UH2.AN44
SIO_PWRBTN#: length 69.9
  TOP w0.102: v2(227.75,25.13) 227.75,22.01 227.97,21.78 227.97,18.48 229.45,17.01 UE1.52
  IN1 w0.114: v2(173.64,26.15) 173.85,26.36 175.34,26.36 176.27,25.43 177.28,25.43 177.46,25.61 179.49,25.61 180.05,25.06 181.63,25.06 182.23,25.66 187.08,25.66 188.11,24.63 188.45,24.63 189.16,23.92 192.06,23.92 192.99,24.84 197.47,24.84 198.89,26.27 202.3,26.27 202.86,25.7 210.54,25.7 210.74,25.7 211.29,26.25 212.65,26.25 213.27,25.63 220.3,25.63 221.21,24.72 223.35,24.72 224.34,25.71 227.14,25.71 227.72,25.14 227.75,25.14 v2(227.75,25.13)
  BOTTOM w0.089: UH2.AT13 173.46,26.33 v2(173.64,26.15)
  BOTTOM w0.102: v2(227.75,25.13) 227.29,24.67 v1(227.29,24.3)
SIO_RCIN#: length 73
  TOP w0.102: v2(228.34,25.14) 227.98,24.78 227.98,22.1 228.2,21.88 228.2,18.58 229.85,16.93 UE1.53 ; v1(180.05,25.82) 180.27,25.59 v2(180.68,25.59) RH87.1
  IN1 w0.114: v2(171.31,25.82) 171.59,25.82 172.33,26.56 173.59,26.56 173.62,26.6 175.81,26.6 176.1,26.32 179.02,26.32 179.14,26.44 179.84,26.44 v2(180.68,25.59) 180.98,25.9 187.18,25.9 188.2,24.88 188.66,24.88 188.94,24.6 190.15,24.6 190.65,25.1 197.38,25.1 198.79,26.51 202.4,26.51 202.96,25.94 210.64,25.94 211.19,26.49 212.75,26.49 213.37,25.87 220.4,25.87 221.31,24.96 223.25,24.96 224.24,25.95 227.52,25.95 v2(228.34,25.14)
  BOTTOM w0.102: UH2.AT17 170.98,26.15 v2(171.31,25.82)
SIO_SLP_A#: length 16.3
  TOP w0.102: v2(171.7,21.08) 171.7,21.16 172.32,21.78 172.91,21.78 173.26,21.43 173.26,20.36 172.55,19.65 172.55,18.73 172.88,18.41 173.01,18.27 173.01,17.75 172.38,17.12 172.38,15.42 173.26,14.54 173.8,14.54 v1(175.17,13.17) 175.17,12.33 175.68,11.82 JAPS.6
  BOTTOM w0.076: UH2.BC15 172.06,22.66 171.92,22.52 171.92,22.5 171.92,21.79 171.66,21.53 171.66,21.12 v2(171.7,21.08)
SIO_SLP_S0#: length 27.9
  TOP w0.102: v2(165.98,21.25) 165.42,20.69 164.47,20.69 163.81,20.03 163.81,18.48 164.86,17.44 164.86,16.04 165.91,14.99 167.92,14.99 169.76,13.15 v3(170.34,13.15) 170.98,13.15 172.79,11.34 172.79,10.98 173.45,10.31 179.84,10.31 180.18,10.66 JAPS.15
  BOTTOM w0.076: v2(165.98,21.25) 166.13,21.4 166.13,22.25 166.09,22.29 166.09,22.67 UH2.BC26
SIO_SLP_S3#: length 445.7
  TOP w0.102: QV2.2 67.46,26.44 v2(67.27,26.63) ; JAPS.2 173.68,11.98 v2(174.12,12.42) 174.12,13.05 173.31,13.86 171.99,13.86 171.32,14.53 171.32,19.38 171.29,19.41 171.29,19.46 170.95,19.8 170.95,21.25 171.62,21.91 171.8,21.91 172.12,22.24 172.6,22.24 172.7,22.34 172.7,24.37 v2(172.58,24.5) ; v2(68.95,53.46) 71.71,53.46 75.02,50.16 75.02,48.61 74.69,48.28 UZ16.3 ; UE1.23 218.71,21.34 218.28,20.92 217.36,20.92 CE74.1 217.13,20.67 216.7,20.23 214.43,20.23 213.69,19.5 213.07,19.5 212.53,20.04 212.53,21.48 212.18,21.83 212.18,24.58 212.51,24.91 v2(212.51,25.09) ; v2(186.55,23.59) 186.55,23.49 187.04,22.99 187.04,22.61 187.31,22.34 UZ21.2 ; PR702.1 62.75,62.8 63.26,62.3 v2(63.74,62.3) ; UZ1.5 216.06,13.34 216.09,13.38 216.39,13.38 216.85,12.92 v2(216.85,12.74) 216.65,12.54 215.52,12.54 UZ1.3
  IN1 w0.114: v2(100.59,18.66) 100.1,19.15 98.61,19.15 98.02,19.74 71.25,19.74 70.94,20.05 69.8,20.05 68.79,21.06 68.79,21.62 67.27,23.14 v2(67.27,26.63) 67.27,26.75 66.3,27.72 66.3,34.29 v2(65.92,34.66) ; v2(61.78,72.25) 62.24,72.25 62.54,72.56 62.54,77.79 62.79,78.03 62.79,79.62 v2(65.54,82.37) ; v2(186.55,23.59) 186.95,23.18 192.39,23.18 193.33,24.12 197.85,24.12 199.27,25.54 201.92,25.54 202.48,24.98 211.04,24.98 211.56,25.49 212.1,25.49 v2(212.51,25.09) 212.68,24.91 219.74,24.91 221.32,23.33 230.28,23.33 230.54,23.59 232.69,23.59 232.85,23.75 234.64,23.75 236.48,25.59 242.07,25.59 242.26,25.41 244.04,25.41 244.05,25.4 246.86,25.4 248.27,26.8 251.61,26.8 253.08,25.33 255.29,25.33 256.43,26.47 257.26,26.47 257.41,26.62 261.13,26.62 v2(261.22,26.53)
  IN2 w0.127: v2(100.59,18.66) 101.23,19.29 145.91,19.29 147.99,21.38 149.79,21.38 150.78,20.39 150.78,19.14 153.87,16.06 158.63,16.06 159.81,14.87 167.96,14.87 170.63,12.21 172.96,12.21 173.19,11.98 173.68,11.98 v2(174.12,12.42) ; v2(186.55,23.59) 186.47,23.59 184.91,25.15 180.66,25.15 179.48,23.98 177.66,23.98 176.54,22.85 176.06,22.85 175.6,23.31 173.41,23.31 172.58,24.15 v2(172.58,24.5) ; v2(132.22,101.59) 132.22,101.8 129.25,104.77 122.29,104.77 121.42,103.9 116.24,103.9 115.47,104.68 110.45,104.68 109.33,103.56 100.97,103.56 100.29,104.24 90.64,104.24 88.96,102.56 88.96,99.4 88.63,99.06 88.63,98.44 87.79,97.6 87.79,96.31 84.77,93.29 84.77,86.15 v2(83.68,85.05)
  IN3 w0.127: v2(65.92,34.66) 66.11,34.85 66.11,44.15 66.53,44.57 66.53,51.04 v2(68.95,53.46)
  BOTTOM w0.102: QA1.2 258.37,26.53 v2(261.22,26.53) ; v2(83.68,85.05) 82.86,84.24 79.61,84.24 78.55,83.17 78.55,81.98 75,78.44 70.93,78.44 67.43,81.93 65.99,81.93 v2(65.54,82.37) ; v2(172.58,24.5) 172.43,24.65 UH2.AW15 ; v2(68.95,53.46) 65.58,53.46 63.73,55.31 63.73,59.21 63.36,59.58 63.36,61.91 v2(63.74,62.3) 63.74,62.72 62.01,64.46 62.01,72.02 v2(61.78,72.25) ; UZ9.4 132.64,101.17 v2(132.22,101.59) ; v2(212.51,25.09) 212.15,25.44 211.63,25.44 211.39,25.2 211.39,23.38 210.83,22.82 210.09,22.82 209.59,22.32 209.59,20.9 209.81,20.67 209.81,18.9 210.73,17.98 210.73,17.24 211.35,16.61 211.35,14.92 212.66,13.6 213.14,13.6 214.21,12.54 216.65,12.54 v2(216.85,12.74)
  BOTTOM w0.114: v2(100.59,18.66) 100.59,18.35 99.76,17.52 PR511.1
SIO_SLP_S4#: length 250.2
  TOP w0.102: v2(143.49,20.87) 143.82,20.87 147.2,17.49 v2(147.2,17.39) 147.27,17.39 148.98,15.67 149.93,15.67 150.38,16.12 RZ102.1 ; v2(230.24,36.55) 230.24,37.9 231.01,38.67 234.94,38.67 238.93,34.69 239.15,34.69 241.08,32.75 241.08,31.57 241.69,30.96 241.69,30.04 243.32,28.41 243.32,27.57 243.49,27.4 243.49,23.63 243.75,23.36 243.75,21.02 243.43,20.69 238.17,20.69 238.06,20.58 238.06,19.56 238.08,19.54 238.08,18.76 237.87,18.54 UE1.67 ; JAPS.5 175.18,11.88 174.91,12.14 174.91,12.9 173.5,14.32 173.17,14.32 172.16,15.33 172.16,17.22 172.78,17.84 172.78,18.18 171.95,19.01 v2(171.95,20.55) ; UZ15.4 129.94,98.68 v2(129.58,98.31)
  IN1 w0.114: v2(149.87,26.66) 146.91,29.62 146.91,30.63 145.22,32.32 145.22,36.48 v2(145.36,36.62)
  IN2 w0.127: v2(171.95,20.55) 171.95,20.38 172.44,19.89 172.96,19.89 173.17,19.68 174.01,19.68 174.48,19.21 179.59,19.21 179.81,19.42 180.4,19.42 181.47,20.49 183.3,20.49 183.58,20.77 183.58,21.38 184.03,21.83 188.06,21.83 190.01,23.79 192.34,23.79 193.15,24.6 202.04,24.6 203.15,25.71 210.33,25.71 215.94,31.31 221.45,31.31 222.84,32.71 225.46,32.71 227.75,34.99 229.56,34.99 230.24,35.67 v2(230.24,36.55) ; v2(145.36,36.62) 141.73,36.62 139.52,38.83 139.52,40.9 140.03,41.41 140.03,43.31 138.82,44.52 138.82,67.24 136.41,69.65 136.41,72.63 137.68,73.9 137.68,77.08 135.39,79.37 135.39,91.61 132.85,94.15 130.58,94.15 129.89,94.83 129.89,95.84 129.63,96.11 129.63,98.26 v2(129.58,98.31) ; v2(149.87,26.66) 144.08,20.87 v2(143.49,20.87)
  IN3 w0.127: v2(149.87,26.66) 150.73,25.8 152.64,25.8 153.88,24.56 153.88,22.96 154.76,22.09 155.33,22.09 156.62,20.8 158.54,20.8 158.88,20.46 160.23,20.46 160.58,20.81 161.5,20.81 162.13,21.44 162.99,21.44 163.59,22.04 170.38,22.04 171,21.42 171,20.93 171.31,20.61 171.89,20.61 v2(171.95,20.55)
  BOTTOM w0.076: UH2.BD15 172.11,22.32 172.11,21.74 172.07,21.7 172.07,20.67 v2(171.95,20.55)
  BOTTOM w0.102: PR1801.1 146.83,16.42 147.09,16.68 147.09,17.27 v2(147.2,17.39)
SIO_SLP_S5#: length 17.5
  TOP w0.102: v2(173.54,24.5) 173.47,24.43 173.34,24.43 172.98,24.07 172.98,22.15 172.85,22.01 172.22,22.01 171.89,21.69 171.71,21.69 171.23,21.21 171.23,20.74 171.7,20.27 171.7,19.96 171.62,19.88 v1(171.62,19.55) 171.62,19.22 171.54,19.14 171.54,14.63 172.09,14.09 173.41,14.09 174.68,12.82 JAPS.4
  BOTTOM w0.089: UH2.BA13 173.09,24.13 173.38,24.43 173.47,24.43 v2(173.54,24.5)
SIO_SLP_WLAN#: length 2.5
  TOP w0.102: T4934.1 173.82,27.14 173.49,26.81 173.26,26.81 v2(172.6,26.15)
  BOTTOM w0.089: v2(172.6,26.15) 173.09,25.67 UH2.AV13
SKU_ID: length 4.5
  TOP w0.102: UE1.114 227.45,33.06 v2(227.38,33.13)
  BOTTOM w0.102: CE104.1 227.47,33.21 v2(227.38,33.13) v1(227.38,32.56) ; CE104.1 RE124.2 ; CE104.1 RE125.2
SLEEVE: length 18.6
  TOP w0.203: HDA1.18 281.11,20.92 280.88,20.69 280.88,20.36 281.31,19.93
  IN2 w1.016: 297.06,14.09 293.38,14.09 291.07,16.4 290.43,16.4 287.16,19.68 282.86,19.68
  vias: v1(283.75,19.7) v2(281.19,19.78) v2(281.72,19.52) v2(298.08,14.21) v2(298.08,13.58)
SLEEVE_R: length 11
  TOP w0.102: v2(296.43,10.2) v3(296.43,9.52)
  BOTTOM w1.016: JHP1.4 307.18,7.86 298.92,7.86 298.74,8.04
SM_PG_CTRL: length 114.2
  TOP w0.102: v2(81.29,81.14) 81.9,80.53 81.9,78.2 85.71,74.39 85.71,65.23 76.3,55.82 68.04,55.82 67.35,55.13 67.34,55.13 65.97,53.76 v3(65.97,51.12) 66.18,50.92 66.18,44.34 65.9,44.06 v2(64.65,44.06)
  IN1 w0.114: v2(98.7,18.72) 97.92,19.5 71.15,19.5 70.85,19.8 68.05,19.8 66.8,21.05 66.8,26.87 66,27.67 66,33.7 65.47,34.23 65.47,34.86 66.25,35.65 66.25,37.6 64.8,39.05 64.8,43.91 v2(64.65,44.06)
  BOTTOM w0.102: v2(81.29,81.14) 81.4,81.26 RH93.2
  BOTTOM w0.114: v2(98.7,18.72) 98.7,17.53 PR509.1
  BOTTOM w0.305: UC1.4 81.42,81.81 RH93.2
SMBALERT#: length 3.8
  TOP w0.102: v2(159.26,23.54) 159.26,23.33 v1(158.24,22.31) 157.13,21.2 RH66.2
  BOTTOM w0.089: v2(159.26,23.54) 159.25,23.49 UH2.BB41
SMBCLK: length 11.1
  TOP w0.102: v2(155.71,25.24) 155.71,24.68 155.1,24.07 154.38,24.07 153.53,23.22 152.35,23.22 151.94,22.82 151.94,22.56 150.76,21.37 QH4.6 149.49,21.37 RH21.2
  BOTTOM w0.089: v2(155.71,25.24) 155.71,25.57 155.84,25.69 156.5,25.69 157.05,25.14 157.41,25.14 UH2.AW44
SMBDATA: length 6.2
  TOP w0.102: QH4.3 152.52,22.72 RH22.2 153.69,22.72 v1(154.66,23.7) 154.71,23.75 157.23,23.75 157.32,23.66 v2(157.69,23.66)
  BOTTOM w0.089: UH2.BB43 157.86,23.51 157.71,23.66 v2(157.69,23.66)
SML0_SMBCLK: length 5.3
  BOTTOM w0.089: 155.33,24.61 157.37,24.61 157.64,24.33 UH2.AY44
  BOTTOM w0.102: RH62.2 v1(154.25,24.89) 154.54,24.61 155.33,24.61
SML0_SMBDATA: length 4.9
  TOP w0.102: RH63.2 157.89,21.14 157.89,21.46 159.41,22.98 v2(160.16,22.98)
  BOTTOM w0.089: v2(160.16,22.98) 160.16,23 UH2.BB39
SML0ALERT#: length 4
  TOP w0.102: RH64.2 160.7,24.25 v2(161.52,25.06)
  BOTTOM w0.089: v2(161.52,25.06) 161.52,24.79 160.76,24.04 UH2.BA40
SML1_SMBCLK: length 7.5
  TOP w0.102: v2(155.97,24.25) 156.37,24.65 157.03,24.65 157.4,24.29 RH23.2 158.24,24.73 v2(158.24,24.92)
  BOTTOM w0.089: v2(158.24,24.92) 158.31,24.99 UH2.AW42
  BOTTOM w0.102: QH5.1 153.54,23.81 153.98,24.25 v2(155.97,24.25)
SML1_SMBDAT: length 10.2
  TOP w0.102: v2(156.35,25.24) 157.39,25.24 RH25.2
  BOTTOM w0.089: UH2.AW45 156.68,24.91 v2(156.35,25.24)
  BOTTOM w0.102: QH5.4 150.87,26.65 151.22,26.99 v1(152,26.99) 152.64,26.36 153.91,26.36 155.46,24.81 155.92,24.81 v2(156.35,25.24)
SML1ALERT#: length 3.1
  TOP w0.102: v2(165.72,25.87) 165.64,25.87 165.14,26.38 v1(165.14,26.89) 165.14,27.98 RH65.2
  BOTTOM w0.089: UH2.AT27 166.2,26.15 165.92,25.87 v2(165.72,25.87)
SNUB_1VALWP: length 1.7
  TOP w0.102: v1(255.33,10.45) 255.33,11.36 254.84,11.85 PC600.1
SNUB_3V: length 1.1
  BOTTOM w0.102: PC418.1 v1(66.96,7.61)
SNUB_5V: length 1.5
  TOP w0.102: PC419.1 v1(44.9,35.31)
SNUB_+0.95VSP: length 0.8
  BOTTOM w0.102: v3(62.58,67.67) 62.58,68.47
SNUB_+1.05VSP: length 3.3
  TOP w0.102: PC800.1 228.86,41.77 229.31,41.33 229.76,41.33 229.84,41.41 v1(230.17,41.41)
  TOP w0.254: PR802.2 227.85,41.77 PC800.1
SNUB_CHG: length 1.6
  TOP w0.102: PR315.2 v1(24.9,27.35)
SPKR: length 121.4
  TOP w0.102: RH82.2 165.49,19.55 v2(166,20.06)
  IN3 w0.127: v2(166,20.06) 166.28,20.06 167.55,18.79 170.15,18.79 171.33,17.6 171.33,17.59 178.55,17.59 179.94,18.99 181.11,18.99 181.85,19.73 186.22,19.73 188.17,21.68 189.49,21.68 190.37,22.56 198.09,22.56 199.7,24.17 204.51,24.17 205.52,25.19 210.86,25.19 211.44,24.6 214.37,24.6 216.13,22.85 220.23,22.85 221.28,21.8 231.98,21.8 233.42,23.23 236.61,23.23 237.37,23.99 239.98,23.99 240.5,24.51 251.68,24.51 252.21,25.03 260.21,25.03 v2(260.87,24.37)
  BOTTOM w0.076: v2(166,20.06) 166,20.41 166.34,20.75 166.34,21.4 166.34,21.4 UH2.BD26
  BOTTOM w0.102: v2(260.87,24.37) 261.88,25.39 267.07,25.39 267.52,24.93 270.19,24.93 270.56,24.56 270.56,23.44 270.9,23.1 271.47,23.1 271.77,22.8 272.88,22.8 273.16,22.51 D1.3
SRCCLKREQ1#: length 7.3
  BOTTOM w0.076: 168.95,19.73 168.95,21.15 168.92,21.17 168.92,21.71 168.83,21.8 168.83,21.83 168.32,22.34 168.32,23.19 168.26,23.26 168.26,23.27 168.25,23.28 168.25,23.52 168.41,23.68 168.41,24.25 168.03,24.63 UH2.AW24
  BOTTOM w0.102: RP2.8 169.42,19.26 168.95,19.73
SRCCLKREQ4#: length 5.3
  BOTTOM w0.076: UH2.BB24 167.76,23.11 167.76,22.63 167.86,22.53 167.86,22.22 167.86,22.22 167.76,22.11 167.76,21.83 168.35,21.24 v1(168.35,20.59) 168.74,20.2 168.74,19.5
  BOTTOM w0.102: 168.74,19.5 168.92,19.32 RP2.7
SRCCLKREQ5#: length 3.8
  BOTTOM w0.076: UH2.BE25 166.95,21.73 166.78,21.56 166.78,20.54 v1(166.96,20.36) 167.17,20.16 167.17,19.6 167.62,19.14
  BOTTOM w0.102: 167.62,19.14 167.92,18.85 RP2.5
SRCCLKREQ7#: length 8.3
  TOP w0.102: v2(163.43,26.71) 163.08,26.36 163.08,25.64 163.94,24.78 163.94,22.32 163.2,21.58 163.2,20.8 162.82,20.42 RP3.6
  BOTTOM w0.102: v2(163.43,26.71) 163.63,26.71 UH2.AR31
SRCCLKREQ8#: length 5.6
  BOTTOM w0.076: 162.88,20.67 163.68,21.47 163.68,22.18 163.65,22.21 163.65,22.47 UH2.BD32
  BOTTOM w0.102: RP22.7 160.75,18.72 162.68,20.65 162.87,20.65 162.88,20.67
SRCCLKREQ9#: length 6.3
  BOTTOM w0.076: 162.34,21.17 162.57,21.4 162.64,21.4 163.21,21.98 163.21,22.11 163.31,22.21 163.31,22.69 163.55,22.92 UH2.BC32
  BOTTOM w0.102: RP22.6 160.25,18.83 160.92,19.5 161.19,19.5 161.86,20.17 v1(161.86,20.41) 161.86,20.69 162.34,21.17
SRCCLKREQ10#: length 6.4
  BOTTOM w0.076: UH2.BB31 163.94,23.17 163.83,23.06 163.83,22.28 163.86,22.25 163.86,21.27 163.06,20.46
  BOTTOM w0.102: RP22.8 161.25,18.89 162.82,20.46 163.06,20.46
SRCCLKREQ11#: length 7
  BOTTOM w0.076: UH2.BC33 162.97,22.69 162.83,22.55 162.83,22.5 162.83,22.06 162.5,21.73 162.27,21.73
  BOTTOM w0.102: 162.27,21.73 161.38,20.84 161.01,20.84 159.13,18.96 158.79,18.96 158.46,18.64 RP23.8
SRCCLKREQ13#: length 9.4
  TOP w0.102: v2(158,19.14) 158,20.39 v1(158.5,20.89) 158.5,21.2 159.5,22.21 160.15,22.21 160.72,22.77 160.72,22.95 162.29,24.53 v2(162.37,24.53)
  BOTTOM w0.089: UH2.AW33 162.62,24.78 v2(162.37,24.53)
  BOTTOM w0.102: RP23.6 157.46,18.61 v2(158,19.14)
SRCCLKREQ14#: length 7.8
  BOTTOM w0.076: 161.95,21.7 161.95,22.05 162.14,22.24 162.31,22.24 162.54,22.24 162.64,22.34 162.64,22.62 162.73,22.7 162.73,23.02 162.94,23.24 UH2.BB33
  BOTTOM w0.102: RP23.7 157.96,18.5 158.73,19.27 159.16,19.27 160.97,21.07 161.33,21.07 161.95,21.7
SRCCLKREQ15#: length 5.7
  BOTTOM w0.076: UH2.BD33 163,22.3 163,22 162.57,21.57 162.44,21.57 162.36,21.49
  BOTTOM w0.102: 162.36,21.49 161.48,20.61 161.09,20.61 160.53,20.06 v1(160.53,19.73) 160.53,19.56 159.75,18.78 RP22.5
SSD_CLK_REQ#: length 64
  TOP w0.076: 163.23,23.84 163.23,23.87 162.9,24.2 162.9,25.31 162.55,25.67 v2(162.55,25.67)
  TOP w0.102: RP3.8 161.82,20.66 162.27,21.11 162.27,21.51 v1(163.33,22.57) 163.33,23.74 163.23,23.84
  IN1 w0.114: v2(162.55,25.67) 163.87,24.35 163.87,24.25 164.91,23.21 166.02,23.21 166.43,23.61 166.96,23.61 167.14,23.43 167.6,22.98 167.69,22.89 167.94,22.89 168.71,22.11 171.73,22.11 171.98,22.37 173.38,22.37 173.96,21.78 175.27,21.78 176.08,20.97 178.09,20.97 178.44,21.32 178.44,21.31 180.61,21.31 180.67,21.38 180.68,21.38 180.73,21.43 186.51,21.43 186.9,21.82 193.04,21.82 193.28,22.06 195.65,22.06 195.9,22.31 198.57,22.31 199.27,23.01 206.87,23.01 207.07,23.21 213.71,23.21 v2(213.75,23.26)
  BOTTOM w0.089: UH2.AT33 162.67,25.96 162.67,25.8 v2(162.55,25.67)
  BOTTOM w0.102: v2(213.75,23.26) 213.75,23.62 214.2,24.07 JNGFF2.52
SSD_LED#: length 236.1
  IN3 w0.127: v2(211.87,21.15) 211.47,21.15 210.99,20.67 207.55,20.67 207.18,20.3 206.02,20.3 205.17,19.45 199.9,19.45 198.19,17.73 189.03,17.73 187.36,16.06 185.23,16.06 183.76,14.58 182.56,14.58 180.77,12.78 180.77,11.91 180.28,11.42 180.28,10.31 178.96,9 175.14,9 173.43,10.71 172.32,10.71 171.92,11.11 169.93,11.11 166.73,14.32 160.53,14.32 159.14,15.71 159.14,16.93 158.62,17.45 154.57,17.45 153.93,18.09 150.7,18.09 149.87,18.91 138.23,18.91 137,17.68 116.57,17.68 114.79,15.9 110.76,15.9 109.53,17.12 100.46,17.12 100.01,17.57 62.76,17.57 61.34,16.14 59.49,16.14 58.25,14.9 55.46,14.9 50.22,9.67 50.22,9.67 47.91,7.36 25.32,7.36 21.26,11.42 17.54,11.42 v2(16.52,12.44)
  BOTTOM w0.102: v2(16.52,12.44) 18.6,14.52 RH502.2 ; JNGFF2.10 213.89,34.57 213.57,34.25 213.57,31.59 213.98,31.18 213.98,26.16 213.73,25.91 213.73,24.78 212.89,23.94 212.89,23.05 212.02,22.19 212.02,21.3 v2(211.87,21.15)
SSD_PCIE_WAKE#: length 3.6
  BOTTOM w0.102: v1(217.58,22.6) RD8.1 217.45,23.74 216.21,23.74 216.04,23.57 JNGFF2.54
STRAP0: length 10
  TOP w0.102: v2(176.01,75.61) 176.01,75.84 176.13,75.97 177.78,75.97 178.5,75.25 179.79,75.25 v3(179.87,75.33) 181.66,75.33 RV152.2 RV146.1
  BOTTOM w0.107: v2(176.01,75.61) 175.91,75.71 175.91,76.22 175.86,76.26 175.86,76.26 175.64,76.48 175.64,76.48 175.49,76.63 UV1.J2
STRAP1: length 19
  TOP w0.102: RV153.2 v2(188.22,75.05) RV147.1
  IN3 w0.127: v2(175.85,80.58) 176.29,80.15 176.29,79.15 176.32,79.11 176.32,78.76 176.29,78.72 176.29,76.72 176.51,76.49 177.4,76.49 178.8,75.1 180.85,75.1 180.9,75.05 186.6,75.05 187.08,74.56 187.73,74.56 v2(188.22,75.05)
  BOTTOM w0.102: UV1.J7 175.49,80.95 v2(175.85,80.58)
STRAP2: length 16.8
  TOP w0.102: RV154.2 v2(187.33,75.05) RV148.1
  IN2 w0.127: v2(187.33,75.05) 187.2,75.17 178.95,75.17 177.23,76.9 176.52,76.9 176.17,77.24 176.17,78.41 176.32,78.56 176.32,79.27 176.15,79.44 176.14,79.44 v2(175.85,79.74)
  BOTTOM w0.102: v2(175.85,79.74) 175.85,79.8 UV1.J6
STRAP3: length 20.4
  TOP w0.102: RV149.1 v2(189.1,75.05) RV155.2 ; v1(174.38,79.92) 174.51,79.79 v2(174.91,79.79)
  IN2 w0.127: v2(174.91,79.79) 175.48,79.22 175.48,78.5 175.9,78.08 175.9,77.15 176.73,76.32 177.43,76.32 178.83,74.92 186.57,74.92 187.08,74.41 188.47,74.41 v2(189.1,75.05)
  BOTTOM w0.102: UV1.J5 175.09,79.71 175.02,79.71 174.94,79.79 v2(174.91,79.79)
STRAP4: length 12
  TOP w0.102: v2(175.12,77.31) 176.13,76.29 177.78,76.29 178.11,75.96 178.7,75.96 178.85,76.11 179.63,76.11 179.76,75.99 v3(182.13,75.99) 182.38,75.73 RV156.2 RV150.1
  BOTTOM w0.102: UV1.J3 175.49,77.68 v2(175.12,77.31)
SUSCLK: length 79.4
  TOP w0.102: RE106.1 215.4,34.53 214.39,33.52 214.39,32.3 213.7,31.61 213.34,31.61 212.07,30.34 v2(212.07,30.23) 211.73,30.23 211.29,30.67 210.7,30.67 210.14,31.23 206.04,31.23 204.99,32.29 v1(204.1,32.29) 200.37,32.29 199.63,33.03 199.63,34.29 199.21,34.71 198.13,34.71 197.62,34.2 197.62,33.65 197.3,33.32 193.58,33.32 v2(193.2,32.94)
  IN3 w0.127: v2(193.2,32.94) 193.2,32.69 192.6,32.1 190.76,32.1 187.74,29.07 185.73,29.07 185.62,28.97 182.97,28.97 181.89,27.89 180.31,27.89 180.05,27.63 177.51,27.63 177.02,27.14 177.02,26.91 176.64,26.53 174.37,26.53 174.15,26.75 173.05,26.75 v2(172.58,27.22)
  BOTTOM w0.102: v2(193.2,32.94) 193.35,33.09 193.35,33.53 193.96,34.15 193.96,35.14 194.83,36.01 RN1.2 ; v2(212.07,30.23) 212.07,29.35 213.12,28.31 213.12,25.03 212.28,24.2 212.28,23.41 211.39,22.52 211.39,20.97 211.77,20.59 212.2,20.59 212.81,21.2 217.48,21.2 RD9.2 ; v2(172.58,27.22) 172.1,27.7 UH2.AN15
