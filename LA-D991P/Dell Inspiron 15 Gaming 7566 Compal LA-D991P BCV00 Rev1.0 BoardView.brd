# Allegro board Dell Inspiron 15 Gaming 7566 Compal LA-D991P BCV00 Rev1.0 BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+5VS on BOTTOM (solid shape): outline of 156 points within 204.66,10.27 211.32,18.41
+5VS on IN1 (solid shape): 296.58,63.74 296.58,62.98 296.2,62.6 296.2,62.59 295.75,62.14 295.48,62.14 295.01,62.61 295.01,62.91 296.02,63.92 296.4,63.92
+5VS on IN1 (solid shape): outline of 784 points within 256.09,19.4 278.06,31.95
+5VS on IN2 (solid shape): 56.8,31.38 56.8,30.42 57.02,30.2 57.02,29.24 56.74,28.96 55.47,28.96 55,29.43 55,31.46 55.18,31.64 56.55,31.64
+5VS on IN2 (solid shape): 260.03,26.1 260.03,25.06 259.9,24.93 256.83,24.93 255.43,23.54 255.43,23 255.33,22.75 255.43,22.5 255.43,20.82 255.84,20.41 256.42,20.41 256.98,20.97 257.34,20.97 257.54,20.77 257.54,19.6 257.06,19.12 255.31,19.12 254.78,19.64 253.01,19.64 252.28,20.36 252.28,23.87 254.21,25.8 255.08,25.8 255.81,26.53 259.6,26.53
+5VS on IN3 (solid shape): 258.86,26.66 259.52,26.66 259.95,26.23 259.95,25.87 259.69,25.61 257.78,25.61 257.13,26.25 257.13,27.37 257.18,27.42 258.1,27.42
+5VS on IN3 (solid shape): 247.1,38.52 247.1,37.38 246.17,37.38 246.09,37.46 243.82,37.46 243.74,37.38 243.55,37.38 242.76,36.59 239.19,36.59 238.82,36.96 238.82,37.96 239.18,38.32 245.02,38.32 245.02,38.27 245.03,38.21 245.05,38.16 245.08,38.12 245.11,38.08 245.15,38.04 245.2,38.01 245.24,37.99 245.29,37.97 245.35,37.96 245.4,37.96 245.45,37.97 245.5,37.99 245.55,38.01 245.6,38.04 245.64,38.08 245.67,38.12 245.7,38.16 245.71,38.21 245.73,38.27 245.73,38.32 245.73,38.37 245.71,38.42 245.7,38.47 245.67,38.52 245.64,38.56 245.6,38.6 245.55,38.63 245.5,38.65 245.45,38.67 245.4,38.67 245.35,38.67 245.29,38.67 245.24,38.65 245.2,38.63 245.15,38.6 245.11,38.56 245.08,38.52 245.05,38.47 245.03,38.42 245.02,38.37 245.02,38.32 239.18,38.32 239.2,38.34 243.32,38.34 244.28,39.31 246.31,39.31
+5VS on IN3 (solid shape): outline of 2642 points within 194.22,9.9 273.19,21.98
+5VS_HDD on BOTTOM (solid shape): 196.69,18.83 196.7,18.83 197.02,18.63 197.33,18.83 203.13,18.83 203.8,18.16 203.8,16.66 203.79,16.65 202.63,16.65 202.3,16.98 197.1,16.98 196.13,16.01 196.13,13.03 195.99,12.89 195.99,11.6 195.81,11.42 194.52,11.42 194.34,11.61 194.34,13.03 194.8,13.5 194.8,18.76 195.4,19.36 196.17,19.36
+19VB_1VALWP on TOP (solid shape): 255.2,18.3 255.2,17.52 253.63,17.52 252.99,18.15 252.99,18.81 253.21,19.03 254.47,19.03
+19VB_1VALWP on BOTTOM (solid shape): 254.27,20.01 254.73,20.01 254.73,20.51 255.07,20.51 255.07,20.01 255.53,20.01 255.53,20.51 255.91,20.51 255.91,18 255.43,17.52 253.78,17.52 253.65,17.64 252.53,17.64 252.02,17.14 251.83,17.14 251.39,16.7 249.97,16.7 249.87,16.8 249.87,17.85 249.56,18.15 249.56,18.58 249.68,18.7 249.68,18.93 249.74,18.99 251.17,18.99 251.34,19.17 251.34,19.93 251.47,20.06 253.43,20.06 253.88,20.51 254.27,20.51
+19VB_+0.95VSP on TOP (solid shape): 70.7,75.13 70.35,74.77 70.67,74.45 71.03,74.81 71.27,74.56 70.91,74.2 71.23,73.88 71.59,74.24 72.45,73.39 72.45,73.06 70.64,71.26 69.06,71.26 68.67,70.86 68.04,70.23 67.89,69.88 68.02,69.53 68.02,69.04 68.03,68.94 68.07,68.84 68.08,68.83 68.08,68.7 67.98,68.6 66.56,68.6 66.46,68.7 66.46,69.17 66.05,69.58 66.05,71.79 65.79,72.05 64.84,72.05 64.62,71.83 64.62,70.61 64.34,70.32 61.08,70.32 61.01,70.4 61.22,71.29 61.66,71.29 63.43,73.06 64.1,73.06 64.11,73.06 65.29,72.88 66.47,73.06 66.48,73.06 68.13,74.06 69.13,75.71 69.35,75.94 69.89,75.94
+19VB_+1.05VSP on TOP (solid shape): 225.21,50.36 225.21,49.57 225.05,49.42 225.05,46.6 224.67,46.22 222.51,46.22 222.28,46.46 222.28,47.81 222.39,47.81 222.39,50.16 222.72,50.49 225.08,50.49
+19VB_+1.05VSP on BOTTOM (solid shape): 225.05,49.39 225.05,46.83 224.19,45.96 224.19,44.83 224.11,44.76 222.65,44.76 222.58,44.83 222.58,46.02 222.35,46.25 222.35,47.78 221.5,48.63 221.5,49.52 221.62,49.65 224.8,49.65
+VCC_CORE on TOP (solid shape): outline of 2186 points within 103.13,81.52 126.63,116.02
+VCC_CORE on BOTTOM (solid shape): outline of 414 points within 110.84,81.27 122.06,83.18
+VCC_CORE on BOTTOM (solid shape): outline of 1696 points within 103.39,93.59 126.63,116.2
+VCC_CORE on IN1 (solid shape): outline of 173 points within 103.17,110.87 110.12,116.42
+VCC_CORE on IN1 (solid shape): outline of 219 points within 119.8,107.74 126.63,116.44
+VCC_CORE on IN1 (solid shape): outline of 265 points within 110.95,108.4 118.2,116.42
+VCC_CORE on IN1 (solid shape): outline of 2101 points within 107.83,81.25 122.82,101.96
+VCC_CORE on IN2 (solid shape): outline of 1035 points within 102.96,108.73 126.63,116.44
+VCC_CORE on IN2 (solid shape): outline of 2049 points within 107.83,81.25 122.82,101.96
+VCC_CORE on IN3 (solid shape): outline of 1093 points within 102.96,108.73 127.01,116.44
+VCC_CORE on IN3 (solid shape): outline of 1217 points within 107.83,87.39 120.02,101.96
+VCC_CORE on VCC: outline of 179 points within 102.83,81.52 126.76,118.61
+VCCGT on TOP (solid shape): outline of 3081 points within 83.83,81.59 108.13,117.15
+VCCGT on BOTTOM (solid shape): outline of 164 points within 93.93,81.49 106.94,83.18
+VCCGT on BOTTOM (solid shape): outline of 1981 points within 83.96,93.85 108.13,119.12
+VCCGT on IN1 (solid shape): 88.53,115.81 88.53,112.79 86.73,110.99 84.34,110.99 83.83,111.5 83.83,116.07 84.34,116.58 87.77,116.58
+VCCGT on IN1 (solid shape): 101.42,114.86 101.45,114.78 101.4,114.71 101.26,114.45 101.35,114.17 101.38,114.1 101.35,114.03 101.29,113.63 101.63,113.43 101.71,113.4 101.74,113.32 101.74,110.73 101.61,110.61 96.13,110.61 96.12,110.65 95.77,110.96 95.41,110.65 95.41,110.61 94.35,110.61 94.34,110.65 93.99,110.96 93.64,110.65 93.63,110.61 90.18,110.61 89.93,110.86 89.93,113.11 91.04,114.22 91.04,114.26 92.21,115.43 100.85,115.43
+VCCGT on IN1 (solid shape): outline of 4104 points within 85.56,81.64 109.48,101.96
+VCCGT on IN2 (solid shape): outline of 266 points within 83.45,108.7 102.24,117.97
+VCCGT on IN2 (solid shape): outline of 3445 points within 88.48,81.64 108.11,101.96
+VCCGT on IN3 (solid shape): outline of 209 points within 83.96,108.73 102.37,116.32
+VCCGT on IN3 (solid shape): outline of 2759 points within 87.74,86.45 108.11,101.96
+VCCGT on VCC: outline of 111 points within 82.31,81.52 108.09,118.61
+VCCIO on TOP (solid shape): 122.72,92.73 122.72,92.32 122.9,92.14 123.45,92.14 123.67,91.93 123.66,91.81 123.68,91.7 123.68,91.28 123.61,91.2 122.82,91.2 122.16,91.86 122.16,92.85 122.18,92.88 122.56,92.88
+VCCIO on TOP (solid shape): 71.02,60.95 71.73,60.95 71.73,60.52 72.38,60.52 72.38,60.95 72.93,60.95 72.93,60.52 73.58,60.52 73.58,60.95 75.43,60.95 75.83,60.55 75.83,57.78 75.57,57.52 67.83,57.52 67.57,57.78 67.57,59.17 68.59,60.19 68.84,60.19 69.61,60.95 71.02,60.95
+VCCIO on TOP (solid shape): 124.97,88.01 124.96,87.98 124.95,87.87 124.98,87.77 124.98,87.62 124.85,87.49 124.6,87.49 124.53,87.42 124.52,87.42 124.33,87.23 124.34,86.96 124.34,86.95 124.34,86.48 124.31,86.32 124.34,86.19 124.34,86.18 124.34,85.7 124.34,85.68 124.3,85.53 124.34,85.39 124.34,85.38 124.34,84.9 124.29,84.72 124.34,84.55 124.34,84.13 124.34,84.1 124.3,83.96 124.34,83.81 124.34,83.8 124.34,83.56 124.22,83.43 123.96,83.43 123.83,83.56 123.83,84.06 123.58,84.32 122.9,84.32 122.65,84.08 122.65,83.96 122.54,83.84 122.33,83.84 122.21,83.96 122.21,84.74 122.21,85.46 122.24,85.51 122.27,85.54 122.28,85.56 122.31,85.59 123.33,85.59 123.73,85.99 123.77,85.99 123.77,86.03 123.83,86.1 123.83,86.73 123.77,86.79 123.77,86.83 123.73,86.83 123.71,86.86 122.56,86.86 122.45,86.86 122.35,86.96 122.35,87.23 122.76,87.64 122.76,88.07 122.95,88.26 124.72,88.26
+VCCIO on BOTTOM (solid shape): outline of 757 points within 121.49,83.24 124.79,93.39
+VCCIO on IN1 (solid shape): outline of 1820 points within 122.06,78.1 134.07,93.72
+VCCIO on IN2 (solid shape): outline of 19994 points within 68.08,33.01 136.66,94.1
+VCCIO on IN3 (solid shape): outline of 810 points within 121.78,78.22 136.36,88
+VCCIO on VCC: outline of 95 points within 120.53,76.57 136.03,89.65
+VCCSA on TOP (solid shape): outline of 602 points within 119.9,84.73 135.9,111.75
+VCCSA on BOTTOM (solid shape): outline of 539 points within 120.1,93.57 136.53,115.94
+VCCSA on IN1 (solid shape): 135.42,114.9 135.42,108.35 135.29,108.22 130.97,108.22 129.96,109.24 129.96,114.98 130.21,115.23 135.09,115.23
+VCCSA on IN1 (solid shape): outline of 358 points within 120.41,86.35 123.2,102.61
+VCCSA on IN2 (solid shape): 135.42,114.9 135.42,108.35 135.29,108.22 133.29,108.22 132.83,108.68 130.51,108.68 129.96,109.24 129.96,114.98 130.21,115.23 135.09,115.23
+VCCSA on IN3 (solid shape): 135.42,114.9 135.42,108.35 135.29,108.22 131.35,108.22 131.32,108.24 130.95,108.24 129.96,109.24 129.96,114.98 130.21,115.23 135.09,115.23
+VCCSA on VCC: outline of 91 points within 120.53,90.16 135.65,117.08
+VCCST on TOP (solid shape): 184.16,36.19 183.45,35.47 183.4,35.47 183.4,35.42 183.27,35.3 183.27,34.92 183.02,34.66 180.98,34.66 180.82,34.83 180.83,34.88 180.83,34.94 180.82,34.99 180.81,35.05 180.78,35.1 180.75,35.14 180.73,35.16 180.73,35.73 182.3,35.73 182.31,35.67 182.32,35.62 182.34,35.57 182.37,35.53 182.4,35.49 182.44,35.45 182.48,35.42 182.53,35.4 182.58,35.38 182.63,35.37 182.69,35.37 182.74,35.38 182.79,35.4 182.84,35.42 182.88,35.45 182.92,35.49 182.96,35.53 182.98,35.57 183,35.62 183.01,35.67 183.02,35.73 183.01,35.78 183,35.83 182.98,35.88 182.96,35.93 182.92,35.97 182.88,36.01 182.84,36.04 182.79,36.06 182.74,36.08 182.69,36.08 182.63,36.08 182.58,36.08 182.53,36.06 182.48,36.04 182.44,36.01 182.4,35.97 182.37,35.93 182.34,35.88 182.32,35.83 182.31,35.78 182.3,35.73 180.73,35.73 180.73,35.93 181.72,36.92 184.16,36.92
+VCCST on TOP (solid shape): outline of 330 points within 122.26,92.27 131.53,96.03
+VCCST on IN3 (solid shape): outline of 943 points within 121.55,87.37 131.84,93.91
+VCCSTG on BOTTOM (solid shape): 133.74,97.02 133.74,95.71 133.11,95.08 132.15,95.08 131.95,95.28 131.95,96.48 131.96,96.49 131.96,96.81 132.27,97.12 133.64,97.12
+VCCSTG on IN2 (solid shape): outline of 642 points within 123.33,93.84 134.12,101.5
GND on TOP (solid shape): 22.87,26.41 22.87,23.49 22.74,23.36 20.46,23.36 19.57,24.25 19.57,26.53 19.69,26.66 22.62,26.66
GND on TOP (solid shape): 46.3,18.19 46.3,16.33 45.48,15.51 44.66,15.51 44.22,15.95 44.22,18.62 44.41,18.81 45.68,18.81
GND on TOP (solid shape): 83.45,117.34 83.45,114.29 83.32,114.16 81.16,114.16 81.04,114.29 81.04,117.21 81.29,117.47 83.32,117.47
GND on TOP (solid shape): 109.61,115.28 109.61,113.05 109.46,112.89 108.52,112.89 108.37,113.05 108.37,115.18 108.49,115.31 109.59,115.31
GND on TOP (solid shape): 112.51,115.05 112.51,112.87 112.43,112.79 111.29,112.79 111.24,112.84 111.24,115 111.41,115.18 112.38,115.18
GND on TOP (solid shape): 118.63,114.67 118.63,112.44 118.58,112.39 117.54,112.39 117.36,112.56 117.36,114.65 117.48,114.77 118.53,114.77
GND on TOP (solid shape): 119.04,91.9 119.04,88.56 118.91,88.43 115.86,88.43 115.61,88.68 115.61,91.1 116.54,92.02 118.92,92.02
GND on TOP (solid shape): 121.27,114.7 121.27,112.56 121.12,112.41 120.05,112.41 120,112.46 120,114.65 120.18,114.82 121.14,114.82
GND on TOP (solid shape): 127.62,114.57 127.62,112.46 127.57,112.41 126.37,112.41 126.27,112.51 126.27,114.59 126.4,114.72 127.47,114.72
GND on TOP (solid shape): 141.13,20.82 141.13,19.85 140.14,18.86 139.35,18.86 139.33,18.89 139.33,21 139.35,21.02 140.93,21.02
GND on TOP (solid shape): 144.15,55.74 144.15,46.09 144.03,45.96 143.39,45.96 141.87,47.49 141.87,56 142.25,56.38 143.52,56.38
GND on TOP (solid shape): 201.66,30.5 201.66,29.73 201.51,29.58 200.64,29.58 199.25,30.98 199.25,32.2 199.32,32.27 199.88,32.27
GND on TOP (solid shape): 217.18,43.81 217.18,41.27 216.74,40.82 214.64,40.82 214.58,40.88 214.58,43.81 214.83,44.06 216.93,44.06
GND on TOP (solid shape): 258.33,29.58 258.33,28.82 258.2,28.69 256.17,28.69 256.04,28.82 256.04,29.58 256.17,29.71 258.2,29.71
GND on TOP (solid shape): 281.89,32.45 281.89,31.55 281.82,31.49 277.89,31.49 277.63,31.74 277.63,32.86 278.09,33.31 281.02,33.31
GND on TOP (solid shape): 238.59,11.29 238.59,10.56 238.31,10.28 235.34,10.28 235.09,10.53 235.09,11.29 235.21,11.42 238.47,11.42
GND on TOP (solid shape): 239.61,16.98 239.61,15.74 239.38,15.51 237.45,15.51 237.25,15.71 237.25,16.63 237.78,17.16 239.43,17.16
GND on TOP (solid shape): 48.65,37.07 48.65,34.54 47.38,33.26 45.86,33.26 45.6,33.52 45.6,37.07 45.86,37.33 48.4,37.33
GND on TOP (solid shape): 72.53,67.62 72.53,63.49 70.62,61.59 69.8,61.59 69.61,61.78 69.61,62.03 71.19,63.62 71.19,67.81 71.26,67.87 72.27,67.87
GND on TOP (solid shape): 136.46,20.67 136.46,19.14 135.67,18.34 134.18,18.34 133.97,18.56 133.97,19.26 134.18,19.46 134.72,19.46 136.01,20.75 136.38,20.75
GND on TOP (solid shape): 149.23,70.6 149.23,67.68 148.6,67.05 145.04,67.05 144.54,67.55 144.54,67.66 144.49,67.71 144.49,70.75 144.84,71.11 148.73,71.11
GND on TOP (solid shape): 163.08,54.98 163.08,53.97 162.95,53.84 162.57,53.84 162.44,53.97 162.06,53.97 161.93,54.09 161.93,54.98 162.06,55.11 162.95,55.11
GND on TOP (solid shape): 174.08,83.84 174.08,82.46 173.7,82.08 169.81,82.08 169.53,82.36 169.53,83.45 169.71,83.63 173.16,83.63 173.52,83.99 173.92,83.99
GND on TOP (solid shape): 177.56,17.26 177.56,15.1 177.3,14.85 173.26,14.85 172.6,15.5 172.6,16.26 172.63,16.28 172.63,17.12 173.03,17.52 177.3,17.52
GND on TOP (solid shape): 180.29,23.36 180.29,23.03 179.93,22.68 179.93,21.3 179.84,21.21 179.51,21.21 179.25,21.46 179.25,23.29 179.4,23.44 180.22,23.44
GND on TOP (solid shape): 215.02,14.21 215.02,10.79 214.89,10.66 214,10.66 213.88,10.79 213.88,11.01 214,11.14 214,14.26 214.08,14.34 214.89,14.34
GND on TOP (solid shape): 14.48,39.89 14.6,39.83 14.73,39.77 15.58,38.93 15.58,37.3 15.48,37.2 14.84,37.2 13.9,38.14 13.9,39.69 14.11,39.89
GND on TOP (solid shape): 187.33,46.22 187.33,42.15 187.21,42.03 182.38,42.03 182,42.41 182,42.79 182.13,42.92 182.51,42.92 182.64,43.04 182.64,46.35 183.27,46.98 186.57,46.98
GND on TOP (solid shape): 200.21,27.19 200.21,25.57 200.06,25.42 200.04,25.42 200.02,25.43 199.7,25.43 199.68,25.42 198.82,25.42 198.43,25.8 198.43,27.09 198.59,27.24 200.16,27.24
GND on TOP (solid shape): 281.44,46.98 281.44,43.04 281.81,42.67 281.81,42.04 281.54,41.77 278.32,41.77 277.63,42.46 277.63,45.91 278.83,47.11 281.31,47.11
GND on TOP (solid shape): 187.46,30.75 187.46,29.81 186.83,29.17 186.5,29.17 185.91,29.76 184.29,29.76 183.98,30.06 183.98,31.05 184.08,31.16 187.06,31.16
GND on TOP (solid shape): 292.01,28.3 292.12,28.3 292.29,28.13 292.29,26.79 292.03,26.53 292.03,25.82 291.83,25.62 290.87,25.62 290.76,25.72 290.76,28.29 290.79,28.31 292.01,28.31
GND on TOP (solid shape): 179.97,72.94 179.97,69.61 179.68,69.32 179.35,69.32 179.33,69.31 175.73,69.31 175.35,69.69 175.35,72.58 175.83,73.07 179.84,73.07
GND on TOP (solid shape): 265.95,20.31 265.95,18.1 265.92,17.99 265.91,17.88 265.91,17.25 265.68,17.03 261.48,17.03 261.38,17.14 261.38,20.06 261.82,20.5 265.76,20.5
GND on TOP (solid shape): 136.26,96.66 136.23,96.49 136.28,96.33 136.28,96.26 136.15,96.13 134.76,96.13 134.63,96.26 134.63,96.51 135.01,96.89 136.03,96.89
GND on TOP (solid shape): 204.35,72 204.35,68.7 204.1,68.44 201.3,68.44 201.05,68.7 201.05,69.84 200.92,69.97 198.76,69.97 198.64,69.84 198.64,68.7 198.38,68.44 194.32,68.44 193.94,68.82 193.94,73.52 194.45,74.03 202.32,74.03
GND on TOP (solid shape): 112.74,87.65 112.74,85.99 112.48,85.74 112.48,85.46 112.74,85.21 112.74,84.78 112.53,84.57 111.16,84.57 110.93,84.8 110.93,85.18 110.65,85.46 110.65,85.61 110.93,85.89 110.93,87.34 110.88,87.39 110.88,87.75 110.93,87.8 112.58,87.8
GND on TOP (solid shape): 170.17,70.66 170.17,70.66 170.22,70.62 172.77,70.62 172.78,70.63 174.05,70.63 175.55,69.13 177.51,69.13 177.7,68.94 177.7,68.14 177.53,67.97 174.53,67.97 174.44,68.06 168.03,68.06 167.9,68.19 167.9,70.68 168.21,70.98 169.84,70.98
GND on TOP (solid shape): 180.22,58.66 180.22,58.17 180.1,58.05 179.38,58.05 178.55,57.22 178.55,56.89 178.61,56.83 178.61,55.94 177.51,54.85 177.51,53.3 177.14,52.94 175.57,52.94 174.23,54.28 174.23,56.01 177.06,58.83 180.05,58.83
GND on TOP (solid shape): 161.63,77.46 161.78,77.46 161.96,77.28 161.96,77.1 161.55,76.7 161.52,76.7 161.52,76.66 161.33,76.47 161.33,76.04 160.77,75.48 159.5,75.48 159.09,75.07 158.35,75.07 158.3,75.12 158.3,75.66 158,75.96 158,77.98 158.27,78.25 159.78,78.25 159.85,78.32 160.77,78.32
GND on TOP (solid shape): 208.11,14.44 208.39,14.16 211.21,14.16 211.52,13.86 211.52,12.23 211.35,12.07 210.9,12.07 210.78,12.18 210.78,13.02 210.54,13.26 209.58,13.26 209.41,13.44 207.89,13.44 207.81,13.36 207.55,13.36 207.41,13.5 207.41,13.65 207.22,13.84 207.22,14.6 208.11,14.6
GND on TOP (solid shape): 113.95,23.26 114.04,23.27 114.12,23.27 114.21,23.18 114.21,22.93 114.21,22.86 114.17,22.82 113.77,22.82 113.7,22.75 113.66,22.69 113.62,22.63 113.61,22.6 113.6,22.49 113.6,22.42 113.54,22.37 112.15,22.37 112.11,22.41 112.11,23.13 112.25,23.27 113.87,23.27
GND on TOP (solid shape): 134.74,125.44 136.28,125.44 136.61,125.77 138.16,125.77 138.49,125.44 139.56,125.44 139.95,125.05 139.95,122.17 139.73,121.95 139.73,119.24 139.56,119.07 137.32,119.07 136.92,119.47 136.92,119.47 136.79,119.6 136.79,122.42 136.59,122.62 135.85,122.62 135.01,123.45 135.01,123.47 134.87,123.61 132.38,123.61 132.21,123.77 132.21,123.92 132.83,124.53 132.83,126.05 133.06,126.28 133.91,126.28
GND on TOP (solid shape): 160.51,82.13 160.51,81.4 160.39,81.27 160.39,80.84 159.88,80.33 159.04,80.33 158.73,80.03 158.73,79.57 158.66,79.49 158.23,79.49 157.87,79.84 157.87,79.86 157.77,80.11 157.52,80.21 157.5,80.21 157.44,80.28 157.34,80.28 157.19,80.43 157.19,81.19 157.72,81.73 159.62,81.73 159.62,81.94 159.63,81.94 159.63,82.14 160.5,82.14
GND on TOP (solid shape): 298.46,25.14 298.08,24.29 298.81,23.72 307.4,23.72 307.57,23.64 307.65,23.47 307.65,21.86 296.4,21.86 296.1,22.16 296.1,24.73 296.5,25.14
GND on TOP (solid shape): 254.49,17.26 254.57,17.23 254.59,17.15 254.76,16.83 255.13,16.83 255.23,16.83 255.28,16.74 255.28,16.7 255.27,16.69 255.27,14.71 255.15,14.6 254.06,14.6 253.98,14.52 253.98,11.67 253.71,11.39 253.12,11.39 252.87,11.65 252.87,14.39 252.46,14.8 252.46,16.02 252.64,16.2 253.2,16.2 253.27,16.27 253.27,17.11 253.43,17.26
GND on TOP (solid shape): 65.8,71.68 65.8,69.71 65.79,69.71 65.79,69.58 65.16,68.95 65.16,68.19 65.26,68.09 67.93,68.09 68.4,67.62 69.44,67.62 69.5,67.55 69.5,67.45 69.4,67.35 68.36,67.35 68.01,67 66.99,67 66.63,67.35 65.52,67.35 65.11,66.94 65.11,66 64.07,64.96 61.26,64.96 61.09,65.13 61.09,69.26 61.25,69.51 61.16,69.8 61.13,69.87 61.16,69.94 61.24,70.02 64.59,70.02 64.78,70.21 64.78,70.41 64.87,70.5 64.87,71.72 64.95,71.8 65.68,71.8
GND on TOP (solid shape): 187.08,72.25 187.19,72.25 187.2,72.25 187.33,72.23 187.46,72.25 187.46,72.25 187.59,72.25 187.72,72.38 188.6,72.38 188.73,72.25 188.73,72 187.97,71.24 187.97,69.71 187.21,68.95 185.56,68.95 185.43,69.08 185.44,69.1 185.46,69.22 185.43,69.33 185.43,69.34 185.43,69.71 185.43,69.72 185.46,69.84 185.43,69.97 185.43,69.97 185.43,70.34 185.43,70.35 185.46,70.48 185.43,70.6 185.43,70.61 185.43,71.75 185.68,72 186.32,72 186.62,72.3 186.68,72.34 186.72,72.38 186.95,72.38
GND on TOP (solid shape): 190.64,77.51 190.64,76.57 190.36,76.29 186.22,76.29 186.12,76.39 186.12,78.55 184.57,80.1 179.89,80.1 179.66,80.33 179.66,80.66 183.11,80.66 183.11,80.61 183.12,80.56 183.14,80.51 183.17,80.46 183.2,80.42 183.24,80.38 183.29,80.35 183.34,80.33 183.39,80.31 183.44,80.3 183.49,80.3 183.55,80.31 183.6,80.33 183.64,80.35 183.69,80.38 183.73,80.42 183.76,80.46 183.79,80.51 183.81,80.56 183.82,80.61 183.82,80.66 183.82,80.71 183.81,80.77 183.79,80.82 183.76,80.86 183.73,80.9 183.69,80.94 183.64,80.97 183.6,80.99 183.55,81.01 183.49,81.02 183.44,81.02 183.39,81.01 183.34,80.99 183.29,80.97 183.24,80.94 183.2,80.9 183.17,80.86 183.14,80.82 183.12,80.77 183.11,80.71 183.11,80.66 179.66,80.66 179.66,81.89 179.75,81.98 180.02,81.98 180.4,82.36 185.79,82.36
GND on TOP (solid shape): 163,86.68 163,84.63 163,84.6 163.15,84.45 163.19,84.45 163.21,84.42 163.3,84.42 163.31,84.42 163.43,84.39 163.56,84.42 163.57,84.42 163.63,84.42 163.65,84.45 163.69,84.45 164.27,85.03 164.56,85.03 164.56,85.02 164.64,85.02 165.24,84.42 165.38,84.42 165.39,84.42 165.52,84.39 165.64,84.42 165.65,84.42 165.8,84.42 166.35,84.98 166.68,84.98 166.76,84.9 166.76,83.73 165.8,82.77 165.8,82.73 165.8,82.36 165.54,82.11 165.54,80.23 165.01,79.7 165.01,79.37 164.35,78.71 164.1,78.71 164,78.81 164,79.43 163.94,79.48 163.94,82.51 163.66,82.79 162.57,82.79 162.29,83.07 162.29,86.58 162.44,86.73 162.95,86.73
GND on TOP (solid shape): outline of 83 points within 225.31,43.42 229.24,49.14
GND on TOP (solid shape): outline of 106 points within 149.87,99.43 153.04,106.8
GND on TOP (solid shape): 272.06,23.32 272.17,23.33 272.6,23.33 272.96,22.98 273.53,22.98 273.53,22.99 273.58,23.08 273.69,23.07 273.85,23 274.02,23.02 274.03,23.03 274.23,23.03 274.35,23.15 274.76,23.15 274.79,23.13 274.79,19.29 274.53,19.04 273.31,19.04 272.88,19.47 271.49,19.47 271.15,19.8 270.22,19.8 269.75,19.33 269.48,19.33 269.44,19.29 268.51,19.29 268.36,19.45 268.36,19.7 269.5,20.84 269.5,21.38 269.66,21.53 269.97,21.53 270.03,21.47 270.11,21.43 270.16,21.37 270.17,21.3 270.18,21.02 270.39,20.83 270.42,20.82 270.52,20.82 271.08,20.82 271.13,20.82 271.38,20.82 271.82,21.25 271.82,21.36 271.82,21.37 271.88,21.68 271.67,21.91 271.66,21.91 271.56,22.01 271.03,22.01 270.86,22.06 270.68,22.02 270.66,22.01 270.49,22.01 270.43,22.06 270.35,22.1 270.32,22.11 270.32,22.49 270.37,22.55 270.86,22.55 271.23,22.5 271.43,22.81 271.44,22.83 271.51,22.9 271.51,23.23 271.61,23.33 271.96,23.33
GND on TOP (solid shape): outline of 171 points within 296.58,36.26 307.49,44.42
GND on TOP (solid shape): 309.17,95.49 309.34,95.41 309.42,95.24 309.42,94.07 309.32,93.7 309.05,93.43 308.35,93.01 307.9,92.55 307.74,91.93 307.74,84.48 307.83,84 308.1,83.6 309.26,82.44 309.32,82.36 309.34,82.26 309.34,81.92 309.26,81.75 309.09,81.67 303.16,81.67 302.67,81.3 302.91,80.73 302.91,66.61 302.67,66.04 303.16,65.67 309.09,65.67 309.26,65.59 309.34,65.42 309.34,64.48 309.32,64.38 309.26,64.3 307.71,62.75 307.54,62.5 307.49,62.21 307.49,58.67 307.41,58.5 307.24,58.42 298.81,58.42 298.23,58.15 298.07,57.52 297,57.52 296.68,57.84 296.68,59.55 297.13,60 300.17,60 301.19,61.01 301.19,64.57 299.6,66.16 299.6,66.92 300.05,67.36 302.14,67.36 302.4,67.62 302.4,80.5 302.24,81.59 303.16,82.18 308.68,82.18 308.73,82.21 308.71,82.27 307.74,83.24 307.36,83.81 307.23,84.48 307.23,91.93 307.23,92 307.23,92.07 307.23,92.74 305.88,94.1 305.88,95.49
GND on TOP (solid shape): outline of 245 points within 157.24,95.86 162.65,109.34
GND on TOP (solid shape): outline of 357 points within 69.1,110.23 130.69,127.12
GND on TOP (solid shape): outline of 399 points within 0.25,11.84 10.91,43.85
GND on TOP (solid shape): outline of 308 points within 0.25,0.25 309.42,134.55
GND on BOTTOM (solid shape): 31.86,35.52 31.86,34.64 31.76,34.53 31.33,34.53 30.97,34.89 30.97,35.68 31.05,35.75 31.63,35.75
GND on BOTTOM (solid shape): 65.29,67.94 65.29,66.16 64.53,65.4 63.76,65.4 63.38,65.78 63.38,66.67 64.78,68.06 65.16,68.06
GND on BOTTOM (solid shape): 80.78,9.13 80.78,6.85 80.65,6.72 77.1,6.72 76.97,6.85 76.97,9.13 77.1,9.26 80.65,9.26
GND on BOTTOM (solid shape): 86.75,16.88 86.75,14.09 86.62,13.96 83.58,13.96 83.19,14.34 83.19,17.14 83.32,17.26 86.37,17.26
GND on BOTTOM (solid shape): 148.47,40.38 148.47,36.31 147.96,35.8 147.08,35.8 145.55,37.33 145.55,40.25 145.81,40.5 148.35,40.5
GND on BOTTOM (solid shape): 151.77,102.61 151.77,100.19 151.52,99.94 150.12,99.94 150,100.07 150,102.48 150.25,102.73 151.65,102.73
GND on BOTTOM (solid shape): 177.28,56.1 177.28,53.71 177.21,53.65 174.82,53.65 174.74,53.72 174.74,56.12 174.81,56.19 177.19,56.19
GND on BOTTOM (solid shape): 200.67,60.44 200.67,58.82 200.37,58.51 194.95,58.51 194.57,58.89 194.57,60.38 194.76,60.57 200.54,60.57
GND on BOTTOM (solid shape): 263.92,16.6 263.92,14.72 263.81,14.62 263.26,14.62 263.15,14.72 263.15,16.58 263.26,16.68 263.84,16.68
GND on BOTTOM (solid shape): 269.6,44.22 269.6,40.34 269.25,40 265.06,40 264.8,40.25 264.8,43.68 265.57,44.44 269.38,44.44
GND on BOTTOM (solid shape): 12.2,24.12 12.2,21.83 11.95,21.58 7.76,21.58 6.99,22.34 6.99,23.61 7.76,24.37 11.95,24.37
GND on BOTTOM (solid shape): 22.11,26.41 22.74,26.41 22.87,26.28 22.87,23.49 22.74,23.36 20.46,23.36 19.57,24.25 19.57,26.53 19.69,26.66 21.85,26.66
GND on BOTTOM (solid shape): 46.57,17.85 46.57,17.34 46.31,17.08 44.54,17.08 44.16,17.47 44.16,18.48 44.54,18.86 45.55,18.86
GND on BOTTOM (solid shape): 48.14,16.55 48.14,14.09 48.04,13.99 47.51,13.99 47.38,14.11 47.38,16.86 47.46,16.93 47.76,16.93
GND on BOTTOM (solid shape): 50.17,27.66 50.17,26.79 49.54,26.15 49.54,24.76 49.16,24.37 48.65,24.37 48.52,24.5 48.52,27.3 49.03,27.8 50.03,27.8
GND on BOTTOM (solid shape): 111.01,110.23 111.01,108.32 110.37,107.69 103.39,107.69 103.11,107.97 103.11,110.81 103.29,110.99 110.25,110.99
GND on BOTTOM (solid shape): 137.3,111.62 137.3,108.58 136.92,108.19 135.9,108.19 135.77,108.32 135.77,108.83 136.03,109.08 136.03,111.5 136.28,111.75 137.17,111.75
GND on BOTTOM (solid shape): 182.38,40.25 184.03,40.25 184.16,40.12 184.16,39.41 183.93,39.18 181.33,39.18 181.06,39.45 181.06,40.17 181.16,40.27 182.36,40.27
GND on BOTTOM (solid shape): 240.04,11.29 240.04,10.4 239.66,10.02 235.34,10.02 234.83,10.53 234.83,11.04 235.21,11.42 239.91,11.42
GND on BOTTOM (solid shape): 60.02,15.55 60.02,15.1 58.53,13.62 57.53,13.62 57.36,13.78 57.36,15.41 56.91,15.87 56.91,16.5 57.03,16.63 58.94,16.63
GND on BOTTOM (solid shape): 113.55,9.32 113.55,8.54 113.83,8.25 113.83,7.64 113.66,7.46 111.44,7.46 111.26,7.64 111.26,9.36 111.31,9.41 113.46,9.41
GND on BOTTOM (solid shape): 258.15,20.13 258.15,17.16 258.23,17.08 258.23,16.58 256.98,16.58 256.8,16.75 256.8,18.99 257.11,19.29 257.11,20.28 258,20.28
GND on BOTTOM (solid shape): 292.49,43.63 292.49,42.28 292.34,42.13 291.07,42.13 290.94,42.26 290.94,43.27 291.07,43.4 291.4,43.4 291.65,43.65 292.47,43.65
GND on BOTTOM (solid shape): 238.02,16.79 238.02,15.94 238,15.92 238,15.76 237.91,15.66 236.76,15.66 236.44,15.97 236.44,16.47 236.9,16.92 237.88,16.92
GND on BOTTOM (solid shape): 261.91,16.58 261.91,15.79 261.45,15.33 260.72,15.33 260.56,15.48 260.56,15.66 260.72,15.81 261.27,15.81 261.66,16.2 261.66,16.58 261.73,16.65 261.83,16.65
GND on BOTTOM (solid shape): 265.39,16.65 265.39,16.07 265.69,15.76 266.41,15.76 266.53,15.64 266.53,15.33 266.43,15.23 265.62,15.23 265.16,15.69 265.16,16.63 265.24,16.7 265.34,16.7
GND on BOTTOM (solid shape): 284.19,11.52 284.19,9.77 283.68,9.26 262.32,9.26 262.11,9.46 262.11,9.62 262.54,10.05 262.54,11.53 262.66,11.65 284.06,11.65
GND on BOTTOM (solid shape): 145.93,16.69 145.93,15.92 145.63,15.61 143.32,15.61 143.11,15.81 143.11,16.78 143.19,16.86 145.77,16.86
GND on BOTTOM (solid shape): 217.51,43.42 217.51,41.14 217.18,40.81 214.59,40.81 214.51,40.88 214.51,42.92 214.94,43.35 215.07,43.35 215.63,43.91 217.03,43.91
GND on BOTTOM (solid shape): 260.08,11.19 260.08,10.18 260.64,9.62 260.64,9.59 260.46,9.41 258.63,9.41 258.61,9.44 258.61,9.57 259.24,10.2 259.24,11.17 259.32,11.25 260.03,11.25
GND on BOTTOM (solid shape): 292.69,48.61 292.69,47.69 292.47,47.46 292.47,46.04 292.36,45.94 291.81,45.94 291.73,46.01 291.73,47.11 291.5,47.34 291.5,48.73 291.58,48.81 292.49,48.81
GND on BOTTOM (solid shape): 175.14,63.24 175.14,61.18 174.98,61.01 172.03,61.01 171.71,60.7 171.71,58.41 171.59,58.28 169.11,58.28 169.05,58.35 169.05,63.3 169.3,63.55 172.86,63.55 172.98,63.68 174.7,63.68
GND on BOTTOM (solid shape): 224.55,38.09 224.55,36.06 224.42,35.93 220.1,35.93 219.8,36.24 219.8,36.48 219.97,36.65 219.97,38.01 220.33,38.37 221.9,38.37 222.01,38.47 224.16,38.47
GND on BOTTOM (solid shape): 219.77,36.92 219.77,36.67 219.64,36.53 219.64,35.98 219.94,35.68 219.94,32.85 219.8,32.71 218.86,32.71 218.86,36.54 218.73,36.67 218.73,36.88 218.86,37.01 219.69,37.01
GND on BOTTOM (solid shape): 99.05,12.46 100.84,12.46 100.97,12.33 100.97,11.62 100.8,11.44 98.34,11.44 98.19,11.29 93.91,11.29 93.65,11.55 93.65,13.04 93.81,13.2 98.31,13.2
GND on BOTTOM (solid shape): 112.07,95.57 112.07,95.38 111.69,95 111.69,94.37 111.56,94.24 111.34,94.24 111.24,94.34 111.24,95.21 111.42,95.39 111.42,95.42 111.72,95.72 111.93,95.72
GND on BOTTOM (solid shape): 157.54,43.91 157.73,43.72 157.73,43.33 157.88,43.17 157.88,43.05 157.78,42.95 157.72,42.96 157.49,42.96 157.34,43.11 156.73,43.11 156.47,43.36 156.47,44.19 156.6,44.31 157.13,44.31
GND on BOTTOM (solid shape): 204.35,71.11 204.35,68.7 204.1,68.44 201.3,68.44 201.05,68.7 201.05,69.84 200.92,69.97 198.76,69.97 198.64,69.84 198.64,68.7 198.38,68.44 195.21,68.44 194.83,68.82 194.83,71.62 194.95,71.75 203.72,71.75
GND on BOTTOM (solid shape): 76.77,122.39 76.77,119.55 76.59,119.37 76.59,116.96 74.56,114.93 74.56,114.16 74.43,114.04 74.43,110.48 74.3,110.35 73.16,110.35 73.16,111.12 72.27,111.12 72.27,119.75 71.76,120.27 71.76,122.77 72.14,123.15 76,123.15
GND on BOTTOM (solid shape): 104.95,95.61 104.95,95.42 104.58,95.05 104.58,94.3 104.51,94.24 104.26,94.24 104.13,94.37 104.13,95 103.75,95.38 103.75,95.57 103.88,95.7 104.07,95.7 104.22,95.55 104.48,95.55 104.65,95.72 104.84,95.72
GND on BOTTOM (solid shape): 175.73,70.55 175.73,69.36 176.01,69.08 177.54,69.08 177.7,68.93 177.7,68.15 177.45,67.91 175.56,67.91 175.22,68.25 169.3,68.25 168.92,68.63 168.92,70.73 169.05,70.86 175.42,70.86
GND on BOTTOM (solid shape): 101.89,95.53 102.08,95.53 102.28,95.73 102.45,95.73 102.61,95.57 102.61,95.38 102.23,95 102.23,94.37 102.1,94.24 101.85,94.24 101.78,94.3 101.78,95.01 101.4,95.4 101.4,95.59 101.54,95.73 101.69,95.73
GND on BOTTOM (solid shape): 107.3,95.59 107.3,95.4 106.93,95.02 106.93,94.3 106.86,94.24 106.61,94.24 106.48,94.37 106.48,95 106.1,95.38 106.1,95.57 106.23,95.7 106.42,95.7 106.56,95.55 106.82,95.55 107,95.73 107.16,95.73
GND on BOTTOM (solid shape): 36.59,14.34 36.59,6.72 36.2,6.34 28.08,6.34 27.39,7.03 27.39,12.21 28.38,13.2 33.54,13.2 33.54,9.01 33.86,8.69 35.47,8.69 35.82,9.04 35.82,13.19 35.56,13.45 33.79,13.45 33.54,13.2 28.38,13.2 30.54,15.36 35.57,15.36
GND on BOTTOM (solid shape): 119.87,127.05 119.87,125.44 120.53,124.78 120.53,119.88 120.02,119.37 118.25,119.37 117.8,119.81 117.8,123.75 116.66,124.89 113.04,124.89 112.98,124.96 112.98,126.04 113.04,126.1 113.8,126.1 113.8,126.93 113.87,126.99 118.12,126.99 118.27,127.14 119.78,127.14
GND on BOTTOM (solid shape): 158.34,22.58 158.34,22.39 158.22,22.27 157.84,22.27 157.74,22.17 157.74,21.83 157.49,21.58 156.92,21.58 156.35,22.15 156.35,22.41 156.48,22.54 157.1,22.54 157.11,22.54 157.29,22.54 157.38,22.64 158.27,22.64
GND on BOTTOM (solid shape): 180.3,23.37 180.3,22.22 179.99,21.91 179.38,21.91 179.16,22.14 179.16,22.44 178.93,22.67 178.76,22.67 178.4,22.31 178.23,22.31 178.16,22.38 178.16,23.06 178.59,23.5 178.59,23.88 178.7,23.99 179.69,23.99
GND on BOTTOM (solid shape): 270.66,17.87 270.69,17.62 270.87,17.45 270.56,17.14 268.87,17.14 268.74,17.26 268.74,17.72 268.9,17.89 270.64,17.89
GND on BOTTOM (solid shape): 144.28,55.11 144.79,55.11 144.98,54.92 144.98,51.87 144.79,51.68 144.28,51.68 144.15,51.55 144.15,49.39 144.28,49.27 144.92,49.27 145.04,49.14 145.04,45.78 144.81,45.54 143.69,45.54 141.87,47.36 141.87,55.24 142.25,55.62 143.77,55.62
GND on BOTTOM (solid shape): 146.95,117.21 146.95,112.13 146.82,112 143.9,112 143.77,112.13 139.33,112.13 138.82,111.62 137.8,111.62 136.79,112.64 136.79,113.78 136.92,113.91 138.75,113.91 138.84,113.83 139.78,113.83 139.86,113.91 144.03,113.91 144.28,114.16 144.28,116.7 144.92,117.34 146.82,117.34
GND on BOTTOM (solid shape): 47.29,37.2 47.48,37.12 47.68,37.2 49.16,37.2 49.35,37.01 49.35,35.24 49.03,34.92 49.03,34.11 48.82,33.9 45.73,33.9 45.48,34.15 45.48,36.95 45.73,37.2
GND on BOTTOM (solid shape): 108.85,18.79 108.85,18.41 109.79,17.47 109.79,15.92 109.84,15.87 109.65,15.67 107.27,15.67 107.26,15.66 106.82,15.66 106.41,16.07 106.36,16.13 106.29,16.19 106.23,16.25 106.23,17.31 106.94,18.02 106.94,18.91 107.07,19.04 108.59,19.04
GND on BOTTOM (solid shape): 109.86,126.36 109.86,125.72 110.12,125.47 110.5,125.47 110.63,125.34 110.63,119.5 110.37,119.24 108.34,119.24 107.9,119.69 107.9,123.62 106.75,124.77 103.13,124.77 103.07,124.83 103.07,125.91 103.13,125.97 103.9,125.97 103.9,126.8 103.96,126.86 108.21,126.86 108.34,126.99 109.23,126.99
GND on BOTTOM (solid shape): 113.62,95.63 113.71,95.55 113.89,95.55 113.92,95.57 113.98,95.57 114.1,95.7 114.29,95.7 114.42,95.57 114.42,95.38 114.04,95 114.04,94.37 113.91,94.24 113.66,94.24 113.59,94.3 113.59,94.97 113.2,95.37 113.2,95.59 113.34,95.73 113.53,95.73
GND on BOTTOM (solid shape): 94.79,95.53 95.01,95.53 95.18,95.71 95.41,95.71 95.54,95.58 95.54,95.36 95.47,95.31 95.42,95.23 95.42,95.23 95.33,95.14 95.33,94.45 95.11,94.23 94.58,94.23 94.42,94.39 94.42,95.23 94.26,95.4 94.26,95.57 94.4,95.71 94.62,95.71
GND on BOTTOM (solid shape): 293.02,69.69 288.29,69.69 289.67,74.69 290.36,79.84 293.02,79.84
GND on BOTTOM (solid shape): 104.02,17.64 104.02,16.75 103.44,16.17 101.05,16.17 100.82,15.94 100.82,14.04 100.83,14.03 100.83,12.69 100.78,12.64 100.62,12.64 100.57,12.69 100.57,13.78 100.21,14.14 100.21,14.9 100.16,14.95 99.4,14.95 99.4,15.61 99.5,15.71 99.5,16.02 99.58,16.09 100.21,16.09 100.26,16.14 100.26,17.36 100.77,17.87 103.79,17.87
GND on BOTTOM (solid shape): 64.4,10.66 64.4,9.9 64.27,9.77 64.27,8.25 64.4,8.12 64.84,8.12 64.91,8.05 64.91,6.78 64.72,6.59 49.92,6.59 49.67,6.85 49.67,10.02 49.92,10.28 52.59,10.28 55.25,7.61 59.45,7.61 60.46,8.63 60.97,8.63 61.22,8.88 61.22,9.26 61.71,9.75 61.71,10.51 62.11,10.91 64.14,10.91
GND on BOTTOM (solid shape): 130.44,116.32 130.44,115.43 129.8,114.8 128.91,114.8 128.66,114.54 128.66,113.66 128.79,113.53 129.04,113.53 129.3,113.27 129.3,111.67 129.75,111.22 129.75,108.42 129.22,107.89 125.66,107.89 125.61,107.94 125.61,110.68 125.69,110.76 126.6,110.76 126.81,110.96 126.81,112.23 126.63,112.41 126.4,112.41 126.27,112.54 126.27,114.95 127.77,116.45 130.31,116.45
GND on BOTTOM (solid shape): 17.66,33.65 17.66,28.18 17.92,27.93 19.31,27.93 19.44,27.8 19.44,27.04 19.31,26.91 18.3,26.91 16.9,25.52 16.01,25.52 15.5,26.03 15.5,26.53 15.88,26.91 15.88,31.48 15.94,31.66 15.88,31.85 15.88,33.01 16.14,33.01 16.39,33.26 16.39,34.03 16.52,34.15 17.15,34.15
GND on BOTTOM (solid shape): 116.8,95.6 116.8,95.41 116.39,95 116.39,94.3 116.32,94.24 116.07,94.24 115.94,94.37 115.94,95 115.56,95.38 115.56,95.57 115.69,95.7 115.88,95.7 116.01,95.57 116.07,95.57 116.07,95.57 116.16,95.56 116.24,95.57 116.25,95.57 116.3,95.57 116.46,95.73 116.67,95.73
GND on BOTTOM (solid shape): 33.66,34.28 33.66,33.52 33.79,33.39 33.79,33.36 34.03,33.12 34.08,33.08 34.14,33.05 34.3,32.88 34.3,26.91 34.17,26.79 32.65,26.79 32.39,27.04 32.39,30.6 31.89,31.11 30.74,31.11 30.62,31.23 30.62,31.89 30.79,31.89 31.4,32.5 31.62,32.5 31.65,32.53 31.67,32.53 31.67,32.55 31.71,32.59 31.71,33.28 31.71,33.28 31.71,34.03 32.09,34.41 33.54,34.41
GND on BOTTOM (solid shape): 118.29,95.7 118.34,95.63 118.44,95.57 118.52,95.56 118.6,95.57 118.61,95.57 118.67,95.57 118.8,95.7 118.99,95.7 119.12,95.57 119.12,95.38 118.74,95 118.74,94.37 118.61,94.24 118.36,94.24 118.29,94.3 118.29,94.99 117.93,95.36 117.93,95.63 118.05,95.75 118.24,95.75
GND on BOTTOM (solid shape): 161.81,56.12 161.81,55.49 162.7,54.6 163.08,54.6 163.2,54.47 163.2,51.43 163.33,51.3 167.4,51.3 167.52,51.17 167.52,49.27 167.4,49.14 160.6,49.14 160.35,48.89 155.97,48.89 155.84,49.01 155.84,51.17 155.97,51.3 159.27,51.3 159.53,51.03 159.53,50.55 159.67,50.41 160.77,50.41 161.17,50.82 161.17,51.81 160.41,52.57 160.16,52.57 159.9,52.82 159.9,56 160.28,56.38 161.55,56.38
GND on BOTTOM (solid shape): 99.84,126.84 99.84,126.22 100.34,125.72 100.34,125.34 101.1,124.58 101.36,124.58 101.48,124.45 101.48,117.85 101.23,117.59 97.55,117.59 97.42,117.72 97.42,122.04 97.55,122.16 98.82,122.16 98.94,122.29 98.94,123.94 98.82,124.07 97.93,124.07 97.67,123.82 96.89,123.82 96.73,123.97 96.73,124.5 96.47,124.77 92.85,124.77 92.78,124.83 92.78,125.91 92.85,125.97 93.61,125.97 93.61,126.8 93.67,126.86 97.93,126.86 98.08,127.01 99.62,127.01 99.64,127.04
GND on BOTTOM (solid shape): 97.87,95.61 97.87,95.34 97.82,95.29 97.78,95.23 97.53,94.98 97.53,94.37 97.38,94.22 96.98,94.22 96.8,94.4 96.8,95.15 96.75,95.19 96.75,95.2 96.7,95.29 96.62,95.36 96.6,95.38 96.6,95.57 96.73,95.71 97,95.71 97.1,95.61 97.12,95.6 97.32,95.56 97.48,95.69 97.49,95.7 97.52,95.73 97.74,95.73
GND on BOTTOM (solid shape): 99.39,95.71 99.39,95.7 99.55,95.57 99.76,95.6 99.78,95.61 99.91,95.73 100.1,95.73 100.23,95.61 100.23,95.41 99.85,95.03 99.85,94.4 99.72,94.27 99.31,94.27 99.2,94.39 99.2,95.14 99.1,95.23 99.1,95.24 99.04,95.32 98.96,95.38 98.96,95.59 99.02,95.63 99.06,95.7 99.1,95.73 99.36,95.73
GND on BOTTOM (solid shape): 109.69,95.6 109.69,95.35 109.62,95.29 109.58,95.21 109.58,95.2 109.36,94.98 109.36,94.37 109.21,94.21 108.8,94.21 108.62,94.39 108.62,95.14 108.56,95.2 108.56,95.21 108.5,95.3 108.42,95.37 108.42,95.56 108.56,95.7 108.83,95.7 108.87,95.66 108.89,95.63 108.94,95.59 109.13,95.56 109.29,95.68 109.33,95.73 109.56,95.73
GND on BOTTOM (solid shape): 228.23,48.89 228.23,47.74 228.74,47.23 229.12,47.23 229.24,47.11 229.24,45.46 229.12,45.33 228.72,45.33 228.66,45.39 228.66,45.84 228.65,45.85 228.65,45.93 228.43,46.14 227.59,46.14 227.44,46.29 226.76,46.29 226.55,46.09 226.55,45.3 227.19,44.67 227.19,43.83 227.04,43.68 225.18,43.68 224.93,43.43 224.39,43.43 224.34,43.42 223.91,43.42 223.53,43.04 222.45,43.04 221.97,43.53 221.19,43.53 221.12,43.6 221.12,43.7 221.19,43.78 221.98,43.78 222.51,44.31 225.18,44.31 225.69,44.82 225.69,45.96 225.31,46.35 225.31,48.89 225.56,49.14 227.97,49.14
GND on BOTTOM (solid shape): 298.46,25.14 298.08,24.29 298.81,23.72 307.4,23.72 307.57,23.64 307.65,23.47 307.65,21.86 296.4,21.86 296.1,22.16 296.1,24.73 296.5,25.14
GND on BOTTOM (solid shape): 254.5,17.31 254.58,17.28 254.6,17.19 254.71,16.87 255.03,16.79 255.06,16.8 255.29,16.57 255.29,14.33 254.92,13.96 252.92,13.96 252.59,14.29 252.59,15.23 252.46,15.36 252.44,15.36 252.38,15.38 252.32,15.39 251.69,15.39 251.62,15.38 251.57,15.36 251.47,15.36 251.22,15.1 249.82,15.1 249.44,15.48 248.5,15.48 248.45,15.53 248.45,15.69 248.5,15.74 249.44,15.74 249.95,16.25 253.17,16.25 253.32,16.4 253.32,17.08 253.55,17.31
GND on BOTTOM (solid shape): 178.83,43.6 178.83,43.35 178.9,43.32 178.98,43.31 179,43.31 179.05,43.26 179.05,43.13 179.05,43.13 179.05,42.29 178.99,42.21 178.96,42.12 178.96,42.11 178.92,42.07 178.22,42.07 177.97,42.33 177.51,42.33 177.34,42.49 177.34,42.5 177.24,42.61 177.1,42.64 176.95,42.64 176.84,42.54 176.84,42.33 177.02,42.15 177.02,41.98 176.97,41.93 176.54,41.93 176.44,42.03 176.44,42.43 176.16,42.71 176.16,43.07 176.44,43.35 176.57,43.35 176.57,43.35 177.08,43.35 177.2,43.47 177.2,43.78 177.33,43.91 178.52,43.91
GND on BOTTOM (solid shape): 130.18,126.86 130.18,124.45 130.48,124.16 130.61,124.16 130.74,124.12 130.88,124.16 131.29,124.16 131.58,124.44 131.74,124.44 131.75,124.45 131.92,124.62 132.58,124.62 133.06,125.1 133.32,125.1 133.37,125.15 136.09,125.15 136.71,125.77 139.02,125.77 139.09,125.84 139.71,125.84 139.94,125.61 139.94,122.07 139.71,121.84 139.71,119.27 139.53,119.09 137.27,119.09 137.08,119.29 137.08,120.41 137.07,120.41 137.07,122.65 136.36,123.36 135.19,123.36 135.01,123.54 132.7,123.54 132.5,123.33 131.4,123.33 131.1,123.03 131.1,119.07 130.64,118.61 127.98,118.61 127.67,118.3 127.24,118.3 127.11,118.43 127.11,121.07 127.31,121.28 128.79,121.28 128.91,121.4 128.91,121.54 129.07,121.86 128.91,122.18 128.91,122.19 128.76,122.19 128.58,122.37 128.58,123.76 128.53,123.82 127.9,123.82 126.82,124.89 123.2,124.89 123.14,124.96 123.14,126.04 123.2,126.1 123.96,126.1 123.96,126.93 124.03,126.99 128.28,126.99 128.47,127.18 129.87,127.18
GND on BOTTOM (solid shape): 146.69,70.6 146.9,70.6 147.08,70.42 147.08,68.82 146.31,68.06 144.03,68.06 143.77,67.81 143.77,63.36 144.28,62.86 146.31,62.86 147.08,62.09 147.08,60.44 146.44,59.81 142.38,59.81 141.23,60.95 141.23,63.28 141.28,63.29 141.56,63.64 141.28,63.99 141.23,64 141.23,65.12 141.27,65.19 141.34,65.22 141.72,65.57 141.34,65.93 141.27,65.96 141.23,66.03 141.23,66.79 142.36,67.91 142.63,68.16 142.88,68.43 143.9,69.46 143.9,70.98 144.15,71.24 146.06,71.24
GND on BOTTOM (solid shape): 289.89,107.9 289.59,106.37 288.72,105.07 285.43,101.78 285.43,101.78 284.54,100.9 284.25,101.36 283.21,102.88 282.11,104.35 281.99,104.56 281.94,104.81 281.94,107.9 282.01,108.64 282.22,109.35 282.35,109.65 282.83,110.53 286.12,116.65 286.39,116.94 286.78,117.05 289.19,117.05 289.56,117.1 289.89,117.26
GND on BOTTOM (solid shape): 84.64,8.57 88.64,12.57 92.64,8.57 92.64,5.5 92.05,5.5 91.57,5.41 91.17,5.14 90.75,4.72 90.51,4.56 90.23,4.5 87.05,4.5 86.77,4.56 86.53,4.72 86.11,5.14 85.71,5.41 85.23,5.5 84.64,5.5
GND on BOTTOM (solid shape): 61.46,56.89 54.56,54.68 54.38,54.88 54.22,55.09 54.18,55.16 54.13,55.25 54.05,55.69 53.91,56.11 53.67,57.97 54.36,59.71 54.61,60.06 54.86,60.41 54.98,60.52 55.13,60.63 55.34,60.77
GND on BOTTOM (solid shape): 173.28,26.1 173.33,26.04 173.6,25.82 173.92,25.97 174,26.01 174.08,25.97 174.13,25.92 174.19,25.89 174.24,25.81 174.21,25.72 174.14,25.65 174.12,25.66 173.81,25.38 174.16,25.17 174.26,25.16 174.3,25.05 174.14,24.89 174.11,24.89 173.98,24.88 173.87,24.8 173.8,24.76 173.73,24.78 173.6,24.83 173.47,24.82 173.4,24.84 173.35,24.89 173.23,25.05 173.04,25.08 172.97,25.1 172.92,25.16 172.92,25.19 172.94,25.29 173.03,25.32 173.34,25.53 173.12,25.82 173.1,25.82 172.91,26.02 172.92,26.06 172.95,26.09 172.99,26.1 173.09,26.08 173.19,26.1
GND on BOTTOM (solid shape): outline of 171 points within 296.58,36.26 307.49,44.42
GND on BOTTOM (solid shape): 177.18,28.61 177.24,28.54 177.32,28.5 177.37,28.45 177.38,28.39 177.39,28.27 177.44,28.15 177.45,28.06 177.38,28 177.18,27.83 177.23,27.58 177.25,27.5 177.2,27.43 177.12,27.34 177.09,27.23 177.09,27.18 177.32,26.95 177.55,27.18 177.55,27.23 177.54,27.3 177.51,27.37 177.49,27.45 177.54,27.52 177.59,27.55 177.63,27.6 177.7,27.64 177.77,27.61 177.83,27.58 177.9,27.57 177.96,27.57 178.03,27.54 178.06,27.47 178.06,26.8 178.02,26.76 177.99,26.78 177.95,26.79 177.91,26.79 177.86,26.79 177.75,26.76 177.68,26.68 177.62,26.63 177.53,26.64 177.48,26.66 177.43,26.67 177.38,26.67 177.32,26.66 177.28,26.64 177.19,26.63 177.13,26.7 177.04,26.82 176.91,26.87 176.84,26.91 176.82,26.99 176.8,27.13 176.72,27.26 176.69,27.29 176.81,27.41 176.82,27.41 177.01,27.61 176.88,27.84 176.83,27.91 176.85,28 176.85,28.35 177.09,28.59 177.09,28.64 177.17,28.64
GND on BOTTOM (solid shape): 167.33,43.55 167.33,43.42 167.3,43.41 167.22,43.33 167.19,43.22 167.19,43.17 167.2,43.09 167.26,43.02 167.29,42.94 167.26,42.87 167.2,42.8 167.19,42.71 167.19,42.66 167.21,42.57 167.28,42.49 167.32,42.43 167.31,42.35 167.26,42.22 167.29,42.09 167.3,42.01 167.24,41.95 167.15,41.87 167.1,41.76 167.1,41.73 166.99,41.66 166.97,41.67 166.81,41.71 166.65,41.67 166.56,41.67 166.5,41.74 166.47,41.81 166.41,41.87 166.37,41.95 166.4,42.03 166.44,42.07 166.49,42.09 166.53,42.06 166.61,41.94 166.75,41.9 166.8,41.9 167.03,42.13 166.8,42.36 166.75,42.36 166.68,42.34 166.61,42.31 166.53,42.29 166.46,42.34 166.43,42.39 166.39,42.43 166.34,42.5 166.37,42.57 166.4,42.64 166.41,42.7 166.41,42.82 166.47,42.88 166.48,42.88 166.52,42.93 166.56,42.94 166.6,42.93 166.96,42.93 166.95,43.29 166.92,43.36 166.94,43.43 166.99,43.51 167,43.59 167,43.64 167.03,43.71 167.1,43.74 167.14,43.74
GND on BOTTOM (solid shape): 309.17,95.49 309.34,95.41 309.42,95.24 309.42,94.07 309.32,93.7 309.05,93.43 308.35,93.01 307.9,92.55 307.74,91.93 307.74,84.48 307.83,84 308.1,83.6 309.26,82.44 309.32,82.36 309.34,82.26 309.34,81.92 309.26,81.75 309.09,81.67 303.16,81.67 302.67,81.3 302.91,80.73 302.91,66.61 302.67,66.04 303.16,65.67 309.09,65.67 309.26,65.59 309.34,65.42 309.34,64.48 309.32,64.38 309.26,64.3 307.71,62.75 307.54,62.5 307.49,62.21 307.49,58.67 307.41,58.5 307.24,58.42 298.81,58.42 298.23,58.15 298.07,57.52 297,57.52 296.68,57.84 296.68,59.55 297.13,60 300.17,60 301.19,61.01 301.19,65.38 300.87,65.7 300.06,65.7 299.6,66.16 299.6,66.92 300.05,67.36 302.14,67.36 302.4,67.62 302.4,80.5 302.24,81.59 303.16,82.18 304.84,82.18 307.23,84.58 307.23,91.93 307.23,92 307.23,92.07 307.23,92.74 305.88,94.1 305.88,95.49
GND on BOTTOM (solid shape): 160.18,26.81 160.29,26.83 160.35,26.73 160.38,26.6 160.48,26.51 160.48,26.39 160.53,26.35 160.52,26.32 160.58,26 160.89,25.89 160.97,25.87 161.01,25.81 161.21,25.6 161.49,25.67 161.58,25.7 161.66,25.63 161.73,25.52 161.84,25.45 161.91,25.38 161.89,25.28 161.82,25.21 161.78,25.26 161.48,25.39 161.21,25.19 161.16,25.14 161.09,25.13 160.74,24.94 160.93,24.59 161,24.52 160.98,24.42 160.86,24.31 160.7,24.31 160.62,24.36 160.61,24.45 160.41,24.84 160.07,24.57 160.01,24.48 159.9,24.5 159.71,24.69 159.71,25.16 159.78,25.23 159.81,25.32 159.86,25.38 159.94,25.39 160.29,25.7 159.87,25.9 159.76,25.9 159.71,25.99 159.71,26.34 159.85,26.48 159.87,26.48 160.02,26.55 160.1,26.71 160.1,26.73
GND on BOTTOM (solid shape): outline of 2921 points within 0.25,0.25 309.42,134.55
GND on BOTTOM (solid shape): outline of 15291 points within 157.55,24.44 178.06,43.46
GND on IN1 (solid shape): 76.84,119.62 76.84,112.39 74.56,110.1 72.4,110.1 72.02,110.48 72.02,119.75 72.15,119.88 76.59,119.88
GND on IN1 (solid shape): 177.56,17.26 177.56,15.1 177.3,14.85 173.42,14.85 172.6,15.66 172.6,16.8 173.2,17.4 177.42,17.4
GND on IN1 (solid shape): 269.63,44.19 269.63,40.38 269.25,40 265.06,40 264.8,40.25 264.8,43.68 265.57,44.44 269.38,44.44
GND on IN1 (solid shape): 187.33,46.22 187.33,42.15 187.21,42.03 183.78,42.03 183.27,42.54 183.27,44.19 182.64,44.82 182.64,46.35 183.27,46.98 186.57,46.98
GND on IN1 (solid shape): 224.55,38.09 224.55,36.06 224.42,35.93 220.1,35.93 219.97,36.06 219.97,38.14 220.2,38.37 221.9,38.37 222.01,38.47 224.16,38.47
GND on IN1 (solid shape): 281.44,46.98 281.44,43.04 281.7,42.79 281.7,42.41 281.06,41.77 278.32,41.77 277.63,42.46 277.63,46.47 278.27,47.11 281.31,47.11
GND on IN1 (solid shape): 179.97,72.91 179.97,69.61 179.66,69.31 175.73,69.31 175.62,69.41 175.62,70.03 175.35,70.3 175.35,72.58 175.83,73.07 179.81,73.07
GND on IN1 (solid shape): 298.56,25.18 298.07,24.34 298.81,23.72 305.84,23.72 307.4,23.72 307.57,23.64 307.65,23.47 307.65,21.86 293.38,21.86 292.72,22.52 292.72,24.37 293.63,25.29 298.56,25.29
GND on IN1 (solid shape): 309.17,95.49 309.34,95.41 309.42,95.24 309.42,94.07 309.32,93.7 309.05,93.43 308.35,93.01 307.9,92.55 307.74,91.93 307.74,84.48 307.83,84 308.1,83.6 309.26,82.44 309.32,82.36 309.34,82.26 309.34,81.92 309.26,81.75 309.09,81.67 303.16,81.67 302.67,81.3 302.91,80.73 302.91,66.61 302.67,66.04 303.16,65.67 309.09,65.67 309.26,65.59 309.34,65.42 309.34,64.48 309.32,64.38 309.26,64.3 307.71,62.75 307.54,62.5 307.49,62.21 307.49,58.67 307.41,58.5 307.24,58.42 298.81,58.42 298.23,58.15 298.07,57.52 297.57,57.52 296.3,57.52 296.05,57.78 296.05,59.71 296.43,60.09 299.4,60.09 301.03,61.71 301.03,64.23 299.63,65.62 299.63,66.87 299.93,67.17 302.22,67.17 302.4,67.35 302.4,79.95 302.14,80.2 299.93,80.2 299.6,80.53 299.6,82.24 300.16,82.79 303.67,82.79 305.83,84.95 305.83,86.86 307.23,88.26 307.23,91.93 307.23,92.04 307.23,92.62 305.83,94.02 305.83,95.49
GND on IN1 (solid shape): outline of 201 points within 295.46,35.91 307.49,46.07
GND on IN1 (solid shape): outline of 245 points within 96.53,117.34 130.95,127.12
GND on IN1 (solid shape): outline of 305 points within 0.25,0.25 309.42,134.55
GND on VCC (solid shape): outline of 924 points within 276.68,0.25 308.47,17.62
GND on IN2 (solid shape): 177.56,17.26 177.56,15.1 177.3,14.85 173.21,14.85 172.6,15.46 172.6,16.88 173.14,17.41 177.4,17.41
GND on IN2 (solid shape): 269.63,44.19 269.63,40.5 269.5,40.38 269.12,40.38 268.74,40.76 264.93,40.76 264.8,40.88 264.8,43.68 265.57,44.44 269.38,44.44
GND on IN2 (solid shape): 281.44,46.98 281.44,43.3 281.7,43.04 281.7,42.41 281.06,41.77 278.34,41.77 277.63,42.48 277.63,46.47 278.27,47.11 281.31,47.11
GND on IN2 (solid shape): 187.33,46.22 187.33,42.15 187.21,42.03 182.38,42.03 182,42.41 182,42.79 182.13,42.92 182.51,42.92 182.64,43.04 182.64,46.35 183.27,46.98 186.57,46.98
GND on IN2 (solid shape): 224.55,38.09 224.55,36.06 224.49,36 220.03,36 219.8,36.24 219.8,36.39 219.97,36.57 219.97,38.14 220.18,38.34 221.88,38.34 222.01,38.47 224.16,38.47
GND on IN2 (solid shape): 204.35,71.11 204.35,68.7 204.1,68.44 201.3,68.44 201.05,68.7 201.05,69.84 200.92,69.97 198.76,69.97 198.64,69.84 198.64,68.7 198.38,68.44 195.21,68.44 194.83,68.82 194.83,71.62 194.95,71.75 203.72,71.75
GND on IN2 (solid shape): 298.56,25.18 298.07,24.34 298.81,23.72 305.51,23.72 307.4,23.72 307.57,23.64 307.65,23.47 307.65,22.95 307.65,21.86 293.38,21.86 292.72,22.52 292.72,24.37 293.63,25.29 298.56,25.29
GND on IN2 (solid shape): 88.13,101.45 88.13,99.74 87.8,99.41 87.8,98.78 86.37,97.35 86.36,97.35 86.25,96.76 86.84,96.91 86.84,96.92 87.18,97.26 87.29,97.28 87.35,97.18 87.35,96.5 83.92,93.07 83.89,93.07 83.77,93.1 83.64,93.09 83.55,93.11 83.51,93.19 83.51,93.89 83.55,93.97 83.63,93.99 83.86,94.04 84.02,94.22 84.02,94.24 84.88,95.1 84.88,99.24 85,99.35 86.05,99.35 86.05,98.49 86.18,97.97 86.68,98.17 86.7,98.29 86.69,98.38 86.69,100.97 87.41,101.69 87.89,101.69
GND on IN2 (solid shape): 309.17,95.49 309.34,95.41 309.42,95.24 309.42,94.07 309.32,93.7 309.05,93.43 308.35,93.01 307.9,92.55 307.74,91.93 307.74,84.48 307.83,84 308.1,83.6 309.26,82.44 309.32,82.36 309.34,82.26 309.34,81.92 309.26,81.75 309.09,81.67 303.16,81.67 302.67,81.3 302.91,80.73 302.91,66.61 302.67,66.04 303.16,65.67 309.09,65.67 309.26,65.59 309.34,65.42 309.34,64.48 309.32,64.38 309.26,64.3 307.71,62.75 307.54,62.5 307.49,62.21 307.49,58.67 307.41,58.5 307.24,58.42 298.81,58.42 298.23,58.15 298.07,57.52 297.57,57.52 296.3,57.52 296.05,57.78 296.05,59.71 296.43,60.09 299.4,60.09 301.03,61.71 301.03,64.23 299.63,65.62 299.63,66.87 299.93,67.17 302.22,67.17 302.4,67.35 302.4,79.95 302.14,80.2 299.93,80.2 299.6,80.53 299.6,82.24 300.16,82.79 303.67,82.79 305.83,84.95 305.83,86.86 307.23,88.26 307.23,91.93 307.23,92.04 307.23,92.62 305.83,94.02 305.83,95.49
