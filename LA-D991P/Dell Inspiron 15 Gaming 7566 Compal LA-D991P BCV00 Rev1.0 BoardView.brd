# Allegro board Dell Inspiron 15 Gaming 7566 Compal LA-D991P BCV00 Rev1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB_PWR_SHR_EN_R#: length 69.6
  TOP w0.102: UE1.109 229.45,30.39 229.4,30.34 v2(229.42,30.34) ; RI10.2 278.8,34.05 280.81,34.05 v2(281.04,34.28) 281.82,33.49 282.28,33.49 282.44,33.65 US1.6
  IN2 w0.127: v2(276.03,41.29) 276.03,41.19 274.99,40.15 269.05,40.15 268.64,40.55 262.97,40.55 261.69,39.27 258.81,39.27 258.18,38.64 258.18,37.84 257.54,37.2 256.2,37.2 253.33,34.33 246.88,34.33 244.36,31.82 233.03,31.82 232.01,30.8 229.7,30.8 229.46,30.56 229.46,30.4 229.4,30.34 v2(229.42,30.34)
  BOTTOM w0.102: v2(281.04,34.28) 281.04,37.07 281.62,37.66 281.62,38.32 279.03,40.91 276.41,40.91 v2(276.03,41.29)
USB_R_CTL: length 4.3
  TOP w0.102: v1(282.86,31.71) 283.27,32.12 RI9.2 ; US1.7 282.94,33.06 RI9.2 ; RI9.2 283.44,32.9 US1.8
USBCHG_DET#: length 3.5
  TOP w0.102: v2(223.02,30.47) 222.65,30.84 UE1.126
  BOTTOM w0.102: v1(224.52,30.9) 224.27,31.16 RE52.1 223.4,30.85 v2(223.02,30.47)
USBP1_R_D+: length 16.9
  IN3 w0.127: JUSB1.3 296.41,31.61 295.64,30.84 295.48,30.84 294.95,31.36 294.95,37.65 294.48,38.12 294.14,38.12 v2(293.96,38.3)
  BOTTOM w0.102: LI2.3 289.37,36.31 289.52,36.16 289.69,36.16 291.39,37.86 291.58,37.86 291.77,38.05 291.77,38.36 DI10.2 292.14,37.96 292.24,37.86 292.97,37.86 293.19,38.09 293.75,38.09 v2(293.96,38.3)
USBP1_R_D-: length 16.9
  IN3 w0.127: v2(293.96,37.67) 294.17,37.87 294.37,37.87 294.7,37.54 294.7,31.26 295.37,30.58 295.69,30.58 296.41,29.87 JUSB1.2
  BOTTOM w0.102: v2(293.96,37.67) 293.75,37.88 293.27,37.88 293.05,37.66 292.24,37.66 292.14,37.56 DI10.3 291.77,37.16 291.77,37.48 291.59,37.66 291.47,37.66 289.77,35.96 289.51,35.96 289.36,35.81 LI2.2
USBP2_D+: length 32
  TOP w0.102: v2(285.3,35.45) 285.1,35.65 284.79,35.65 284.64,35.5 US1.10
  IN1 w0.114: v2(285.3,35.45) 285.48,35.62 285.5,35.62 285.55,35.68 290.42,35.68 292.36,37.62 292.36,39.08 292.84,39.56 292.84,44.43 291.74,45.53 290.82,45.53 289.04,47.31 289.04,54.07 287.69,55.42 287.38,55.42 v2(287.16,55.64)
  BOTTOM w0.102: v2(287.16,55.64) 287.16,55.49 287.39,55.26 287.84,55.26 287.93,55.36 LI5.4
USBP2_D-: length 32
  TOP w0.102: US1.11 284.62,36 284.77,35.85 285.15,35.85 v2(285.32,36.03)
  IN1 w0.114: v2(287.16,54.73) 287,54.73 286.88,54.85 286.88,55.08 286.99,55.19 287.59,55.19 288.81,53.97 288.81,47.22 290.73,45.3 291.65,45.3 292.62,44.34 292.62,39.65 292.14,39.17 292.14,37.71 290.33,35.9 285.46,35.9 v2(285.32,36.03)
  BOTTOM w0.102: v2(287.16,54.73) 287.16,54.82 287.39,55.06 287.73,55.06 287.93,54.86 LI5.1
USBP2_R_D+: length 15.2
  IN3 w0.127: JUSB2.3 296.41,51.67 296.28,51.55 295.32,51.55 294.75,52.11 294.75,56.69 294.01,57.42 v2(294.01,57.62)
  BOTTOM w0.102: v2(294.01,57.62) 293.41,57.01 292.92,57.01 292.77,57.17 DI8.2 292.36,57.44 292.36,57.13 292.2,56.97 292.08,56.97 290.32,55.21 290.18,55.21 290.03,55.36 LI5.3
USBP2_R_D-: length 15.1
  IN3 w0.127: v2(294.01,56.35) 294.01,56.68 294.1,56.77 294.31,56.77 294.5,56.58 294.5,52.01 295.21,51.29 296.24,51.29 296.41,51.12 JUSB2.2
  BOTTOM w0.102: v2(294.01,56.35) 293.56,56.81 292.94,56.81 292.77,56.64 DI8.3 292.36,56.33 292.36,56.66 292.26,56.76 292.17,56.76 290.41,55.01 290.23,55.01 290.08,54.86 LI5.2
VCIN0_PH: length 220.4
  TOP w0.254: HT1.1 CT80.1 RT1.2 108.06,83.53 v2(108.29,83.3)
  IN2 w0.254: v2(236.75,33.37) 235.2,34.92 233.78,34.92 231.33,37.36 229.2,37.36 228.94,37.1 227.62,37.1 227.18,36.66 227.18,35.59 226.26,34.67 221.63,34.67 220.82,33.86 220.82,33.32 220.56,33.06 209.29,33.06 206.61,35.73 188.67,35.73 185.32,32.38 184.49,32.38 181.58,29.46 181.58,29.15 181.3,28.88 180.21,28.88 178.38,30.7 178.38,34.27 177.51,35.14 174.08,35.14 173.75,35.47 172.06,35.47 171.52,36.01 170.44,36.01 169.92,35.49 169.92,32.07 169.44,31.59 165.06,31.59 164.51,32.14 164.51,33.18 164.17,33.52 163.68,33.52 162.72,34.49 162.72,35.58 161.27,37.02 160.62,37.02 159.68,37.96 158.04,37.96 157.56,38.45 156.5,38.45 155.86,37.8 155.84,37.8 154.05,36.01 154.05,34.25 151.84,32.04 148.4,32.04 148.16,31.8 145.74,31.8 138.95,38.59 138.95,41.14 139.46,41.65 139.46,43.02 138.25,44.22 138.25,50.79 137.47,51.56 137.47,53.96 138.06,54.54 138.06,66.54 134.12,70.48 134.12,74.79 135.14,75.81 135.14,78.35 134.63,78.86 134.63,80.8 133.26,82.17 v2(133.26,82.79)
  IN3 w0.127: 124.01,84.06 124.29,84.34 126.27,84.34 126.86,83.76 126.65,83.56 124.22,83.56 124.01,83.76 124.01,84.06
  IN3 w0.254: 126.86,83.76 126.98,83.89 132.52,83.89 133.26,83.15 v2(133.26,82.79) ; v2(108.29,83.3) 108.29,83.66 109.33,84.7 119.42,84.7 119.67,84.95 122.79,84.95 123.68,84.06 124.01,84.06
  BOTTOM w0.254: v2(236.75,33.37) v1(235.51,32.12) 232.98,32.12 231.51,30.64 231.51,30.17 231.79,29.89 233.46,29.89 234.71,28.64 234.71,27.8 233.64,26.74 RE73.2
VCORE_B+: length 106.6
  IN1 w0.508: 105.04,133.47 89.42,133.47 88.53,132.58 88.53,127.88 85.1,124.45 64.58,124.45 63.48,123.36 63.48,93.72 63.69,93.51 63.69,88.48 63.28,88.08 63.28,86.91 63.79,86.4 66.33,86.4 66.89,85.84 68.62,85.84 69.93,84.53 75.95,84.53 76.12,84.36 v2(77.38,84.36)
  BOTTOM w0.508: PR1102.1 75.5,80.69 77.38,82.57 v2(77.38,84.36)
  vias: v2(107.58,129.66) v2(108.21,130.29) v2(108.21,129.66) v2(108.85,130.29) v2(108.85,129.66) v2(109.48,130.29) v2(109.48,129.66) v2(117.13,129.81) v2(117.13,129.23) v2(117.76,129.81) v2(117.76,129.23) v2(118.07,128.13) v2(118.4,129.81) v2(118.4,129.23) v2(118.37,128.64) v2(118.37,127.6) v2(119.03,129.81) v2(119.03,129.23) v2(119.01,128.64) v2(119.67,129.81) v2(119.67,129.23) v2(119.64,128.64) v2(120.3,129.81) v2(120.3,129.23) v2(120.28,128.64) v2(127.64,130.42) v2(127.64,129.78) v2(127.64,129.15) v2(128.28,130.17) v2(128.28,129.53) v2(128.91,130.17) v2(128.91,129.53) v3(106.23,128.74)
VCREF0: length 8.1
  TOP w0.102: v2(221.42,18.71) 221.43,18.72 221.43,20.22 221.12,20.54 UE1.25
  BOTTOM w0.102: CE91.1 RE35.1 RE34.2 223.42,20.12 222.95,19.65 v1(222.23,19.65) 221.62,19.04 221.62,18.91 v2(221.42,18.71)
VGA_CLK_REQ#: length 81
  TOP w0.102: v2(157.39,19.17) 157.39,19.12 157.9,18.61 158.38,18.61 158.64,18.88 158.64,19.61 161.59,22.56 161.59,23.12 162.37,23.89 v2(162.37,23.94) ; v2(144.13,71.75) 144.13,71.9 145.2,72.96 147.36,72.96 148.23,73.84 QV3.3
  IN1 w0.114: v2(162.37,23.94) 160.21,23.94 158.2,25.95 149.67,25.95 146.29,29.33 146.29,30.37 144.6,32.06 144.6,33.63 144.26,33.98 144.26,40.57 139.13,45.7 139.13,64.55 143.88,69.3 143.88,71.49 v2(144.13,71.75)
  BOTTOM w0.089: UH2.BA33 162.44,24.02 v2(162.37,23.94)
  BOTTOM w0.102: RP23.5 156.96,18.74 v2(157.39,19.17)
VGA_CRT_CLK: length 6.5
  BOTTOM w0.102: RV510.1 169.45,74.44 169.45,75.52 169.85,75.92 170.15,75.92 170.34,75.74 170.64,75.74 170.86,75.96 170.86,78.05 170.49,78.42 UV1.R4
VGA_CRT_DATA: length 7.5
  BOTTOM w0.102: UV1.R5 170.65,79.31 170.9,79.05 170.9,78.37 171.15,78.12 171.5,78.12 171.72,77.9 171.72,75.97 170.84,75.1 170.42,75.1 170.3,74.98 170.3,74.47 RV511.1
VGA_EDID_CLK: length 3.7
  BOTTOM w0.102: UV1.R2 170.49,76.89 169.22,75.62 RV514.1
VGA_EDID_DATA: length 6
  BOTTOM w0.102: UV1.R3 170.49,77.68 170.09,77.28 170.09,76.84 169.57,76.32 169.57,76.29 168.78,75.51 168.78,74.23 RV515.1 v1(167.17,73.78)
VGA_SMB_CK2: length 28.3
  IN1 w0.114: v2(152.18,72.08) 151.75,72.51 149.27,72.51 v2(148.51,73.27)
  BOTTOM w0.102: v2(152.18,72.08) 152.41,71.84 155.18,71.84 156.2,72.86 159.8,72.86 RV191.1 160.74,73.35 160.74,73.19 162.01,71.92 164.25,71.92 164.98,72.65 164.98,73.17 167.53,75.71 167.53,77.85 167.77,78.1 169.23,78.1 UV1.T4 ; QV1.1 148.91,73.67 v2(148.51,73.27)
VGA_SMB_DA2: length 27.9
  IN1 w0.114: v2(151.6,72.08) 151.19,71.67 149.38,71.67 148.33,72.71 v2(147.86,72.71)
  BOTTOM w0.102: QV1.4 147.52,72.37 v2(147.86,72.71) ; v2(151.6,72.08) 151.95,71.72 151.96,71.72 152.09,71.59 155.25,71.59 156.3,72.63 159.8,72.63 RV192.1 160.84,72.25 161.36,72.25 161.92,71.69 164.35,71.69 165.21,72.56 165.21,73.07 167.85,75.71 168.18,75.71 168.4,75.94 168.4,77.08 168.66,77.33 169.26,77.33 UV1.T3
VR_CAP: length 3.4
  TOP w0.102: CE103.1 218.3,22.72 T4931.1 218.92,23.34 UE1.18
VR_ON: length 243.3
  TOP w0.102: UZ21.4 185.83,22.99 185.43,22.6 RZ71.1 184.92,22.67 184.92,22.85 185.58,23.51 185.86,23.51 186.19,23.84 186.19,27.83 188.07,29.71 188.07,31.18 189.49,32.6 189.49,33.65 192.53,36.69 v2(192.53,37.06) ; UC16.2 136.36,76.32 136.85,76.81 v1(136.85,77.7) 137.34,78.19 139.42,78.19 140.19,78.96 140.81,78.96 142.79,80.95 144.59,80.95 145.41,81.76 146.42,81.76 v2(146.67,82.02)
  IN2 w0.127: v2(146.67,82.02) 146.68,82.02 146.68,82.62 143.19,86.11 143.19,99.02 142.07,100.14 v2(141.37,100.14)
  IN3 w0.127: v2(192.53,37.06) 192.72,37.25 192.72,47.08 186.32,53.48 186.32,57.04 184.5,58.85 184.5,59.57 183.34,60.72 181.06,60.72 174.41,67.37 174.41,72.33 174,72.74 173.77,72.74 172.75,73.75 172.35,73.75 170.06,76.04 170.06,76.22 168.51,77.77 157.03,77.77 156.2,78.6 156.2,81.29 153.68,83.81 153.68,89.07 142.61,100.14 v2(141.37,100.14) 138.97,100.14 131.19,107.92 85.7,107.92 78.1,100.33 78.1,95.76 78.72,95.14 78.72,92.9 76.84,91.02 76.84,87.87 73.21,84.24 69.58,84.24 v2(67.75,82.41)
  BOTTOM w0.102: PR1120.1 67.32,82.84 v2(67.75,82.41)
VR_SVID_ALERT#: length 20.2
  TOP w0.102: v2(70.29,82.34) 70.29,82.46 72.45,84.62 74.51,84.62 77.51,87.62 v3(79.25,87.62) 80.65,87.62 83.22,90.19 84.03,90.19 RH152.2 85.86,91.13 RH153.1
  BOTTOM w0.102: PR1107.1 70.29,82.79 v2(70.29,82.34)
VR_SVID_ALERT#_C: length 3
  BOTTOM w0.102: PU1100.44 71.14,85.17 PR1107.2
VR_SVID_ALERT#_R: length 8.5
  TOP w0.102: RH153.2 86.93,91.18 89.62,93.87 91.45,93.87 92.93,95.35 v2(92.93,95.46)
  BOTTOM w0.102: v2(92.93,95.46) 92.58,95.81 UH1.BH31
VR_SVID_CLK: length 32.3
  TOP w0.102: v2(92.14,96.78) 92.14,95.42 91.15,94.43 89.39,94.43 86.69,91.73 86.4,91.73 86.34,91.68 84.52,91.68 84.29,91.46 84.29,91.28 83.78,90.77 82.33,90.77 81.29,89.73 81.29,89.05 80.42,88.18 77.28,88.18 74.46,85.36 72.37,85.36 v3(70.23,83.22) 69.68,82.67 v2(69.68,82.34)
  BOTTOM w0.076: UH1.BH32 92.46,96.46 v2(92.14,96.78)
  BOTTOM w0.102: PR1108.1 69.68,82.51 v2(69.68,82.34) 69.68,81.7 PR1103.2
VR_SVID_CLK_C: length 3.2
  BOTTOM w0.102: PU1100.45 70.74,85.66 v1(70.08,84.99) PR1108.2
VR_SVID_DATA: length 34
  TOP w0.102: v2(93.08,93.5) 92.08,93.5 91.32,92.75 89.29,92.75 RH151.2 87.22,89.9 87.22,89.23 85,87.01 85,86.02 84.52,85.54 82.33,85.54 v3(81.58,86.29) 80.88,86.99 77.66,86.99 74.74,84.06 72.78,84.06 70.85,82.13 70.85,82.11 70.52,81.78 70.49,81.78 70.37,81.65 v2(70.24,81.65)
  BOTTOM w0.076: UH1.BH29 93.08,94.04 v2(93.08,93.5)
  BOTTOM w0.102: PR1106.1 PR1104.2 70.29,81.6 v2(70.24,81.65)
VR_SVID_DATA_C: length 2.8
  BOTTOM w0.102: PU1100.43 71.54,85.09 v1(71.41,84.95) 70.88,84.42 PR1106.2
VREF_CPU: length 4.5
  TOP w0.203: UE1.95 236.9,29.74
  TOP w0.254: 236.9,29.74 237.12,29.96 v2(237.12,30.47)
  BOTTOM w0.254: RE116.1 CE77.1 236.05,30.11 v1(236.43,30.5) 237.09,30.5 v2(237.12,30.47)
VSB_N_001: length 5.7
  BOTTOM w0.102: v1(208.65,64.43) 208.65,63.82 208.9,63.57 PR106.2
  BOTTOM w0.254: PR107.1 209.26,62.93 PR106.2 208.9,62.41 PC113.2 209.09,61.37 208.44,60.72 PQ102.4
VSB_N_002: length 3.9
  BOTTOM w0.102: PQ103.2 211.82,63.64 212,63.46 212.33,63.46 212.47,63.61 PQ103.3 212.59,64.13 PR110.2 214.13,64.13 v1(214.56,64.56)
VSB_N_003: length 2.9
  BOTTOM w0.102: v1(212.2,60.8) 211.45,61.55 211.45,61.83 PQ103.6
  BOTTOM w0.254: PR107.2 210.11,62.11 PQ103.6
WLAN_CLK_REQ#: length 45.7
  TOP w0.102: v2(161.07,20.01) 161.07,19.78 161.36,19.49 162.17,19.49 162.32,19.64 RP3.7
  IN3 w0.127: v2(161.07,20.01) 161.17,19.9 163.15,19.9 163.94,20.69 166.91,20.69 v2(167.22,21) 167.22,20.06 167.6,19.68 170.03,19.68 170.28,19.42 170.41,19.42 171.07,18.76 172.81,18.76 173.16,18.41 175.82,18.41 177.04,19.62 180.85,19.62 181.58,20.36 185,20.36 185.66,21.02 186.61,21.02 188.01,22.42 188.83,22.42 190.05,23.64 197,23.64 197.27,23.37 197.27,23.25 v2(197.27,23.24)
  BOTTOM w0.076: UH2.BD25 167.19,22.26 167.19,21.03 v2(167.22,21)
  BOTTOM w0.102: v2(197.27,23.24) 197.27,23.08 197.31,23.04 JNGFF1.45
WLAN_WIGIG60GHZ_DIS#: length 43.2
  IN3 w0.127: v2(197.8,32.27) 196.89,33.19 195.59,33.19 195.41,33.37 192.97,33.37 192.34,32.73 189.8,32.73 187.21,30.14 185.89,30.14 185.36,29.61 182.7,29.61 181.66,28.57 180.09,28.57 179.81,28.29 177.35,28.29 176.49,27.42 176.4,27.42 175.35,27.42 175.03,27.73 174.55,27.73 174.42,27.6 171.84,27.6 171.82,27.57 169.96,27.57 169.73,27.35 168.79,27.35 167.95,26.51 166.56,26.51 166.23,26.18 166.23,25.69 165.49,24.96 165.49,23.92 165.74,23.66 v2(165.77,23.66)
  BOTTOM w0.102: UH2.BC27 165.82,23.18 165.77,23.23 v2(165.77,23.66) ; v2(197.8,32.27) 197.88,32.35 v1(197.88,34.03) 197.88,35.8 197.37,36.31 DN1.1
WLAN_WIGIG60GHZ_DIS#_R: length 5.9
  BOTTOM w0.102: JNGFF1.48 v1(198.06,31.4) 197.32,32.14 197.32,34.93 DN1.2
XDP_PRDY#: length 182.2
  IN1 w0.114: v2(182.41,26.76) 182.34,26.7 179.06,26.7 178.92,26.56 176.2,26.56 175.91,26.84 173.52,26.84 173.49,26.81 172.23,26.81 171.73,26.3 171.69,26.3 171.69,26.3 171.35,26.3 171.35,26.3 169.71,26.3 169.48,26.53 168.31,26.53 167.25,27.59 165.33,27.59 163.8,29.12 163.8,29.59 163.48,29.91 162.3,29.91 162.11,30.1 160.75,30.1 159.83,31.03 153.59,31.03 153.35,31.27 152.82,31.27 151.01,33.07 151.01,35.86 146.25,40.62 146.25,41.35 141.06,46.55 141.06,62.29 146.59,67.82 146.59,70.83 146.9,71.13 146.9,72.3 144.29,74.91 144.29,75.7 v2(144.27,75.72)
  IN2 w0.127: v2(144.27,75.72) 143.25,75.72 136.74,82.24 136.74,94.1 135.56,95.28 135.56,96.14 135.07,96.62 135.07,98.7 133.38,100.39 132.4,100.39 128.57,104.23 122.52,104.23 121.51,103.22 118.78,103.22 118.45,102.89 110.17,102.89 109.56,102.28 100.82,102.28 100.21,102.89 90,102.89 89.47,102.35 89.47,99.56 90.1,98.93 90.1,98.36 90.31,98.16 90.31,97.75 90.02,97.46 89.61,97.46 89.3,97.77 88.32,97.77 88.05,97.5 88.05,96.21 87.23,95.39 87.23,92.92 v2(86.93,92.62)
  BOTTOM w0.076: UH2.AT4 177.63,26.46 177.74,26.36 178.54,26.36 178.59,26.4 181.38,26.4 181.52,26.54 181.57,26.54 v1(181.8,26.76) v2(182.41,26.76) ; UH1.BP27 88.39,92.29 87.31,92.29 86.98,92.62 v2(86.93,92.62)
XDP_PREQ#: length 197
  IN1 w0.114: v2(144.76,81.78) 144.76,80.53 143.56,79.33 143.56,75.26 145.73,73.09 145.73,71.39 146.1,71.02 146.1,68.01 142.45,64.37 141.17,64.37 140.24,63.44 140.24,46.33 145.53,41.05 145.53,40.32 150.29,35.56 150.29,31.19 151.77,29.71 153.15,29.71 154.07,28.78 156.82,28.78 156.87,28.72 163.51,28.72 165.13,27.11 166.09,27.11 166.65,26.55 167.95,26.55 168.81,25.69 169.73,25.69 170.06,25.36 171.5,25.36 171.87,25.74 173.97,25.74 174.35,26.12 175.24,26.12 176.17,25.19 177.38,25.19 177.53,25.34 179.02,25.34 v2(179.16,25.2)
  IN2 w0.127: v2(144.76,81.78) 144.76,82.44 141.16,86.05 141.16,97.78 131.96,106.97 88.43,106.97 81.62,100.16 81.62,97.27 80.5,96.15 v2(80.5,94.53)
  BOTTOM w0.076: UH1.BL30 90.45,94.65 87.31,94.65 87,94.35 85.86,94.35 85.4,93.89 ; UH2.AT3 177.96,25.84 178.54,25.84 178.79,25.59 178.79,25.45 179.03,25.21 179.15,25.21 v2(179.16,25.2)
  BOTTOM w0.102: v1(80.5,95.21) v2(80.5,94.53) 80.5,93.39 80.75,93.14 80.75,93.1 81.12,92.73 82.48,92.73 83.02,93.26 RH156.2 83.02,93.67 83.24,93.89 85.4,93.89
XTAL24_IN: length 10.6
  BOTTOM w0.089: UH2.A6 176.53,43.61 177.22,44.31 178.65,44.31 178.78,44.44
  BOTTOM w0.127: 178.78,44.44 178.86,44.52 181.49,44.52 RH72.1 182.86,45.02 CH47.1 183.25,45 183.54,44.71 184.91,44.71 185.88,45.67 YH2.1
XTAL24_OUT: length 8
  BOTTOM w0.089: 179.03,43.88 178.78,44.13 177.3,44.13 176.96,43.79 UH2.A5
  BOTTOM w0.127: YH2.3 183.92,43.47 183.25,44.14 CH48.1 182.03,44.14 RH72.2 181.77,43.88 179.03,43.88
XTAL_OUT: length 8.2
  BOTTOM w0.102: YV1.3 177.9,70.94 177.9,72.75 CV71.2 178,73.7 RV52.2 177.74,74.06 177.74,74.54 177.1,75.19 177.1,76.14 176.33,76.91 UV1.H2
XTALIN: length 8.3
  BOTTOM w0.102: YV1.1 177.49,71.63 177.66,71.8 177.66,72.4 CV70.2 177.19,73.7 RV52.1 177.51,74.12 177.51,74.44 176.86,75.09 176.86,76.04 176.4,76.5 176.12,76.5 175.93,76.69 175.93,77.35 UV1.H3
XTALOUT: length 2.6
  TOP w0.102: v1(174.3,78.4) RV51.1 174.45,77.44 v2(175.11,78.1)
  BOTTOM w0.102: UV1.J4 175.49,78.48 v2(175.11,78.1)
XTALSSIN: length 3.3
  TOP w0.127: RV49.1 176.92,74.67 176.54,75.05 v2(176.26,75.05)
  BOTTOM w0.102: UV1.H1 176.44,75.96 176.44,75.22 v2(176.26,75.05)
  BOTTOM w0.127: v1(175.82,74.09) 175.82,74.62 176.25,75.05 v2(176.26,75.05)
XTLI: length 3.8
  BOTTOM w0.127: UL1.29 281.93,44.89 CL36.1 281.65,45 280.98,45.67 YL2.1
XTLO: length 6.3
  BOTTOM w0.127: UL1.28 282.18,44.49 CL37.1 281.69,44.14 281.26,44.57 279.28,44.57 278.81,44.1 YL2.3
N48197: length 5.3
  BOTTOM w0.203: PU1100.2 68.21,87.77 67.83,87.38 67.83,87.16
  BOTTOM w0.254: PR1105.2 PC1104.2 67.37,85.92 v1(67.5,86.05) 67.83,86.38 67.83,87.16
N48329: length 3.9
  TOP w0.102: v2(67.27,88.15) v1(67.85,88.15)
  TOP w0.254: PC1106.2 PR1118.2 66.84,87.75 67.24,88.15 v2(67.27,88.15)
  BOTTOM w0.203: PU1100.4 67.91,88.57 67.5,88.15 v2(67.27,88.15)
N48371: length 2.1
  TOP w0.102: PC1107.2 64.78,88.53 v1(64.53,88.79)
  TOP w0.254: PC1107.2 64.79,87.75 PR1118.1
N48789: length 3.3
  BOTTOM w0.203: 76.24,91.48 75.32,90.57 PU1100.28
  BOTTOM w0.254: PR1135.1 PC1120.1 76.49,91.73 76.24,91.48
N48933: length 2
  BOTTOM w0.102: PC1123.1 79.46,94.29 v1(79.26,94.49)
  BOTTOM w0.254: PC1123.1 PR1133.2
N48941: length 6.7
  BOTTOM w0.102: PR1133.1 78.55,92.6 v1(77.57,93.58)
  BOTTOM w0.203: PU1100.29 75.43,90.17 76.49,91.23 77.73,91.23
  BOTTOM w0.254: 77.73,91.23 78.09,91.23 PC1121.1 PR1133.1
N48965: length 0.9
  BOTTOM w0.254: PC1122.1 PR1134.2
N48979: length 7.5
  BOTTOM w0.203: 76.26,90.41 v1(75.88,90.03) 75.61,89.77 PU1100.30
  BOTTOM w0.254: PR1128.1 80.71,91.09 PR1129.1 80.68,90.13 77.32,90.13 77.3,90.16 77.28,90.16 PR1134.1 76.51,90.41 76.26,90.41
N49205: length 3.9
  TOP w0.102: v2(67.83,90.19) v1(68.44,90.19)
  TOP w0.254: v2(67.83,90.19) 67.83,90.13 67.47,89.78 66.82,89.78 PR1136.2 66.62,88.65 PC1119.2
  BOTTOM w0.203: PU1100.8 67.85,90.17 v2(67.83,90.19)
N49217: length 2.3
  TOP w0.102: v1(64.63,90.11) 65.17,90.11 65.71,89.58 PR1132.2
  TOP w0.254: PR1132.2 65.72,89.56 PC1119.1
N49289: length 4.5
  TOP w0.203: PR1111.2 66.62,85.96 PC1105.2 67.26,86.59 v2(67.31,86.59)
  BOTTOM w0.203: v2(67.31,86.59) 67.27,86.63 67.27,87.42 v1(67.51,87.66) 68.02,88.17 PU1100.3
N49471: length 2.6
  BOTTOM w0.102: PR1124.1 78.39,87.1 78.83,86.67 78.83,86.15 v1(78.45,85.77)
  BOTTOM w0.254: PC1110.2 77.44,87.1 PR1124.1
N49551: length 3
  BOTTOM w0.203: 76.51,88.13 76.29,88.13 75.78,88.64 75.37,88.64 75.3,88.57 PU1100.33
  BOTTOM w0.254: PC1110.1 PR1121.1 76.51,88.13
N49667: length 4.2
  TOP w0.102: v2(68.69,84.72) v1(68.69,85.33)
  TOP w0.203: v2(68.69,84.72) 68.69,84.24 PR1109.2
  BOTTOM w0.203: v2(68.69,84.72) 69.4,85.44 69.89,85.44 70.34,85.89 PU1100.46
N49815: length 2.2
  BOTTOM w0.203: PU1100.36 74.99,87.37 76.13,86.22
  BOTTOM w0.254: 76.13,86.22 PR1123.1
N50153: length 4.9
  BOTTOM w0.102: v1(72.35,79.63) 72.27,79.71 72.27,80.91 72.78,81.42 PR1101.2
  BOTTOM w0.508: PR1101.2 72.78,82.04 72.55,82.27 72.55,83.48 72.02,84.01
N50385: length 4.7
  BOTTOM w0.203: PR1143.1 PC1136.1 67.98,94.76 v1(67.98,93.7) 68.41,93.27 69.85,93.27 69.94,93.18 PU1100.14
N50425: length 86.7
  IN3 w0.254: v2(128.03,123.43) 127.67,123.43 127.39,123.15 127.39,110.15 125.59,108.35 85.27,108.35 82.04,105.12 78.52,105.12 v2(76.21,107.43)
  BOTTOM w0.254: v2(76.21,107.43) 75.8,107.03 73.42,107.03 73.16,106.77 73.16,106.23 72.46,105.53 70.57,105.53 69.48,104.43 69.48,102.16 68.18,100.87 v1(68.18,99.1) 68.18,97.07 68.56,96.69 PR1144.1 PR1141.1 ; PH1104.1 v2(128.03,123.43)
N50433: length 3
  BOTTOM w0.203: PU1100.15 70.34,93.28 69.87,93.75 v1(69.57,93.75) 68.84,94.48 PR1141.2
N50477: length 3.7
  BOTTOM w0.102: PR1116.1 74.94,84.68 74.21,85.41 v1(74.08,85.41) 73.47,85.41 72.74,86.14 PU1100.40
N50505: length 4.2
  BOTTOM w0.102: PU1100.39 73.14,86.15 73.56,85.74 74.77,85.74 75.11,85.41 75.11,84.86 PR1115.1
N50517: length 4.4
  BOTTOM w0.102: PR1114.1 76.64,84.14 v1(75.5,85.28) 74.85,85.93 73.78,85.93 73.54,86.17 PU1100.38
N50567: length 4.9
  BOTTOM w0.102: v1(77.99,84.38) 77.57,84.8 77.1,84.8 76.57,85.33 PR1113.1 76.21,85.33 75,86.54 PU1100.37
N50631: length 1
  BOTTOM w0.254: PR1147.2 PC1139.1
N50639: length 5.8
  TOP w0.102: PC1137.1 69.11,95.8 v1(68.62,96.29)
  TOP w0.203: v2(70.14,94.15) 70.14,94.17 69.73,94.58 PC1137.1
  BOTTOM w0.203: PU1100.16 70.74,93.55 v2(70.14,94.15) 70.14,94.22 69.73,94.63 PR1147.1
N50651: length 1
  BOTTOM w0.254: PR1145.2 PC1138.1
N50739: length 6.6
  TOP w0.102: v2(70.8,94.15) 70.8,93.68 v1(71.38,93.09)
  TOP w0.203: v2(70.8,94.15) 70.8,95.43 PR1146.1
  TOP w0.254: PR1142.1 70.62,95.63 PR1146.1
  BOTTOM w0.203: PR1145.1 70.62,94.4 70.8,94.22 v2(70.8,94.15) 70.8,93.97 71.08,93.69 71.08,93.16 71.14,93.09 PU1100.17
N51003: length 9.4
  TOP w0.254: v2(76.87,94.25) v1(76.16,93.54) 75.27,93.54 74.43,92.7 73.29,92.7 72.4,93.59 v2(72.27,93.59)
  BOTTOM w0.203: PU1100.20 72.34,93.52 v2(72.27,93.59)
  BOTTOM w0.254: PC1133.1 77.23,96.37 PR1137.1 76.6,94.52 v2(76.87,94.25)
N51011: length 2
  BOTTOM w0.102: PC1133.2 v1(78.32,97.6)
  BOTTOM w0.254: PR1139.1 PC1133.2
N57527: length 45.6
  IN1 w0.254: v2(74.81,104.38) 74.81,104.2 74.94,104.08 76.38,104.08 76.56,104.26 81.82,104.26 87.63,110.07 101.68,110.07 102.4,110.8 102.4,117.62 102.88,118.1 103.77,118.1 v2(104.02,118.35)
  BOTTOM w0.254: PR1435.2 105.23,118.45 104.98,118.19 104.18,118.19 v2(104.02,118.35) ; PR1437.1 73.59,105.53 73.61,105.53 PR1438.1 74.47,105.68 74.47,104.79 v2(74.81,104.38)
N3514407: length 3
  BOTTOM w0.203: PU400.5 54.23,20.76 55.05,19.93 v1(55.05,19.88) 55.38,19.55 PR405.2
N3514423: length 3.3
  BOTTOM w0.203: PU400.3 54.61,21.55
  BOTTOM w0.254: 54.61,21.55 v2(54.92,21.24) 55.09,21.07 PR400.2 55.69,22.1 PC400.1
N3514453: length 2.4
  BOTTOM w0.203: PU400.13 50.05,21.55
  BOTTOM w0.254: 50.05,21.55 49.88,21.39 v1(49.69,21.39) PC421.1
N13347359: length 4.7
  TOP w0.254: v2(68.08,84.7) 67.98,84.7 67.57,84.29 PR1117.2
  BOTTOM w0.203: PU1100.47 69.94,86.02 69.74,85.82 69.12,85.82 v1(68.65,85.35) 68.08,84.78 v2(68.08,84.7) 68.18,84.6 68.18,84.04 PR1112.2
N13351923: length 3.4
  BOTTOM w0.508: PR1102.2 74.24,82.17 74.24,83.56 PC1103.1
  vias: v1(72.67,85.4)
N13352071: length 4.4
  BOTTOM w0.203: PU1100.48 69.19,86.54 67.55,84.91 v1(66.86,84.91) 66.86,84.48 PR1120.2
N13353452: length 6.8
  BOTTOM w0.102: v1(63.43,87.87) 63.87,88.31 65.15,88.31 65.62,87.84 PR1127.2
  BOTTOM w0.203: PR1127.2 65.63,87.82 PR1122.2 66.63,87.9 PR1119.2 66.74,88.66 67.52,88.66 67.83,88.97 PU1100.5
N17034077: length 3.2
  BOTTOM w0.203: PU400.1 53.82,23.18 v1(54.79,24.15) 54.79,24.77 PR406.1
N17034092: length 4.1
  BOTTOM w0.102: PR416.2 49.41,19.5 v1(50.12,18.79)
  BOTTOM w0.203: 50.05,20.95 50.26,21.16 PU400.12
  BOTTOM w0.254: 50.05,20.95 49.74,20.95 PC420.1 49.16,20.36 PR416.2
N18094620: length 19.3
  TOP w0.508: v2(290.74,96.31) v1(290.74,94.5) 290.74,91.58 292.62,89.7 RL40.2 RL39.2 RL20.2 RL19.2
  BOTTOM w0.508: v2(290.74,96.31) 290.05,96.99 CL33.1
N18094850: length 3.9
  BOTTOM w0.203: UL1.31 283.43,45.69 283.33,45.79
  BOTTOM w0.254: RL31.2 281.75,47.49 v1(282.13,47.11) 282.5,46.73 282.5,46.35 283.07,45.79 283.33,45.79
N18095026: length 1.2
  BOTTOM w0.102: T944.1 283.04,44.09 UL1.27
N18095028: length 1.9
  BOTTOM w0.102: UL1.25 283.61,43.29 T95.1
N19473413: length 5
  BOTTOM w0.102: v1(148.98,27.09) 148.64,26.75 PR1804.1
  BOTTOM w0.254: PU1800.7 146.23,24.79 146.89,25.45 146.89,25.69 PC1802.2 PR1803.2 147.94,26.72 PR1804.1
N19473597: length 4.5
  BOTTOM w0.254: PU1800.1 147.5,20.68 147.96,21.15 v1(148.83,21.15) 149.27,21.15 PR1800.2
N19473637: length 0.7
  TOP w0.102: v2(145.49,25.77) v3(145.49,25.11)
  BOTTOM w0.102: 146.11,27.18 146.12,27.18
N19901660: length 2.2
  TOP w0.102: v1(229.12,11.62) 228.76,11.98 RE10.1 CE78.2
N20173493: length 7.3
  TOP w0.102: v2(224.9,30.39) 225.05,30.54 UE1.120
  BOTTOM w0.102: v1(226.11,26.64) 225.5,27.24 RE20.1 224.77,27.24 224.34,27.68 224.34,28.63 224.23,28.74 RE22.1 224.47,29.43 224.47,29.94 224.9,30.37 v2(224.9,30.39)
N20180024: length 3.2
  TOP w0.102: v1(182.74,54.4) 182.41,54.4 181.65,53.63 PC1031.1
  TOP w0.508: PR1011.1 PR1010.2 PC1031.1
N20194225: length 7.5
  TOP w0.254: v2(178.96,57.08) 179.41,57.52 PR1004.2 179.84,57.47 179.84,56.68 PR1002.2
  BOTTOM w0.254: PR1005.1 180.64,59.88 181.21,59.31 181.21,58.44 PC1009.1 180.81,58 179.92,57.11 v1(179.47,57.11) 179,57.11 v2(178.96,57.08)
N20335974: length 5.2
  BOTTOM w0.102: UL2.3 279.85,48.7 279.42,49.13 RL41.1 v1(279.42,52.95)
N20440449: length 4.3
  TOP w0.203: UE1.54 230.25,15.22 v2(229.75,14.72)
  BOTTOM w0.102: v2(229.75,14.72) v1(229.75,14.01)
  BOTTOM w0.254: RE15.2 228.69,15.66 CE71.1 v2(229.75,14.72)
N21876819: length 3.8
  TOP w0.102: QV21.1 v1(204.16,91.06)
  TOP w0.406: QV21.1 205.2,92.83 RV144.1 205.25,93.83 RV141.1
N21997699: length 6.6
  TOP w0.102: QV20.1 170.89,128.06 RV126.1 ; RV126.1 171.71,128.77 172.26,128.22 172.81,128.22 173.54,128.95 v1(173.54,129.16) ; RV126.1 169.93,128.77 RV129.1
N26964858: length 3.4
  TOP w0.102: v2(175.37,75.56) 175.26,75.45 175.26,75.17 v1(176.07,74.37) 176.66,73.78 RV66.1
  BOTTOM w0.102: UV1.J1 175.4,76.02 175.4,75.58 v2(175.37,75.56)
N32834652: length 2.1
  TOP w0.203: RA19.1 279.74,20.13 280.13,20.53 280.13,20.91 280.31,21.09 HDA1.16
N34662854: length 4.6
  TOP w0.203: 282.05,20.64 282.05,20.79 281.91,20.93 HDA1.20
  TOP w0.508: 282.05,20.64 282.05,20.23 v1(282.46,19.83) 282.46,19.04 282.03,18.61 RA18.1 RA17.1
N35924928: length 3.2
  TOP w0.102: RV77.2 175.44,100.22 175.41,100.2 v1(175.41,98.72) 175.41,98.68 v2(175.89,98.21)
  BOTTOM w0.102: UV1.J27 v2(175.89,98.21)
N35928308: length 3.3
  TOP w0.102: RV78.2 176.33,100.22 176.28,100.17 176.28,100.1 176.23,100.06 v1(176.23,99.73) 176.23,99.4 176.28,99.35 176.28,98.72 v2(176.79,98.21)
  BOTTOM w0.102: UV1.H27 v2(176.79,98.21)
N35950826: length 5.2
  TOP w0.102: v2(176.82,96.49) 177.22,96.09 177.22,95.39 177.35,95.25 178.04,95.25 v1(178.12,95.17) 178.94,94.35 178.94,93.68 RV79.2
  BOTTOM w0.102: v2(176.82,96.49) 176.39,96.06 UV1.H25
N38952253: length 4.4
  BOTTOM w0.102: UV1.E1 178.67,75.98 178.67,75.17 v1(179.25,74.59) 180.73,73.11 RV104.2
N48676721: length 2.6
  TOP w0.102: RE3.2 120.33,14.74 v2(120.27,14.68) 120.25,14.66 120.25,14.32 v3(120.46,14.11)
  BOTTOM w0.102: v2(120.27,14.68) 120.27,14.7 120.56,14.99 120.56,15.8 JBL1.2
N48680518: length 8.6
  TOP w0.102: QE4.2 210.47,32.22 211.41,31.28 212.1,31.28 213.32,32.5 QE3.1 213.24,32.7 CE1.1 RE1.1 214.16,34.33 v1(215.1,35.27)
N48680573: length 3.4
  TOP w0.102: v1(208.92,35.68) 209.43,36.19 RE2.1 209.86,35.27 QE4.1
N52997531: length 3.6
  TOP w0.102: v1(16.06,34.56) 15.66,34.15 PR114.2 15.24,33.86 PD100.1 15.24,32.45 PL106.1
N52999984: length 3.6
  TOP w0.102: PR100.2 PR102.1 ; PR102.1 16.2,28.39 16.1,28.29 PQ100.3 ; PR102.1 v1(17.99,28.39)
N52999986: length 12.4
  TOP w0.102: PR100.1 15.94,29.33 13.09,29.33 12.53,28.77 PR103.1 ; PR100.1 16.57,30.37 PQ100.1 14.06,30.67 PL106.2 ; PR100.1 v1(17.79,30.17)
N101473516: length 2.2
  TOP w0.102: v2(175.2,125.69) 175.24,125.69 175.55,126 v1(175.55,126.15)
  TOP w0.127: v2(175.2,125.69) 174.95,125.94 RV116.1
  BOTTOM w0.254: UV6.J1 v2(175.2,125.69)
N101473793: length 8.1
  TOP w0.102: v1(185.28,125.34) 185.28,125.2 184.97,124.89 v2(184.8,124.89) 184.42,125.27 182.9,125.27 182.79,125.16 182.26,125.16 181.59,125.82 181.59,127.24 181.72,127.37 181.72,128.17 RV120.1
  BOTTOM w0.107: UV6.J13 v2(184.8,124.89)
N101474312: length 5
  TOP w0.102: RV118.1 v1(181.21,126.38) 181.21,125.7 182.03,124.88 183.19,124.88 v2(183.2,124.89)
  BOTTOM w0.107: UV6.J10 v2(183.2,124.89)
N101484120: length 2.7
  TOP w0.102: RV117.1 v1(168.12,126.34)
  TOP w0.254: v2(166.3,125.69) 166.95,126.34 RV117.1
  BOTTOM w0.254: v2(166.3,125.69) 166.7,125.29 UV7.J1
N101484397: length 3.3
  TOP w0.107: RV121.1 159.73,126.09 v1(158.68,126.09) 157.9,126.09 v2(157.5,125.69)
  BOTTOM w0.102: UV7.J13 v2(157.5,125.69)
N101484914: length 1.5
  TOP w0.107: v2(159.1,124.89) 159.11,124.87 159.99,124.87 RV119.1
  BOTTOM w0.254: UV7.J10 v2(159.1,124.89)
N101908901: length 2.4
  TOP w0.102: RV131.1 204.43,95.76 v1(204.53,95.86) 204.53,96.32 v2(204.26,96.59)
  BOTTOM w0.254: UV9.J1 v2(204.26,96.59)
N101909174: length 3.2
  TOP w0.102: RV135.1 204.68,103.46 204.68,104.4 204.65,104.43 204.65,105 v2(204.26,105.39)
  BOTTOM w0.102: UV9.J13 v2(204.26,105.39)
N101909529: length 2.9
  TOP w0.102: RV133.1 202.75,103.12 202.65,103.01 v2(202.65,103.01) 202.4,102.76 v1(202.4,102.4)
  BOTTOM w0.102: v2(202.65,103.01) 202.68,103.04 203.5,103.04 UV9.J10
N101910032: length 2
  TOP w0.102: v2(204.26,87.88) 204.53,87.61 v1(204.78,87.61)
  TOP w0.254: RV132.1 204.05,88.09 v2(204.26,87.88)
  BOTTOM w0.254: UV8.J1 v2(204.26,87.88)
N101910312: length 7.6
  TOP w0.102: v2(203.41,78.28) 203.84,78.72 203.84,80.26 v1(202.65,81.46) 201.38,81.46 201.09,81.74 RV136.1
  BOTTOM w0.107: v2(203.41,78.28) 203.46,78.28 UV8.J13
N101910826: length 5
  TOP w0.102: RV134.1 199.97,80.82 200.31,81.17 v1(201.2,81.17) 202.17,81.17 v2(203.46,79.88)
  BOTTOM w0.107: UV8.J10 v2(203.46,79.88)
N108873638: length 2.2
  BOTTOM w0.203: PR409.1 53.6,24.22 v1(53.5,24.12) 53.5,23.85 53.14,23.49 PU400.20
N109801960: length 4.8
  TOP w0.102: QZ6.3 207.16,73.94 208.19,74.97 208.28,74.97 v1(208.52,75.2)
  TOP w0.305: QZ6.2 206.51,72.58 RZ12.2 206.79,72.38 207.16,72.75 QZ6.3
N109970739: length 2.3
  BOTTOM w0.203: PR411.1 53.02,24.75 v2(53.02,24.42) 53.02,24.01 52.74,23.72 PU400.19
N110936976: length 2.9
  TOP w0.102: PC1076.1 v1(198.51,56.96)
  TOP w0.635: PC1076.1 PR1031.2
N111036757: length 3.3
  TOP w0.102: v1(177.28,52.67) 177.68,52.67 v2(177.91,52.9)
  TOP w0.254: PR1023.2 178.41,54.04 PR1021.2 177.94,52.92 v2(177.91,52.9)
  BOTTOM w0.254: PU1000.13 177.87,52.94 v2(177.91,52.9)
N111036762: length 5.6
  BOTTOM w0.102: v1(180.64,50.55) 180.32,50.87 PR1024.2
  BOTTOM w0.254: PU1000.14 176.76,52.38 176.99,52.15 178.97,52.15 179.59,51.53 PR1024.2
N111036767: length 4.5
  BOTTOM w0.102: v1(178.65,51.74) 178.65,51.32 PR1027.2
  BOTTOM w0.254: 176.59,51.78 176.59,51.99 176.26,52.31 PU1000.15
  BOTTOM w0.508: 176.59,51.78 176.59,51.56 PR1028.1 177.14,51.02 178.04,51.02 PR1027.2
N111798152: length 1.6
  TOP w0.102: CZ4.1 212.24,12.46 212.79,12.46 212.87,12.54 UZ1.12
N111798158: length 1.7
  TOP w0.102: CZ6.1 212.33,13.34 UZ1.10
N120139517: length 2
  TOP w0.102: v2(179.28,42.05) v1(179.28,41.49)
  TOP w0.254: v2(179.28,42.05) 178.83,42.51 RH71.2
  BOTTOM w0.254: UH2.E1 179.04,41.76 179.28,42 v2(179.28,42.05)
N120174690: length 2.8
  TOP w0.102: T20.1 173.97,25.26 173.7,25.54 173.06,25.54 v2(172.6,25.09)
  BOTTOM w0.089: UH2.AV15 172.32,25.19 172.5,25.19 v2(172.6,25.09)
N120176772: length 2.7
  BOTTOM w0.089: UH2.V44 157.53,35.51 156.95,35.51 156.77,35.69 156.17,35.69
  BOTTOM w0.102: T2.1 155.76,36.1 156.17,35.69
N120176782: length 3.8
  BOTTOM w0.102: T4.1 155.84,40.5 157.08,39.26 157.86,39.26 UH2.L43
N120176822: length 8
  BOTTOM w0.102: UH2.BD36 161.28,22.5 160.78,22 160.78,21.15 159.16,19.54 156.43,19.54 155.71,18.81 T8.1
N120177456: length 4
  BOTTOM w0.076: T17.1 170.78,19.55 170.34,19.55 170.06,19.83 170.06,20.71 170.66,21.31 170.66,22.18 UH2.BD17
N120361004: length 4.9
  BOTTOM w0.102: RD7.2 RD59.1 ; RD7.2 v1(218.49,26.96) ; RD7.2 216.92,26.96 216.31,27.57 JNGFF2.38
N120361079: length 2.6
  BOTTOM w0.102: JNGFF2.68 216.44,20.07 216.73,20.36 RD9.1
N120970730: length 1.6
  TOP w0.102: v1(125.44,123.31) 126.01,122.74 PC1409.1
N120976432: length 1.4
  TOP w0.508: PR1434.1 v2(104.09,122.5)
  vias: v1(102.22,122.8)
N121033408: length 7.5
  BOTTOM w0.203: PU400.7 52.74,19.4 52.97,19.17
  BOTTOM w0.254: PR410.2 PR408.2 55.59,16.53 54.14,16.53 53.93,16.73 53.93,18.2 v1(53.55,18.58) 52.97,19.17
N121163993: length 7.9
  BOTTOM w0.076: 123.85,73.4 123.71,73.4 123.46,73.64 UH1.J2
  BOTTOM w0.203: 123.85,73.4 125.17,72.08
  BOTTOM w0.305: RH150.2 v1(122.62,70.63) 123.01,71.02 124.95,71.02 125.17,71.24 125.17,72.08
N121163994: length 5.1
  BOTTOM w0.203: UH1.H1 123.97,73.73 125.09,72.61 125.37,72.61 125.46,72.52
  BOTTOM w0.305: RH149.2 125.36,70.49 125.78,70.9 125.78,72.2 125.46,72.52
N121163995: length 6
  BOTTOM w0.203: 125.92,72.76 125.92,72.82 125.8,72.94 125.22,72.94 124.63,73.53 UH1.G1
  BOTTOM w0.305: RH148.2 125.29,69.6 v1(125.9,70.21) 126.23,70.54 126.23,72.45 125.92,72.76
N121388945: length 10.2
  BOTTOM w0.076: UH2.AJ4 177.63,29.81 178.43,29.81 178.53,29.71 179.97,29.71 180.63,30.37 180.63,30.72 181.02,31.11 181.24,31.11 v1(181.47,31.33) 181.79,31.33 182.13,31.68 182.13,31.79
  BOTTOM w0.102: RH189.1 184.29,34.4 183.55,33.67 183.55,33.16 182.74,32.35 182.38,32.35 182.13,32.1 182.13,31.79
N121479122: length 8.5
  BOTTOM w0.254: UH1.AG38 109.07,101.94 109.39,102.26 109.39,103.62 108.76,104.26 v1(108.76,104.96) 107.93,105.78 107.26,105.78 RH29.1 RH28.1
N121480352: length 6.3
  BOTTOM w0.254: UH1.M37 120.48,100.11 120.48,100.6 119.66,101.42 119.22,101.42 118.34,102.31 v1(117.97,102.31) 117.52,102.76 RH31.1 RH41.1
N121480355: length 4.5
  BOTTOM w0.254: RH202.1 RH201.1 v1(119.3,102.28) 119.45,102.12 119.62,102.12 120.84,100.9 120.84,100.41 UH1.M38
N121480375: length 2.3
  TOP w0.102: v2(115.03,80.61) 114.68,80.26 v1(114.58,80.26)
  TOP w0.305: v2(115.03,80.61) 115.03,80.74 114.59,81.18 RH34.2
  BOTTOM w0.203: UH1.Y12 114.61,80.9 114.89,80.61 v2(115.03,80.61)
N121507165: length 4.7
  BOTTOM w0.102: UH1.BR25 87.82,90.8 87.39,90.8 87.13,90.54 87.13,89.35 86.42,88.64 v1(86.22,88.64) RH57.2
N121507167: length 4.2
  BOTTOM w0.102: RH58.2 85.3,90.5 v1(86.22,91.42) 86.36,91.56 88.53,91.56 UH1.BP25
N121507169: length 2.7
  BOTTOM w0.203: RH166.2 85.61,93.34 86.35,94.08 87.3,94.08 UH1.BT29
N121616289: length 2.5
  TOP w0.102: UE4.3 136.86,13.56 RZ33.2 v1(136.51,12.22)
N121673930: length 3.1
  BOTTOM w0.102: PC1109.2 65.61,86.92 65.14,86.45 v1(63.68,86.45)
  BOTTOM w0.254: PR1122.1 66.55,86.92 PC1109.2
N121674134: length 1.9
  TOP w0.102: PR1142.2 v1(69.66,97.86)
  TOP w0.254: PR1142.2 PC1134.1
N121674335: length 2
  BOTTOM w0.102: v1(80.44,92.98) 80.72,92.7 PR1128.2
  BOTTOM w0.254: PC1115.1 PR1128.2
N121710332: length 11.1
  BOTTOM w0.254: UH1.AG37 109.22,99.71 109.45,99.94 109.45,101.83 109.79,102.17 109.79,105.64 v1(109.26,106.18) 108.51,106.92 107.32,106.92 RH197.2 RH198.1
N121712022: length 5.7
  BOTTOM w0.254: UH1.AH38 108.28,102.16 v1(108.5,102.38) 108.5,102.83 107.99,103.34 107.23,103.34 RH203.2 RH204.1
N121795600:
  vias: v1(121.22,123.23) v2(124.15,122.61)
N121981266: length 71.9
  TOP w0.254: PR1111.1 PR1110.2 65.72,84.11 65.19,84.65 63.69,84.65 63.13,85.21 63.13,87.87 63.76,88.51 v3(63.76,96.28) 63.76,96.89 v2(71,104.13)
  IN3 w0.254: v2(71,104.13) 70.91,104.13 70.11,104.92 70.11,107.69 69.93,107.87 69.93,112.69 71.56,114.32 71.56,120.09 71.94,120.46 86.52,120.46 89.67,123.61 94.4,123.61 94.7,123.31 v2(97.8,123.31)
  BOTTOM w0.254: v2(97.8,123.31) 98.13,123.64 PH1100.2
N121981305: length 2.1
  BOTTOM w0.102: v1(85.84,120.84) 86.24,120.44 PR1130.2
  BOTTOM w0.254: PR1130.2 PH1102.1
N121981509: length 2.7
  BOTTOM w0.102: PR1125.1 129.17,118.07 129.63,117.62 v1(129.63,117.16)
  BOTTOM w0.254: PR1125.1 130.62,118.1 PH1101.2
N121981539: length 0.9
  BOTTOM w0.254: PR1140.1 PH1103.2
N121983108: length 3
  TOP w0.102: v1(201.1,59.1) PR1029.2
  TOP w0.254: PU1001.1 202.41,57.1 201.48,58.03 PR1029.2
N122017994: length 1.4
  TOP w0.508: PR1420.1 v2(113.99,122.67)
  vias: v1(111.74,122.65)
N122314333: length 7.6
  BOTTOM w0.254: RH32.1 RH33.1 107.25,103.72 108.55,103.72 v1(108.61,103.66) 109.01,103.27 109.01,102.36 108.7,102.05 108.7,100.02 108.4,99.71 UH1.AH37
N122397475: length 11.5
  TOP w0.102: RH145.1 133.99,95.49 v2(133.49,94.99)
  IN1 w0.114: v2(124.61,94.19) 124.61,95.06 125.05,95.49 128.94,95.49 129.58,94.86 133.36,94.86 v2(133.49,94.99)
  BOTTOM w0.102: UH1.G29 124.31,94.58 124.61,94.28 v2(124.61,94.19)
N122449909: length 3.5
  TOP w0.254: RH514.1 121.63,84.22 v2(122.45,83.4) 122.71,83.4 RH515.1
  BOTTOM w0.203: v2(122.45,83.4) 122.67,83.18 123.21,83.18 UH1.H14
N122449918: length 3.8
  TOP w0.102: v1(123.47,81.97) 123.47,82.58 RH516.1
  TOP w0.254: RH516.1 122.9,82.7 v2(122.4,82.7) 121.88,82.7 121.6,82.98 RH513.1
  BOTTOM w0.254: v2(122.4,82.7) 122.88,82.7 UH1.J14
N122476680: length 58
  IN1 w0.254: v2(80.6,102.2) 80.71,102.1 82.27,102.1 87.94,107.76 108.98,107.76 109.18,107.97 117.97,107.97 118.58,108.58 118.58,111.13 118.12,111.59 118.12,114.07 118.88,114.83 118.88,116.41 120.77,118.29 122.37,118.29 v2(122.56,118.48)
  BOTTOM w0.254: v2(80.6,102.2) 80.45,102.35 PR1410.1 79.7,101.7 PR1409.1 ; PR1407.2 123.77,118.54 123.52,118.29 122.76,118.29 v2(122.56,118.48)
N122477585: length 49.9
  IN1 w0.254: v2(113.55,118.48) 113.29,118.23 111.61,118.23 110.5,117.12 110.5,111.15 108.03,108.68 102.85,108.68 102.68,108.85 87.72,108.85 81.98,103.11 78.11,103.11 v2(77.99,103.24)
  BOTTOM w0.254: PR1424.1 77.04,103.25 PR1423.1 77.81,103.06 v2(77.99,103.24) ; v2(113.55,118.48) 113.67,118.35 114.63,118.35 114.88,118.61 PR1421.2
N122563835: length 142.5
  TOP w0.102: v2(141.74,39.49) 141.84,39.39 142.24,39.39 144.22,37.41 144.22,36.63 145.04,35.8 146.06,35.8 146.75,36.49 153.04,36.49 v1(153.25,36.29) 153.83,35.71 RH89.2
  IN2 w0.127: v2(86.5,97.02) 86.5,97.03 88.12,98.65 88.12,99.28 88.45,99.61 88.45,102.77 90.78,105.1 100.7,105.1 101.22,104.59 105.09,104.59 105.83,105.32 131.19,105.32 134.27,102.24 134.27,101.14 139.58,95.83 139.58,81.68 141.13,80.13 v2(141.13,80.13)
  IN3 w0.127: v2(141.13,80.13) 141.13,80.15 140.7,79.72 140.7,77.23 136.33,72.86 136.33,69.54 139.99,65.88 139.99,43.37 141.92,41.44 141.92,39.66 v2(141.74,39.49)
  BOTTOM w0.076: v2(86.5,97.02) 87.15,96.37 87.88,96.37 UH1.BR33
N122712620: length 4.8
  BOTTOM w0.102: RD58.2 RD10.2 205.14,18.96 206,19.83 v1(206.33,19.83) 208.07,19.83 JNGFF2.69
N122754354: length 4.8
  TOP w0.102: UZ16.6 70.63,48.28 CZ57.1 70.42,48.47 69.66,49.23 69.66,50.03 70.27,50.64 v1(70.7,50.64)
N122763041: length 3.7
  TOP w0.102: v1(172.81,73.07) 172.7,72.96 171.43,72.96 170.99,72.53 CZ95.1 170.74,72.77 UZ17.6
N123052806: length 3.2
  TOP w0.102: v1(191.58,28.06) 191.58,27.17 191.16,26.76 RH106.2 UH14.2
N123983992:
  vias: v2(76.59,110.99) v3(75.96,113.45)
N123984002: length 24
  IN1 w0.254: v2(67.19,106.54) 68.34,107.69 74.18,107.69 79.51,113.02 81.67,113.02 v2(81.8,113.15)
  BOTTOM w0.254: PR1522.1 66.49,105.39 PR1521.1 v2(67.19,106.54) ; v2(81.8,113.15) 81.92,113.27 81.92,116.7 81.67,116.96 PR1519.2
N123984081: length 42
  IN1 w0.254: v2(66.68,102.71) 66.86,102.89 68.32,102.89 70.32,104.89 81.72,104.89 89.29,112.46 89.29,113.01 90.66,114.38 90.66,117.68 90.1,118.23 89.04,118.23 v2(88.91,118.35)
  BOTTOM w0.102: PR1510.1 v1(64.86,99.93)
  BOTTOM w0.254: v2(66.68,102.71) 65.83,102.71 PR1509.1 64.86,101.73 PR1510.1 ; v2(88.91,118.35) 89.04,118.23 91.2,118.23 91.83,118.86 PR1506.2
N123984213: length 26.6
  TOP w0.254: PR1526.1 v2(66.84,104.38)
  IN1 w0.254: v2(66.84,104.38) 66.84,105.32 68.82,107.31 74.34,107.31 79.67,112.64 82.18,112.64 82.56,113.02 v2(82.56,113.15)
  BOTTOM w0.254: PR1526.1 v2(66.84,104.38) ; PR1520.2 82.69,116.96 82.43,116.7 82.43,113.27 v2(82.56,113.15)
N123984271:
  vias: v2(132.09,120.64) v2(132.09,119.62) v2(132.09,118.48) v2(133.23,121.91) v2(134.25,120.64) v2(135.01,120.51) v2(136.03,118.23) v3(134.12,122.55)
N123984459: length 1.5
  TOP w0.102: PC1507.1 95.43,122.74 v1(94.9,123.26)
N123984461: length 2
  TOP w0.102: v1(93.57,123) 93.7,123 93.8,122.89 v2(93.8,122.42)
  TOP w0.508: 93.8,121.15 v2(93.8,122.42)
N123985122: length 38.6
  TOP w0.254: PR1525.1 66.63,103.37 v2(66.68,103.42)
  IN1 w0.254: v2(66.68,103.42) 66.84,103.27 68.16,103.27 70.16,105.27 81.56,105.27 88.91,112.62 88.91,113.17 90.27,114.53 90.27,117.52 89.95,117.85 89.16,117.85 v2(88.91,117.59)
  BOTTOM w0.254: PR1507.2 91.83,117.21 91.2,117.85 89.16,117.85 v2(88.91,117.59) ; v2(66.68,103.42) 66.63,103.37 PR1525.1
N124752685: length 2
  TOP w0.102: v1(71.94,44.92) 71.51,44.92 71.51,44.92 CH101.2
  TOP w0.508: RH211.1 70.85,44.94 CH101.2
N124753277: length 2.1
  TOP w0.102: RH212.1 v1(112.84,26.33)
  TOP w0.508: RH212.1 CH100.2
N125233563: length 3.1
  BOTTOM w0.102: v1(62.84,89.28) 63.17,89.28 63.19,89.3 64.35,89.3 64.86,88.79 PC1108.2
  BOTTOM w0.254: PC1108.2 PR1119.1
N125374216: length 5.8
  TOP w0.102: v3(147.48,108.04) 149.44,108.04 QZ8.1
  TOP w0.508: RZ9.2 150.18,107.31 QZ8.1
N125749803: length 2.3
  TOP w0.102: v1(204.38,74.23) 204.81,74.67 RZ8.2 205.8,75.3 QZ6.6
N125750578: length 2.1
  TOP w0.102: QZ7.6 156.81,75.85 RZ10.2 156.8,74.99 v1(156.68,74.87)
N125750624: length 1.2
  TOP w0.102: QZ7.3 155.51,79.18 RZ11.2
N128659288: length 6.4
  BOTTOM w0.102: PQ203.6 47.82,38.19 47.52,37.89 46.02,37.89 v1(45.43,37.3)
  BOTTOM w0.254: PQ203.6 47.4,38.46 47.13,38.73 47.13,39.96 47.39,40.22 47.58,40.22 PR210.2
N128659290: length 5.6
  BOTTOM w0.102: PR214.1 44.38,39.18 43.85,38.65 v1(43.85,38.42)
  BOTTOM w0.254: PQ203.2 44.92,39.11 PR214.1 44.84,40.17 PR209.2 45.92,40.26 PQ203.3
N128659296: length 3.6
  BOTTOM w0.102: PR212.2 48.04,37.96 v1(47.48,37.4)
  BOTTOM w0.254: PQ203.5 48.57,39.11 PC204.1 PR212.2
N128706078: length 3.6
  TOP w0.102: v1(45.25,46.48) v2(46.25,46.48) 46.36,46.48 47.05,45.79 PR215.1
  BOTTOM w0.102: PQ201.1 46.55,45.82 46.25,46.12 v2(46.25,46.48)
N128706262: length 3.3
  TOP w0.102: PR206.2 PC202.1 45.81,44.87 v2(45.53,44.59) v1(44.79,44.59)
  BOTTOM w0.102: v2(45.53,44.59) 45.44,44.68 PQ201.2
N128723044: length 11.5
  TOP w0.102: v2(50.3,47.79) 49.97,47.46 49.97,44.67 v1(48.32,43.02) 47.88,42.57 47.88,41.46 v2(48.82,40.52)
  BOTTOM w0.102: PQ202.2 49.69,47 49.88,47.18 PR211.1 v2(50.3,47.79) ; PC203.2 v2(48.82,40.52)
N128723211: length 2.9
  TOP w0.102: PR217.1 46.44,47.03 v2(46.37,47.1) 46.37,47.51 v1(46.19,47.69)
  BOTTOM w0.102: PQ202.1 47.19,46.68 46.77,47.1 v2(46.37,47.1)
N128731318: length 20.9
  BOTTOM w0.508: QZ9.1 212.15,47.79 212.99,48.63 216.19,48.63 218.7,51.15 221.42,51.15 222.36,50.21 v1(227.67,50.21) 228.8,49.08 RZ37.1
N128782144: length 5.8
  TOP w0.102: PR703.2 64.2,61.51 v1(63.95,61.75)
  TOP w0.254: PR706.1 67.75,63.24 67.19,62.68 67.19,62.27 PR703.2 66.43,60.65 PR705.1
N128782226: length 3.5
  TOP w0.254: PR708.2 PR711.1 67.75,60.82 v1(67.42,60.49) 67.42,60.09 67.02,59.68 PR710.1
N128802462: length 2.4
  BOTTOM w0.102: PC504.1 109.28,7.64 v1(109.79,7.13)
  BOTTOM w0.635: PC504.1 108.67,8.14 PR502.2
N128802488: length 5.9
  BOTTOM w0.254: PU500.16 100.7,9.49 v1(100.39,9.18) 99.65,8.45 PC508.2 PR503.2 99.65,7.31 100.26,6.7 101.1,6.7 101.48,7.08 PR505.1
N128802974: length 2.5
  BOTTOM w0.508: 102.91,10.05 v2(103.62,9.33) 104.45,8.5 104.45,8.45 PC505.1
N128803011: length 1.3
  BOTTOM w0.102: PC502.1 93.9,10.71 v1(93.34,11.27)
N128803052: length 2.1
  BOTTOM w0.254: PU500.14 101.6,9.63 101.94,9.29 101.94,8.86 102.37,8.42 PC507.1
N128803144: length 1.6
  BOTTOM w0.254: PU500.3 100.25,13.49 99.7,14.04 PC514.1
N128828208: length 1.5
  TOP w0.102: v1(115.2,123.03) 115.49,122.74 PC1417.1
N128828374: length 1.6
  TOP w0.102: v1(105.24,123.18) 105.69,122.74 PC1425.1
N128835022: length 1.1
  TOP w0.102: v1(80.35,117.57) 79.94,117.16 79.38,117.16
N128835130: length 1.9
  TOP w0.102: PR1524.2 135.96,119.26 v1(136.53,118.68)
N128845288: length 3.9
  TOP w0.102: v1(48.21,47.06) v2(48.21,46.44) 48.27,46.39 PR216.1
  BOTTOM w0.102: v2(48.21,46.44) 48.21,45.6 47.32,44.71 PQ200.6
N128845311: length 4.5
  BOTTOM w0.102: PR213.1 v1(45.22,43.5)
  BOTTOM w0.254: PR213.1 46.29,43.55 PQ200.5 47.76,43.55 48.12,43.2 PR203.2
N128845336: length 3.7
  BOTTOM w0.102: PR204.2 50.78,44.49 v1(51.65,45.35)
  BOTTOM w0.254: PR204.2 PC200.2 50.23,43.55 PQ200.2
N128845350: length 4
  BOTTOM w0.102: PC200.1 51.52,43.93 v1(51.52,44.03)
  BOTTOM w0.254: PR202.2 50.38,42.64 PC200.1 50.11,42.9 PQ200.3
N128884081: length 4.5
  TOP w0.508: PQ300.1 19.19,34.48 PR303.2 ; PC303.2 24.98,38.93 24.98,37.61 PC324.2 PR325.2 24.93,35.78 PR308.1
  vias: v2(22.79,34.09) v2(23.59,34.78)
N128884094: length 2.1
  BOTTOM w0.102: 24.06,37.07 24.06,37.76 23.86,37.96 23.86,38.73 v1(24.09,38.95)
  vias: v2(18.5,35.25) v2(19.09,35.27) v2(19.57,37.3) v2(19.67,35.27) v2(20.23,37.3) v2(20.25,35.3) v2(20.81,37.3) v2(20.84,35.27) v2(21.42,35.25) v2(21.45,37.3) v2(22.03,37.33)
N128884102: length 6.5
  TOP w0.102: PR301.1 v1(22.06,30.55)
  TOP w0.508: PQ300.2 18.87,31.07 19.29,30.65 20.76,30.65 21.17,31.05 PR300.2 PR301.1
N128884116: length 3.3
  TOP w0.102: PQ300.3 20.17,31.81 v1(19.57,31.21)
  TOP w0.508: PQ300.3 20.54,32.63 PR300.1 PC301.1
N128884118:
  vias: v3(23.77,32.15)
N128884914: length 5.4
  BOTTOM w0.203: PR321.1 v1(35.03,40.4) 34.3,39.66 32.95,39.66 32.54,39.26 32.54,38.83 32.25,38.54 PU300.15
N128884971: length 5.2
  TOP w0.102: v1(41.03,19.73) 40.68,19.37 40.68,18.63 40.32,18.28 PC302.1
  TOP w0.635: PQ303.4 39.38,19.29 39.82,18.85 PC302.1 39.82,17.4 PR306.1
N128884983: length 1.5
  BOTTOM w0.203: PU300.20 32.6,36.54 PR322.1
N128884987: length 1.3
  BOTTOM w0.203: PR324.1 32.85,36.82 32.73,36.94 PU300.19
N128884993: length 3
  BOTTOM w0.203: PU300.21 32.28,36.14 32.65,35.77 32.65,35.3 32.95,34.99 PR313.1 PR312.2
N128885024: length 1.5
  TOP w0.508: PR310.2 26.27,30.9 26.81,31.44 v2(26.81,32.12)
  vias: v1(27.65,34.08)
N128885041: length 4.9
  TOP w0.102: PR310.1 v1(23.53,29.07)
  TOP w0.508: PR310.1 24.17,31.54 PD300.1
N128885051: length 3.1
  BOTTOM w0.102: PR326.1 30.95,40.76 30.32,40.76 29.47,39.9 PU300.10
N128885101: length 3.9
  BOTTOM w0.102: v1(32.01,30.53) 31.62,30.93 30.67,30.93 30.05,31.55 PR311.1
  BOTTOM w0.508: PC304.2 29.21,31.55 PR311.1
N128885126: length 4.1
  BOTTOM w0.203: PU300.7 27.6,38.54 27.47,38.67 27.47,38.98
  BOTTOM w0.254: 27.47,38.98 27.47,39.51 27.82,39.87 v1(27.82,40.45) PC321.1 PR319.2
N128885130: length 2.3
  BOTTOM w0.102: PC322.2 29.6,40.91 v1(29.13,40.44) 28.67,39.98 PU300.8
N128889202: length 1.1
  BOTTOM w0.102: PR901.2 v1(143.37,117.02)
N128889244: length 1.7
  TOP w0.102: PR904.2 v1(141.68,126.04)
N128889297: length 6
  BOTTOM w0.102: PR900.2 143.44,111.17 143.77,111.5 145.35,111.5 PR908.2 v1(145.86,109.97)
  BOTTOM w0.254: PR900.2 142.88,110.99 142.31,111.56 PU900.1
N128983344: length 1.3
  TOP w0.102: PR1030.2 v1(206.09,59.64)
N129020146: length 3
  TOP w0.102: RA33.1 281.01,16.07 v1(281.4,16.07)
  TOP w0.254: CA29.1 279.83,16.79 RA30.2 RA33.1
N129088154: length 2.8
  BOTTOM w0.102: UA2.3 262.78,21.78 262.48,22.09 v2(262.48,22.33) 262.48,22.74 RA67.1 RA65.2
N129088268: length 1.7
  BOTTOM w0.102: CD94.1 263.78,22.9 v2(263.78,22.3) UA2.5
N129088271: length 1.8
  BOTTOM w0.102: UA2.6 264.28,22.76 CD95.1
N129088477: length 2.6
  BOTTOM w0.102: RA63.2 RA66.1 v2(265.44,22.28) 265.28,22.12 UA2.8
N129088540: length 5.7
  BOTTOM w0.102: UA2.9 266.42,20.54 266.59,20.71 266.59,21.85 267.22,22.47 v1(267.22,23.5) 267.81,24.09 RA64.1 RA61.2
N129088559: length 4.8
  BOTTOM w0.102: RA60.2 268.28,22.16 RA62.1 267.93,21.81 v1(267.18,21.81) 267.09,21.81 266.88,21.6 266.88,20.3 266.62,20.04 UA2.10
N129089294: length 5.1
  BOTTOM w0.102: 258.86,22.72 259.14,22.72 260.59,21.28 260.59,20.69 260.74,20.54 UA2.32 ; 258.86,22.72 258.86,22.88 259.52,23.54 259.52,23.69 v1(259.83,23.99) ; 258.86,22.72 CD92.1
N129089311: length 3.4
  BOTTOM w0.102: CD91.1 259.5,21.78 v1(259.7,21.58) 259.93,21.35 260.16,21.35 260.36,21.15 260.36,20.36 260.68,20.04 UA2.31
N129089914: length 2.2
  BOTTOM w0.254: UA2.26 259.54,17.54 CA48.1
N129089927: length 1.9
  BOTTOM w0.102: 258.84,14.21 v1(256.98,14.21)
N129090458: length 1.5
  BOTTOM w0.254: CA49.2 262.78,14.91 UA2.22
N129090491: length 1.7
  BOTTOM w0.254: CA50.1 264.28,14.78 UA2.19
N129090627:
  vias: v1(267.19,14.28)
N129090703: length 2
  BOTTOM w0.254: UA2.15 v2(267.01,17.54) 268.08,17.54 CA51.2
N129091037: length 2.6
  BOTTOM w0.102: CA47.2 v1(270.29,15.2)
  BOTTOM w0.254: RA58.1 269.15,16.65 269.15,15.23 CA47.2
N129091040: length 2.3
  BOTTOM w0.102: v1(256.92,15.87) 256.97,15.92 RA57.2
  BOTTOM w0.254: RA57.2 257.95,14.7 CA46.1
N129091624: length 1.9
  TOP w0.203: HDA1.24 283.51,21.41 283.91,21.02 283.91,21
  TOP w0.508: CA21.1 283.63,20.34 283.91,20.62 283.91,21
N129161519: length 3.2
  TOP w0.102: DI1.2 62.56,27.94 v2(61.69,28.81) v1(61.69,28.19)
  BOTTOM w0.102: v2(61.69,28.81) 61.69,28.88 62.32,29.51 JEDP1.12
N129169183: length 4.5
  TOP w0.102: CA10.2 v1(286.55,37.33)
  TOP w0.254: UA1.3 287.9,37.09 CA10.2 288.38,38.04 288.81,38.04 RA2.2
N129172883: length 3.3
  BOTTOM w0.102: JDEG1.9 253.22,33.95 253.39,33.78 v1(254.9,33.78) 255.45,33.78 RE118.2
N129203755: length 2.2
  BOTTOM w0.102: v1(271.51,24.32) 272.4,24.32 CA33.1 272.73,23.99 RA35.1
N129347215: length 4.9
  TOP w0.102: RH499.1 190.33,23.54 191.16,24.37 RH103.2 RH105.1 ; RH499.1 189.93,23.13 v1(190.64,22.42) ; RH499.1 189.92,23.54 RH180.2
N129476748: length 2.5
  TOP w0.102: v1(260.97,38.65) 261.35,39.03 RM25.2 261.57,39.78 CM20.2 CM45.1
N129476750: length 4.1
  TOP w0.102: CM46.1 CM21.2 261.57,41.43 RM26.2 260.97,42.03 259.32,42.03 v1(259.01,41.72)
N129484386: length 10.2
  TOP w0.102: UM1.C6 264.93,36.68 264.93,38.13 263.56,39.5 263.56,39.98 263.34,40.19 263.34,40.57 262.62,41.29 262.35,41.29 262.04,41.6 262.04,41.87 261.88,42.03 261.35,42.03 RM4.1 259.98,42.46 v1(259.5,42.94)
N129506546: length 3.9
  TOP w0.102: v1(271,27.32) 270.49,26.81 270.49,26.41 270.04,25.95 RM10.2 269.73,25.95 269.22,26.46 UM2.7
N129510341: length 5.3
  TOP w0.102: v1(259.24,25.26) 259.12,25.39 259.09,25.39 259.04,25.44 258.74,25.44 258.64,25.54 258.05,25.54 257.95,25.64 CZ98.1 257.29,26.13 257.29,27.17 257.19,27.27 UZ22.6
N129677522: length 2.3
  BOTTOM w0.102: PQ403.3 56.03,31.14 PR419.2 56.68,31.16 56.7,31.13 v1(57.03,31.13)
N129680759: length 28.6
  BOTTOM w0.102: RH510.2 166.13,17.88 166.13,17.34 165.87,17.08 165.36,17.08 v1(165.03,16.75) 165.03,14.03 165.63,13.43 167.23,13.43 167.97,12.68 170.22,12.68 171.56,11.34 172.55,11.34 172.93,10.96 175.55,10.96 175.83,11.24 179.51,11.24 179.97,10.79 179.97,8.8 180.38,8.4 183.7,8.4 184.39,9.08 RE129.1
N129681032: length 25.7
  TOP w0.102: v2(171.08,10.15) 170.83,10.15 168.64,12.34
  TOP w0.114: 168.64,12.34 167.25,13.73 v3(166.2,13.73) 165.31,13.73 163.04,15.99 162.32,15.99 162.14,15.81 162.14,15.43 161.33,14.62 161.33,14.29 161.48,14.14 162.75,14.14 162.98,13.91 162.98,13.66 162.8,13.48 160,13.48 159.8,13.68 159.8,13.86 161.55,15.61 161.55,16.37 161.68,16.5 162.7,16.5 163.1,16.91 v2(163.1,17.21)
  BOTTOM w0.102: v2(163.1,17.21) 163.2,17.31 RH104.2
  BOTTOM w0.114: v2(171.08,10.15) 171.13,10.2 RE71.1
