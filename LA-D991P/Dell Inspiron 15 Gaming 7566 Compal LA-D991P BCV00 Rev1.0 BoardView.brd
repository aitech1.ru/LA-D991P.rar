# Allegro board Dell Inspiron 15 Gaming 7566 Compal LA-D991P BCV00 Rev1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA_D43: length 27.2
  IN3 w0.102: v2(158.31,98.98) 157.88,99.42 157.88,100.1 158.27,100.5 158.27,101.11 157.97,101.41 157.97,103.39 158.54,103.96 158.54,104.8 158.65,104.92 158.65,105.45 159.13,105.93
  IN3 w0.145: v2(157.5,120.09) 157.9,119.68 157.9,119.08 158.86,118.12 158.86,113.86 158.72,113.71 158.1,113.71 157.97,113.59 157.97,113.19 158.1,113.06 158.72,113.06 158.86,112.91 158.86,112.53 158.72,112.39 158.32,112.39 158.18,112.24 158.18,111.81 158.32,111.66 158.72,111.66 158.86,111.52 158.86,110.81 158.48,110.43 158.48,110.01 159.73,108.76 159.73,108.13 159.59,107.98 159.59,107.98 159.44,107.84 159.44,106.24 159.13,105.93
  BOTTOM w0.102: UV7.T13 v2(157.5,120.09) ; UV1.AK28 v2(158.31,98.98)
FBA_D44: length 27.4
  IN3 w0.102: v2(156.68,99.81) 156.29,100.2 156.29,101.53 157.12,102.36 157.12,103.24 156.82,103.55
  IN3 w0.145: v2(159.1,122.49) 158.7,122.09 157.34,122.09 157.09,121.83 157.09,121.5 156.88,121.29 156.42,121.29 155.66,120.52 155.66,109.28 156.82,108.12 156.82,103.55
  BOTTOM w0.102: UV7.N11 v2(159.1,122.49) ; v2(156.68,99.81) 156.29,99.42 UV1.AM29
FBA_D45: length 25.3
  IN3 w0.102: v2(155.89,100.66) 155.89,101.95 156.21,102.28 156.21,103.6
  IN3 w0.145: v2(157.5,122.49) 157.27,122.49 156.87,122.09 155.96,122.09 155.18,121.31 155.18,109.12 156.35,107.95 156.35,103.74 156.21,103.6
  BOTTOM w0.102: UV1.AM31 v2(155.89,100.66) ; UV7.N13 v2(157.5,122.49)
FBA_D46: length 30
  IN3 w0.102: v2(155.09,99.81) 154.56,100.34 154.56,101.89 155.5,102.83 155.5,103.71 155.42,103.79
  IN3 w0.145: v2(159.1,123.23) 158.65,123.68 156.21,123.68 154.26,121.73 154.26,108.77 155.42,107.61 155.42,103.79
  BOTTOM w0.102: v2(155.09,99.81) 155.09,99.81 155.49,99.41 UV1.AN29 ; v2(159.1,123.23) 158.75,122.89 UV7.M11
FBA_D47: length 27.2
  IN3 w0.102: 155.79,103.76 155.79,102.64 155.5,102.35 155.5,100.17 v2(155.89,99.78)
  IN3 w0.145: v2(157.5,123.29) 157.1,122.89 156.08,122.89 154.72,121.53 154.72,108.94 155.89,107.78 155.89,103.86 155.79,103.76
  BOTTOM w0.102: UV1.AM30 156.29,100.18 v2(155.89,99.78) ; UV7.M13 v2(157.5,123.29)
FBA_D48: length 38.9
  BOTTOM w0.13: UV1.AN31 154.94,101.06 154.74,100.86 153.44,100.86 152.53,101.77 152.53,108.64 153.86,109.97 v1(153.86,118.48) 153.86,130.65 155.81,132.6 157.78,132.6 UV7.A11
FBA_D49: length 35
  BOTTOM w0.13: UV1.AN32 155.26,101.91 154.9,101.55 154.37,101.55 154.22,101.7 154.03,101.7 153.02,102.71 153.02,108.4 v1(154.15,109.53) 154.37,109.74 154.37,130.36 156.05,132.04 156.93,132.04 157.1,131.88 UV7.A13
FBA_D50: length 41.5
  BOTTOM w0.13: UV7.B11 159.07,131.26 159.07,132.01 157.97,133.11 155.58,133.11 153.38,130.9 153.38,110.15 v1(152.06,108.84) 152.06,101.42 153.28,100.21 UV1.AP30
FBA_D51: length 36.2
  BOTTOM w0.13: UV1.AP32 154.4,101.91 153.51,102.79 153.51,108.02 v1(155.58,110.1) 155.58,110.91 155.69,111.02 156.17,111.02 156.3,111.15 156.3,111.53 156.17,111.66 155.04,111.66 154.91,111.79 154.91,112.17 155.04,112.3 156.22,112.3 156.35,112.42 156.35,112.8 156.22,112.93 155.04,112.93 154.87,113.1 154.87,129.26 156.04,130.43 156.63,130.43 UV7.B13
FBA_D52: length 35.3
  BOTTOM w0.13: UV7.E11 158.39,128.49 158,128.1 156.2,128.1 155.86,127.76 155.86,118.51 155.99,118.38 159.22,118.38 159.39,118.2 159.39,117.62 159.27,117.49 157.59,117.49 157.36,117.26 v1(157.36,115.53) 157.36,115 157.26,114.89 156.78,114.89 156.66,114.76 156.66,114.39 156.78,114.26 157.26,114.26 157.39,114.13 157.39,109.85 155.91,108.37 155.91,103.3 156.29,102.92 UV1.AM33
FBA_D53: length 37.1
  BOTTOM w0.13: UV7.E13 156.74,128.84 155.59,128.84 155.34,128.6 155.34,117.18 155.47,117.05 156.29,117.05 156.42,116.92 156.42,116.54 156.29,116.41 155.47,116.41 155.34,116.28 155.34,115.91 155.47,115.78 156.17,115.78 156.3,115.65 156.3,115.27 156.17,115.14 155.47,115.14 155.34,115.01 155.34,114.62 156.83,113.13 156.83,110.66 v1(154.05,107.88) 154.05,102.76 154.52,102.29 156.51,102.29 156.7,102.1 156.7,101.5 UV1.AL31
FBA_D54: length 36.5
  BOTTOM w0.13: UV7.F11 159,127.69 159.44,128.13 160.41,128.13 160.77,127.78 160.77,118.32 160.79,118.29 v1(160.79,116.62) 160.61,116.44 158.89,116.44 158.76,116.31 158.76,115.94 158.89,115.81 160.61,115.81 160.74,115.68 160.74,115.3 160.61,115.17 158.94,115.17 158.81,115.04 158.81,114.66 158.94,114.53 160.61,114.53 160.74,114.4 160.74,112.83 159.52,111.61 159.52,110.6 157.19,108.26 157.19,104.29 157.49,103.98 157.49,103.48 157.99,102.98 UV1.AK33
FBA_D55: length 37
  BOTTOM w0.13: UV7.F13 157.52,127.27 159.9,127.27 160.33,126.83 160.33,117.52 159.83,117.01 158.18,117.01 157.9,116.73 157.9,113.96 158.05,113.81 159.01,113.81 159.14,113.68 159.14,113.3 159.01,113.17 158,113.17 157.87,113.04 157.87,112.66 158,112.53 158.94,112.53 159.06,112.4 159.06,112.02 158.94,111.89 158.05,111.89 157.92,111.77 157.92,111.39 158.05,111.27 158.65,111.27 158.83,111.09 158.83,110.58 v1(156.55,108.29) 156.55,103.92 157.58,102.89 157.58,102.31 UV1.AK32
FBA_D56: length 37.7
  BOTTOM w0.102: 163.31,106.32 163.31,104.98 163.2,104.87 163.2,104.54 162.99,104.33 UV1.AD34
  BOTTOM w0.13: 163.31,106.32 v1(166.77,109.78) 168.82,111.83 168.82,112.16 168.56,112.41 168.41,112.41 168.23,112.59 168.23,112.89 168.82,113.48 168.82,114.95 169.71,115.84 169.71,126.07 168.97,126.81 168.97,131.54 167.47,133.04 165.41,133.04 164.83,132.45 164.83,132.22 UV7.A4
FBA_D57: length 36.7
  BOTTOM w0.102: 162.21,106.48 162.26,106.44 162.26,104.59 162.41,104.43 162.41,103.04 162.5,102.95 162.5,102.4 UV1.AD32
  BOTTOM w0.13: 162.21,106.48 162.21,107.03 v1(164.55,109.37) 165.6,110.42 165.6,111.76 167.85,114.01 167.85,115.46 168.76,116.37 168.76,125.71 168.05,126.42 168.05,128.49 167.92,128.61 167.57,128.61 167.45,128.74 167.45,129.12 167.57,129.25 167.85,129.25 167.98,129.38 167.98,129.76 167.85,129.89 167.62,129.89 167.49,130.02 167.49,130.4 167.62,130.53 167.86,130.53 168,130.67 168,131.11 167.05,132.06 166.26,132.06 UV7.A2
FBA_D58: length 43.4
  BOTTOM w0.102: UV1.AC30 163.4,100.69 163.4,103.72 163.32,103.8 163.32,104.23 163.94,104.84 163.94,106.05
  BOTTOM w0.13: UV7.B4 163.9,131.29 163.9,132.19 164.57,132.86 165.25,133.54 167.75,133.54 169.66,131.64 169.66,126.77 170.17,126.25 170.17,115.44 169.33,114.59 169.33,111.44 v1(165.91,108.03) 164.84,106.95 164.34,106.95 163.94,106.54 163.94,106.05
FBA_D59: length 37.4
  BOTTOM w0.102: UV1.AD33 162.99,102.94 162.63,103.3 162.63,104.28 162.72,104.36 162.72,106.63
  BOTTOM w0.13: UV7.B2 165.51,131.27 165.51,131.96 166.07,132.53 167.27,132.53 168.51,131.29 168.51,126.62 169.22,125.9 169.22,116.09 168.34,115.2 168.34,113.78 167.4,112.85 167.4,111.31 167.18,111.09 166.99,111.09 166.82,111.27 166.64,111.27 166.36,110.99 166.36,110.81 166.54,110.63 166.54,110.45 v1(163.45,107.36) 162.72,106.63
FBA_D60: length 39
  BOTTOM w0.102: 159.03,105.2 159.03,104.62 159.16,104.48 159.16,102.62 159.47,102.31 159.85,102.31 160.07,102.09 160.07,101.64 160.19,101.53 160.94,101.53 161.29,101.18 UV1.AF31
  BOTTOM w0.13: 159.03,105.2 v1(159.03,107.98) 161.2,110.15 161.2,111.21 162.26,112.27 162.26,113.25 162.39,113.38 164.12,113.38 164.25,113.51 164.25,113.89 164.12,114.02 162.39,114.02 162.26,114.15 162.26,114.53 162.39,114.66 164.07,114.66 164.2,114.79 164.2,115.16 164.07,115.29 162.45,115.29 162.26,115.49 162.26,127.5 162.8,128.03 163.84,128.03 UV7.E4
FBA_D61: length 37.2
  BOTTOM w0.102: 160.94,105.16 160.94,103.62 160.83,103.51 UV1.AG34
  BOTTOM w0.13: 160.94,105.16 160.94,106.79 164.82,110.67 164.82,111.69 167.37,114.24 v1(167.37,116.22) 167.57,116.42 168.06,116.42 168.2,116.57 168.2,117.04 168.07,117.17 167.47,117.17 167.35,117.29 167.35,117.68 167.47,117.8 168.07,117.8 168.2,117.93 168.2,118.31 168.07,118.44 167.7,118.44 167.57,118.57 167.57,118.95 167.7,119.08 168.07,119.08 168.2,119.21 168.2,119.59 168.07,119.72 167.7,119.72 167.57,119.85 167.57,120.22 167.7,120.35 168.07,120.35 168.2,120.48 168.2,120.86 168.07,120.99 167.7,120.99 167.57,121.12 167.57,121.5 167.7,121.63 168.07,121.63 168.2,121.76 168.2,122.14 168.07,122.27 167.7,122.27 167.57,122.4 167.57,122.77 167.7,122.9 168.07,122.9 168.2,123.03 168.2,123.41 168.07,123.54 167.7,123.54 167.57,123.67 167.57,124.05 167.7,124.18 168.07,124.18 168.2,124.31 168.2,124.69 168.07,124.82 167.7,124.82 167.57,124.95 167.57,125.32 167.7,125.45 167.88,125.45 168.02,125.59 168.02,125.81 167.59,126.23 167.59,127.96 167.44,128.11 166.58,128.11 166.2,128.49 UV7.E2
FBA_D62: length 37.4
  BOTTOM w0.102: 159.66,104.87 160.12,104.41 160.12,104 159.87,103.74 159.87,103.24 160.09,103.01 160.09,102.47 160.49,102.08 UV1.AG32
  BOTTOM w0.13: UV7.F4 163.88,127.27 163.36,127.27 162.67,126.58 162.67,118.53 163.17,118.04 163.17,116.3 163.3,116.17 163.79,116.17 163.92,116.3 163.92,117.84 164.05,117.97 164.47,117.97 165.03,117.41 165.03,115.56 165.16,115.43 166.22,115.43 166.35,115.3 166.35,114.92 166.22,114.79 165.16,114.79 165.03,114.66 165.03,113.48 164.09,112.54 163.33,112.54 161.91,111.12 161.91,110.13 159.66,107.88 v1(159.66,106.09) 159.66,104.87
FBA_D63: length 37.1
  BOTTOM w0.102: UV1.AG33 160.49,102.95 160.11,103.33 160.11,103.64 160.5,104.03 160.5,104.82 160.3,105.02
  BOTTOM w0.13: UV7.F2 166.27,127.32 166.92,127.32 167.09,127.15 167.09,118.29 166.75,117.95 165.65,117.95 165.52,117.82 165.52,117.44 165.65,117.31 166.75,117.31 166.88,117.18 166.88,116.8 166.75,116.67 165.65,116.67 165.52,116.54 165.52,116.17 165.65,116.04 166.75,116.04 166.88,115.91 v1(166.88,114.5) 164.09,111.72 164.09,110.71 163.83,110.45 163.65,110.45 163.44,110.66 163.25,110.66 162.99,110.39 162.99,110.21 163.2,110 163.2,109.82 162.93,109.55 162.75,109.55 162.54,109.76 162.35,109.76 162.09,109.49 162.09,109.31 162.29,109.1 162.29,108.91 162.03,108.65 161.84,108.65 161.63,108.86 161.45,108.86 161.18,108.59 161.18,108.41 161.39,108.2 161.39,108.01 161.13,107.75 160.94,107.75 160.73,107.95 160.55,107.95 160.28,107.69 160.28,107.5 160.49,107.29 160.49,107.11 160.3,106.92 160.3,105.02
FBA_DBI0#: length 27.3
  IN3 w0.102: v2(171.71,100.71) 172.13,101.13 172.13,101.87 171.74,102.26 171.74,104.32 172.14,104.71 172.14,104.92
  IN3 w0.145: 172.14,104.92 172.3,105.08 172.3,111.04 172.52,111.26 173.34,111.26 174.13,110.48 174.31,110.48 174.62,110.8 174.62,110.98 173.44,112.16 173.44,112.7 174.09,113.35 174.09,120.22 174.35,120.49 175.37,120.49 175.77,120.89 v2(176,120.89)
  BOTTOM w0.102: UV6.D2 v2(176,120.89) ; v2(171.71,100.71) 171.31,100.31 UV1.P30
FBA_DBI1#: length 26.1
  IN3 w0.145: v2(177.56,101.51) 177.56,102.27 178.51,103.22 178.51,106.01 182.05,109.55 182.05,110.43 186.32,114.7 186.32,117.26 186.85,117.8 186.85,120.21 186.5,120.56 186.03,120.56 185.96,120.5 185.19,120.5 v2(184.8,120.89)
  BOTTOM w0.102: UV1.F31 177.96,101.11 v2(177.56,101.51)
  BOTTOM w0.107: UV6.D13 v2(184.8,120.89)
FBA_DBI2#: length 31.1
  IN1 w0.147: v2(185.6,128.89) 185.66,128.83 185.66,127.07 188.05,124.68 188.05,114.13 v2(178.06,104.14)
  BOTTOM w0.102: UV1.F34 177.99,104.07 v2(178.06,104.14)
  BOTTOM w0.107: UV6.P13 v2(185.6,128.89)
FBA_DBI3#: length 34.8
  BOTTOM w0.102: UV1.M32 172.59,102.31 172.59,102.87 172.4,103.06 172.4,103.81 172.57,103.98 172.57,104.77 172.42,104.92 172.42,106.02 171.95,106.48 171.95,106.67
  BOTTOM w0.13: UV6.P2 176.77,129.66 176.77,130.35 176.65,130.48 176.22,130.48 176.02,130.68 176.02,131.01 175.76,131.28 174.96,131.28 v1(172.83,129.15) 172.83,127.35 172.83,113.57 172.38,113.12 172.38,107.89 171.95,107.46 171.95,106.67
FBA_DBI4#: length 25.2
  IN3 w0.102: 164.5,107.18 164.06,106.74 164.06,105.45 163.11,104.5 163.11,101.25 v2(162.56,100.7)
  IN3 w0.145: 164.5,107.18 164.5,107.99 166.86,110.35 166.86,116.03 166.6,116.29 166.16,116.29 166,116.46 166,116.8 166.16,116.96 166.6,116.96 166.76,117.13 166.76,120.27 166.55,120.48 165.9,120.48 v2(165.5,120.89)
  BOTTOM w0.102: UV7.P2 v2(165.5,120.89) ; UV1.AD31 162.97,101.11 v2(162.56,100.7)
FBA_DBI5#: length 25.4
  IN3 w0.102: v2(156.69,98.98) 157.08,99.37 157.08,101.64 157.34,101.9 157.34,104.21 157.41,104.28
  IN3 w0.145: 157.41,104.28 157.41,108.35 156.22,109.54 156.22,120.23 156.48,120.49 156.86,120.49 157.1,120.74 157.1,121.04 157.5,121.44 v2(157.5,121.69)
  BOTTOM w0.102: v2(156.69,98.98) 157.09,99.38 UV1.AL29 ; UV7.P13 v2(157.5,121.69)
FBA_DBI6#: length 34
  IN3 w0.145: v2(153.29,101.62) 153.09,101.82 153.09,122.23 155.76,124.91 155.76,127.58 156.82,128.63 156.82,129.06 157.45,129.69 v2(157.5,129.69)
  BOTTOM w0.102: v2(153.29,101.62) 153.29,101.55 153.53,101.31 155.04,101.31 155.25,101.51 155.9,101.51 UV1.AM32
  BOTTOM w0.107: UV7.D13 v2(157.5,129.69)
FBA_DBI7#: length 32.1
  IN1 w0.147: v2(166.3,129.69) 165.9,130.08 162.89,130.08 161.25,128.44 161.25,121.44 160.86,121.06 160.86,118.98 160.61,118.74 160.61,117.08 161.07,116.63 161.07,106.02 v2(161.49,105.6)
  BOTTOM w0.102: UV1.AF34 161.29,104.47 161.49,104.67 v2(161.49,105.6)
  BOTTOM w0.107: UV7.D2 v2(166.3,129.69)
FBA_EDC0: length 28
  IN3 w0.102: 172.47,102.43 172.56,102.33 172.56,101.51 v2(172.56,101.51)
  IN3 w0.145: 172.47,102.43 172.37,102.53 172.37,103.75 172.61,103.99 172.61,104.85 172.86,105.1 172.86,108.07 173.67,108.88 173.67,109.16 172.88,109.95 172.88,110.13 173.15,110.4 173.41,110.4 174.27,109.54 174.45,109.54 175.81,110.9 175.81,111.08 174.92,111.97 174.46,111.97 174.3,112.13 174.3,112.48 174.46,112.64 174.66,112.64 174.79,112.77 174.79,116.3 174.98,116.49 174.98,117.3 174.79,117.49 174.79,118.04 174.93,118.19 175.22,118.19 175.35,118.31 175.35,118.78 175.22,118.91 174.93,118.91 174.79,119.06 174.79,119.42 175.86,120.49 176.4,120.49 v2(176.8,120.89)
  BOTTOM w0.102: UV6.C2 v2(176.8,120.89) ; v2(172.56,101.51) 172.96,101.11 UV1.M31
FBA_EDC1: length 25.7
  IN1 w0.147: v2(175.2,104.64) 175.2,104.95 185.33,115.08 185.33,119.56 v2(184.8,120.09)
  BOTTOM w0.107: UV6.C13 v2(184.8,120.09)
  BOTTOM w0.127: UV1.G31 177.11,101.11 176.71,101.51 175.33,101.51 175.09,101.76 175.09,103.8 175.2,103.91 v2(175.2,104.64)
FBA_EDC2: length 33.5
  BOTTOM w0.102: 179.17,104.31 179.17,103.09 UV1.E33 ; 187.39,127.12 187.22,127.28 187.22,127.61 186.75,128.08 186.75,130.17 186.45,130.47 185.58,130.47 UV6.R13
  BOTTOM w0.13: 179.17,104.31 179.17,104.47 180.63,105.92 180.63,108.7 180.63,108.7 180.63,109.23 v1(186.26,114.86) 187.83,116.43 187.83,124.27 187.39,124.71 187.39,127.12
FBA_EDC3: length 30.7
  BOTTOM w0.102: UV1.M33 172.99,102.85 172.62,103.22 172.62,103.66 172.9,103.94 172.9,106.16 172.59,106.47
  BOTTOM w0.13: 172.59,106.47 172.59,107.2 173.02,107.63 173.02,112.85 173.47,113.3 v1(173.47,114.82) 173.47,124.89 173.47,128.82 174.79,130.14 175.07,130.14 175.42,130.5 175.72,130.5 176.13,130.09 UV6.R2
FBA_EDC4: length 24.2
  IN3 w0.102: v2(162.56,101.46) 162.8,101.7 162.8,104.64 163.8,105.63 163.8,106.45 ; 165.9,118.93 165.92,118.91
  IN3 w0.145: 165.9,118.93 165.9,119.68 v2(165.5,120.09) ; 163.8,106.45 163.8,107.01 163.89,107.1 163.89,108.55 165.36,110.02 165.36,113.01 165.53,113.17 166.12,113.17 166.28,113.33 166.28,113.68 166.12,113.84 165.53,113.84 165.36,114 165.36,114.35 165.53,114.51 166.12,114.51 166.28,114.67 166.28,115.02 166.12,115.18 165.53,115.18 165.36,115.34 165.36,117.3 165.92,117.86 165.92,118.91
  BOTTOM w0.102: UV1.AE31 162.21,101.11 v2(162.56,101.46) ; UV7.R2 v2(165.5,120.09)
FBA_EDC5: length 24.9
  IN3 w0.102: 157.57,103.96 157.57,101.71 157.53,101.68 v2(157.53,100.79)
  IN3 w0.145: 157.57,103.96 157.97,104.36 157.97,108.68 156.8,109.85 156.8,116.02 157.04,116.25 157.72,116.25 157.85,116.38 157.85,116.78 157.72,116.9 156.93,116.9 156.8,117.03 156.8,117.43 156.93,117.56 157.24,117.56 157.36,117.68 157.36,118.08 157.24,118.21 156.89,118.21 156.75,118.35 156.75,118.75 157.1,119.1 157.1,120.26 157.5,120.65 v2(157.5,120.89)
  BOTTOM w0.102: UV1.AK30 157.89,100.44 v2(157.53,100.79) ; UV7.R13 v2(157.5,120.89)
FBA_EDC6: length 31.8
  IN3 w0.145: v2(157.5,130.49) 157.89,130.1 157.89,129.85 157.89,129.45 157.9,129.43 157.9,128.53 157.56,128.18 157.03,128.18 156.23,127.38 156.23,124.56 153.68,122.01 153.68,108.19 154,107.86 154,103.42 154.29,103.13 v2(155.06,103.13)
  BOTTOM w0.107: UV7.C13 v2(157.5,130.49) ; UV1.AN33 v2(155.06,103.13)
FBA_EDC7: length 31.4
  IN1 w0.147: v2(161.51,106.78) 161.65,106.92 161.65,116.89 161.17,117.36 161.17,118.63 161.32,118.78 161.32,120.87 161.7,121.25 161.7,124.5 161.92,124.72 161.92,128.27 162.95,129.3 165.11,129.3 v2(165.5,129.69)
  BOTTOM w0.102: v2(161.51,106.78) 161.52,106.78 161.9,106.4 161.9,104.5 161.5,104.09 161.5,103.83 161.64,103.69 161.64,103.04 161.31,102.71 UV1.AF33
  BOTTOM w0.107: UV7.C2 v2(165.5,129.69)
FBA_MA0_MA10_H: length 29.9
  IN1 w0.102: 166.01,100.02 166.01,100.9 166.27,101.15 166.27,102.63 163.15,105.76 162.69,105.76
  IN1 w0.14: v2(165.89,99.9) 166.01,100.02
  IN1 w0.147: v2(163.08,124.96) 163.08,124.87 162.15,123.94 162.15,121.07 161.77,120.68 161.77,117.65 162.22,117.2 162.22,106.23 162.69,105.76
  BOTTOM w0.102: UV7.K4 163.9,124.89 163.15,124.89 v2(163.08,124.96) ; UV1.Y30 166.29,100.31 165.89,99.91 v2(165.89,99.9)
FBA_MA0_MA10_L: length 35.3
  IN1 w0.102: 167.1,107.19 167.1,106.39 167.22,106.27 167.22,105.69 167.26,105.64 167.26,104.83 167.97,104.12 167.97,101.06 v2(167.61,100.7)
  IN1 w0.147: v2(177.6,124.89) 177.6,125.06 178.02,125.47 178.02,125.83 177.74,126.1 176.54,126.1 176.21,126.43 174.47,126.43 169.33,121.29 169.33,118.18 167.19,116.04 167.19,107.29 167.1,107.19
  BOTTOM w0.102: v2(167.61,100.7) 167.99,100.32 UV1.V30 ; UV6.H4 v2(177.6,124.89)
FBA_MA1_MA9_H: length 23.1
  IN1 w0.102: v2(165.36,104.1) 165.12,104.1 162.86,106.37 162.79,106.37
  IN1 w0.147: 162.79,106.37 162.67,106.49 162.67,117.45 162.22,117.9 162.22,120.49 162.6,120.88 162.6,123.72 162.97,124.09 v2(163.1,124.09)
  BOTTOM w0.102: UV7.K5 v2(163.1,124.09)
  BOTTOM w0.127: v2(165.36,104.1) 165.36,103.64 165.48,103.51 UV1.AA34
FBA_MA1_MA9_L: length 28.6
  IN1 w0.147: v2(178.4,124.09) 178.79,123.7 178.79,122.33 178.55,122.09 173.97,122.09 172.04,120.17 172.04,117.06 170.3,115.31 170.3,107.1 169.48,106.29 169.39,106.29 v2(169.34,106.24)
  BOTTOM w0.102: 169.73,105.5 169.46,105.23 169.46,104.75 168.74,104.02 168.74,103.56 UV1.U34 ; UV6.H5 v2(178.4,124.09)
  BOTTOM w0.13: v2(169.34,106.24) v1(169.73,105.85) 169.73,105.5
FBA_MA2_BA0_H: length 35
  IN1 w0.102: 158.09,106.14 158.09,105.68 158.87,104.91 159.69,104.91 161.23,103.37 162.68,103.37 163.34,102.71 164.35,102.71 164.65,102.41 164.65,102.08 165.2,101.53 165.2,101.21 165.45,100.97 165.45,100.55 165.2,100.29 164.94,100.29 164.66,100.01 164.66,99.47 v2(165.07,99.05)
  IN1 w0.147: 158.09,106.14 158.09,114.88 157.08,115.89 157.08,118.1 156.08,119.1 156.08,122.51 156.46,122.9 157.66,122.9 157.66,122.9 157.73,122.9 157.9,123.08 157.9,123.39 158.13,123.62 158.63,123.62 v2(159.1,124.09)
  BOTTOM w0.102: UV7.K11 v2(159.1,124.09) ; v2(165.07,99.05) 165.07,99.03 UV1.AA28
FBA_MA2_BA0_L: length 35
  IN1 w0.102: 170.58,102.19 170.44,102.05 170.44,99.68 169.96,99.2 v2(169.79,99.2)
  IN1 w0.147: 170.58,102.19 170.58,102.19 171.43,103.04 172.42,103.04 177.93,108.55 177.93,114.07 182.75,118.89 182.75,121.84 182.99,122.09 184.24,122.09 184.41,122.26 184.41,124.48 v2(184,124.89)
  BOTTOM w0.102: UV1.U29 169.54,99.46 v2(169.79,99.2)
  BOTTOM w0.107: UV6.H11 v2(184,124.89)
FBA_MA3_BA3_H: length 32.9
  IN1 w0.102: v2(165.88,99.05) 165.5,99.44 165.5,100.1 165.65,100.26 165.65,101.07 165.5,101.22 165.5,102.41 164.99,102.92 163.66,102.92 162.23,104.35 160.67,104.35 159.69,105.33 159.58,105.33 159.29,105.63
  IN1 w0.147: v2(159.9,124.09) 159.49,123.68 159.49,122.34 159.49,122.33 159.49,122.33 159.26,122.1 159.25,122.1 159.24,122.09 158.12,122.09 157.89,121.86 157.89,119.07 158.03,118.93 158.03,116.28 159.04,115.27 159.04,105.88 159.29,105.63
  BOTTOM w0.102: UV7.K10 v2(159.9,124.09) ; UV1.AA29 165.88,99.06 v2(165.88,99.05)
FBA_MA3_BA3_L: length 30.7
  IN1 w0.147: v2(169.61,103.85) 169.71,103.94 171.31,103.94 176.99,109.62 176.99,114.41 181.84,119.27 181.84,123.1 182.83,124.09 v2(183.2,124.09)
  BOTTOM w0.102: v2(169.61,103.85) 169.92,103.54 169.92,103.15 170.08,102.99 170.08,101.54 UV1.T31
  BOTTOM w0.107: UV6.H10 v2(183.2,124.09)
FBA_MA4_BA2_H: length 28.1
  IN1 w0.102: v2(163.72,104.05) 163.35,104.05 162.46,104.94 160.98,104.94 160.6,105.32 ; v2(158.3,125.69) 158.68,126.07 159.25,126.07 160.54,124.78 160.54,121.94 159.5,120.9 159.5,119
  IN1 w0.147: 159.5,119 159.5,116.09 159.99,115.6 159.99,105.94 160.6,105.32
  BOTTOM w0.102: UV7.H11 v2(158.3,125.69)
  BOTTOM w0.107: UV1.AC34 163.79,103.98 v2(163.72,104.05)
FBA_MA4_BA2_L: length 28.3
  IN1 w0.147: v2(183.25,125.69) 183.25,125.49 182.74,124.98 182.74,124.63 181.39,123.29 181.39,119.56 172.7,110.87 172.7,105.97 171.12,104.39 v2(170.64,104.39)
  BOTTOM w0.102: UV1.R34 170.42,103.58 170.42,104.17 v2(170.64,104.39)
  BOTTOM w0.107: UV6.K11 183.25,125.73 v2(183.25,125.69)
FBA_MA5_BA1_H: length 29.4
  IN1 w0.102: 159.49,105.96 160.8,104.65 162.39,104.65 163.69,103.34 v2(164.65,103.34) ; v2(159.1,125.69) 160.28,124.51 160.28,122.18 159.4,121.3
  IN1 w0.147: 159.4,121.3 158.92,121.3 158.69,121.07 158.69,116.26 159.49,115.46 159.49,105.96
  BOTTOM w0.102: UV7.H10 v2(159.1,125.69)
  BOTTOM w0.127: v2(164.65,103.34) 164.42,103.34 UV1.AC33
FBA_MA5_BA1_L: length 29.8
  IN1 w0.102: v2(170.21,105.67) 170.45,105.91 171.25,105.91 171.8,106.46
  IN1 w0.147: v2(182.46,125.67) 182.44,125.69 181.77,125.69 180.49,124.41 180.49,119.94 171.8,111.25 171.8,106.46
  BOTTOM w0.102: v2(170.21,105.67) 170.33,105.55 170.33,104.87 170.19,104.73 170.19,103.71 170.13,103.65 170.13,103.34 170.49,102.98 UV1.R33
  BOTTOM w0.107: UV6.K10 182.47,125.76 182.47,125.71 182.46,125.69 v2(182.46,125.67)
FBA_MA6_MA11_H: length 30.4
  IN1 w0.102: 163.35,106.42 163.5,106.27 163.5,106.01 165,104.51 165.49,104.51 166.47,103.53 166.47,101.07 166.3,100.9 166.3,99.44 166.63,99.11 166.63,99.11 v2(166.67,99.07)
  IN1 w0.147: 163.35,106.42 163.12,106.64 163.12,117.75 162.67,118.2 162.67,120.31 163.06,120.69 163.06,123.49 163.48,123.91 163.48,123.92 163.49,123.93 163.49,125.3 v2(163.1,125.69)
  BOTTOM w0.102: UV1.Y28 166.29,98.78 166.58,99.07 v2(166.67,99.07) ; UV7.H5 v2(163.1,125.69)
FBA_MA6_MA11_L: length 35
  IN1 w0.102: v2(169.21,99.03) 168.72,99.53 168.72,100.03 169.06,100.37 169.37,100.37 169.62,100.62 169.62,101.91 169.15,102.38 169.15,104.43 169.44,104.72 169.44,105.25 169.7,105.51 169.7,105.73 170.13,106.16 170.84,106.16 171.35,106.67
  IN1 w0.147: v2(178.42,126.5) 178.95,125.97 178.95,125.88 179.77,125.07 179.77,119.85 171.35,111.43 171.35,106.67
  BOTTOM w0.102: UV1.U28 v2(169.21,99.03)
  BOTTOM w0.13: v2(178.42,126.5) 178.8,126.12 UV6.K5
FBA_MA7_MA8_H: length 24.7
  IN1 w0.102: 164.02,106.87 164.02,106.31 v2(164.45,105.88)
  IN1 w0.147: 164.02,106.87 164.02,118.71 164.3,118.98 164.3,123.44 164.31,123.45 164.31,123.45 164.55,123.7 164.55,124.48 164.27,124.76 164.27,125.26 v2(164.7,125.69)
  BOTTOM w0.102: UV1.AA33 165.13,103.07 165.13,103.71 164.45,104.39 v2(164.45,105.88) ; UV7.H4 v2(164.7,125.69)
FBA_MA7_MA8_L: length 31.3
  IN1 w0.102: v2(169.24,105.64) 169.38,105.78 169.43,105.78 170.19,106.54 170.51,106.54
  IN1 w0.147: 170.51,106.54 170.59,106.54 170.89,106.85 170.89,114.66 172.93,116.7 172.93,119.32 174.89,121.28 175.83,121.28 175.84,121.28 178.56,121.28 178.57,121.28 178.83,121.28 179.18,121.63 179.18,124.91 v2(178.41,125.68)
  BOTTOM w0.102: UV6.K4 v2(178.41,125.68) ; v2(169.24,105.64) 168.94,105.64 168.56,105.27 168.56,105.02 168.34,104.79 168.34,103.24 168.79,102.79 UV1.U33
FBA_MA12_RFU_H: length 28.7
  IN1 w0.102: 163.57,106.75 163.73,106.59 163.73,106.07 165.08,104.71 165.57,104.71 166.68,103.61 v2(166.68,100.71)
  IN1 w0.147: 163.57,106.75 163.57,118.19 163.28,118.48 163.28,119.6 163.49,119.81 163.49,123.47 163.71,123.69 164.03,123.69 164.04,123.7 164.06,123.7 164.29,123.93 164.29,123.94 164.3,123.95 164.3,124.39 163.9,124.79 v2(163.9,125.69)
  BOTTOM w0.102: UV7.J5 v2(163.9,125.69) ; UV1.W31 167.08,101.11 v2(166.68,100.71)
FBA_MA12_RFU_L: length 33.1
  IN1 w0.102: 169,106.86 168.62,106.48 168.62,105.46 168.37,105.21 168.37,104.66 168.62,104.41 168.62,100.64 168.39,100.41 v2(168.39,99.03)
  IN1 w0.147: v2(178.39,124.93) 177.96,124.5 177.77,124.5 177.76,124.5 175.1,124.5 171.14,120.54 171.14,117.43 169,115.29 169,106.86
  BOTTOM w0.102: UV1.V29 167.99,99.43 v2(168.39,99.03) ; UV6.J5 178.44,124.93 v2(178.39,124.93)
FBA_RAS#_H: length 27.1
  IN1 w0.102: 165.44,106.88 165.31,106.75 165.31,105.53 165.51,105.32 165.89,105.32 166.2,105.02 v2(166.51,105.02)
  IN1 w0.147: 165.44,106.88 165.44,107.1 165.38,107.16 165.38,116.79 167.52,118.93 167.52,122.74 166.58,123.69 166.1,123.69 165.7,124.09 v2(165.5,124.09)
  BOTTOM w0.102: UV1.Y31 166.68,101.5 166.68,102.86 166.92,103.1 166.92,104.08 166.82,104.18 166.82,104.71 v2(166.51,105.02) ; UV7.L3 v2(165.5,124.09)
FBA_RAS#_L: length 29
  IN1 w0.102: v2(169.21,100.75) 168.86,101.11 168.86,104.58 168.58,104.85 168.58,105.11 168.86,105.39 168.86,106.31 169.45,106.91
  IN1 w0.147: v2(176.79,124.04) 176.44,123.69 174.93,123.69 171.59,120.35 171.59,117.24 169.45,115.1 169.45,106.91
  BOTTOM w0.102: UV6.G3 176.84,124.04 v2(176.79,124.04) ; UV1.U31 168.86,101.11 v2(169.21,100.75)
FBA_RST#_H: length 27.8
  TOP w0.13: v2(165.72,105.84) 165.16,105.84 164.7,105.37 163.21,105.37 RV107.1
  IN1 w0.102: v2(165.72,105.84) 165.64,105.93 165.64,106.53 165.91,106.8
  IN1 w0.147: v2(165.5,124.89) 165.9,124.49 166.6,124.49 167.98,123.11 167.98,118.74 165.83,116.6 165.83,107.09 165.91,107 165.91,106.8
  BOTTOM w0.102: UV7.J2 v2(165.5,124.89) ; 165.67,105.62 165.43,105.39 165.43,104.86 166.29,104 UV1.Y34
  BOTTOM w0.13: v2(165.72,105.84) 165.72,105.68 165.67,105.62
FBA_RST#_L: length 28.5
  TOP w0.102: v2(167.97,105.17) 167.53,105.17 166.34,103.99 RV108.1
  IN1 w0.102: 168.34,105.74 168.34,105.54 v2(167.97,105.17)
  IN1 w0.147: v2(176,124.89) 174.85,124.89 170.69,120.73 170.69,117.62 168.55,115.48 168.55,106.97 168.34,106.76 168.34,105.74
  BOTTOM w0.102: v2(167.97,105.17) 167.99,105.16 UV1.V34 ; UV6.J2 v2(176,124.89)
FBA_WCK0: length 27
  IN3 w0.13: v2(178.4,120.89) 178.46,120.83 178.68,120.83 178.85,121 178.85,121.3 179.01,121.46 179.33,121.46 180.1,120.69 180.1,112.49 179,111.39 179,110.38 175.6,106.98 175.6,104.4 174.78,103.58 174.78,100.6 174.48,100.31 174.31,100.31 174.17,100.45 174.17,100.65 v2(174.23,100.71)
  BOTTOM w0.114: v2(174.23,100.71) 174.63,101.11 UV1.K31 ; UV6.D4 v2(178.4,120.89)
FBA_WCK0_N: length 27
  IN3 w0.13: v2(174.23,99.89) 174.39,99.89 175.01,100.51 175.01,103.48 175.83,104.3 175.83,106.89 179.23,110.29 179.23,111.3 180.33,112.39 180.33,120.79 179.43,121.69 v2(178.4,121.69)
  BOTTOM w0.114: UV1.L30 173.82,100.31 v2(174.23,99.89) ; UV6.D5 v2(178.4,121.69)
FBA_WCK1: length 30.8
  BOTTOM w0.114: UV6.P4 178.34,129.63 179.86,129.63 180.97,128.52 180.97,116.01 v4(179.74,114.77) 176.49,111.52 176.49,107.86 176.52,107.83 176.52,107.23 176.49,107.21 176.49,106.31 175.98,105.8 175.98,104 176.29,103.69 UV1.H34
FBA_WCK1_N: length 30.8
  BOTTOM w0.114: UV6.P5 178.8,128.95 178.96,128.79 179.12,128.79 179.23,128.91 179.23,129.31 179.35,129.42 179.77,129.42 180.77,128.43 180.77,116.09 179.82,115.15 179.79,115.15 179.36,114.73 179.36,114.69 176.28,111.61 v4(176.28,107.53) 176.28,106.39 175.77,105.88 175.77,103.86 175.9,103.73 175.9,103.53 175.78,103.42 175.58,103.42 UV1.J34
FBA_WCK2: length 26.3
  IN3 w0.102: 159.85,102.56 159.85,102.53 159.87,102.52 159.87,102 159.67,101.8 159.67,100.34 v2(160.07,99.94)
  IN3 w0.13: v2(163.9,121.69) 162.87,121.69 161.55,120.37 161.55,119.03 160.21,117.69 160.21,111.93 161.21,110.93 161.21,107.38 160.83,107 160.83,105.56 160.12,104.85 160.12,103.44 159.85,103.18 159.85,102.56
  BOTTOM w0.102: UV7.P4 v2(163.9,121.69)
  BOTTOM w0.114: UV1.AG30 160.44,100.31 v2(160.07,99.94)
FBA_WCK2_N: length 26.3
  IN3 w0.102: v2(160.06,100.68) 160.22,100.85 160.22,101.04 160.11,101.16 159.97,101.16 159.87,101.26 159.87,101.72 160.07,101.92 160.07,102.52 160.09,102.53 160.09,102.56
  IN3 w0.13: v2(163.9,120.89) 163.9,120.71 163.75,120.56 163.54,120.56 163.41,120.69 163.41,121.33 163.29,121.46 162.96,121.46 161.78,120.28 161.78,118.94 160.44,117.59 160.44,112.03 161.44,111.02 161.44,107.28 161.06,106.9 161.06,105.46 160.35,104.75 160.35,103.35 160.09,103.08 160.09,102.56
  BOTTOM w0.102: UV7.P5 v2(163.9,120.89)
  BOTTOM w0.114: v2(160.06,100.68) 160.48,101.11 UV1.AG31
FBA_WCK3: length 29.8
  BOTTOM w0.114: UV7.D4 163.9,128.9 162.06,128.9 161.63,128.47 v4(161.63,114.57) 161.63,112.53 160.39,111.29 160.39,110.28 158.02,107.92 158.02,106.54 158.05,106.51 158.05,105.91 158.02,105.89 158.02,104.69 158.47,104.24 158.47,103.83 UV1.AJ34
FBA_WCK3_N: length 29.8
  BOTTOM w0.114: UV1.AK34 158.26,103.78 158.26,104.16 157.82,104.61 v4(157.82,106.21) 157.82,108 160.18,110.36 160.18,111.37 161.42,112.62 161.42,114.24 161.4,114.27 161.4,114.87 161.42,114.9 161.42,128.55 161.98,129.1 162.94,129.1 163.05,129.22 163.05,129.49 163.17,129.61 163.38,129.61 163.5,129.49 UV7.D5
FBA_WE#_H: length 32.8
  IN1 w0.102: v2(158.3,126.49) 158.68,126.87 160.05,126.87 160.79,126.13 160.79,121.63 160.41,121.24 160.41,121.12 ; 160.9,105.67 160.9,105.44 161.15,105.19 163.39,105.19 165.89,102.69 v2(165.89,101.51)
  IN1 w0.147: 160.41,121.12 160.41,119.19 160.03,118.81 160.03,116.8 160.44,116.39 160.44,106.12 160.9,105.67
  BOTTOM w0.102: UV7.G12 v2(158.3,126.49) ; UV1.AA32 v2(165.89,101.51)
FBA_WE#_L: length 32.4
  IN1 w0.102: v2(169.81,104.44) 169.98,104.44 170.35,104.81 170.35,105.18 170.82,105.65 171.55,105.65
  IN1 w0.147: 171.55,105.65 172.25,106.35 172.25,111.06 180.94,119.75 180.94,123.6 182.85,125.51 182.85,125.88 183.06,126.09 183.6,126.09 v2(184,126.49)
  BOTTOM w0.102: v2(169.81,104.44) 169.63,104.44 169.14,103.95 169.14,102.25 UV1.U32
  BOTTOM w0.107: UV6.L12 v2(184,126.49)
FBC_ABI#_H: length 32.7
  IN1 w0.102: 183.62,92.17 183.59,92.14 183.59,91.14 182.13,89.68 178.46,89.68 177.76,88.98 v2(177.61,88.98)
  IN1 w0.147: 183.62,92.17 183.62,92.29 185.06,93.74 187.21,93.74 192.86,99.39 200.05,99.39 200.42,99.76 203.03,99.76 203.46,99.34 v2(203.46,98.99)
  BOTTOM w0.102: UV1.G17 v2(177.61,88.98) ; UV9.J4 v2(203.46,98.99)
FBC_ABI#_L: length 32
  IN1 w0.102: 185.52,88.82 185.49,88.85 184.02,88.85 183.88,89 183.24,89 182.87,88.62 180.64,88.62 180.36,88.34 179.82,88.34 179.6,88.57 178.05,88.57 v2(177.61,88.13)
  IN1 w0.147: v2(204.26,85.48) 204.66,85.88 204.66,88.2 204.05,88.82 185.52,88.82
  BOTTOM w0.102: UV8.J4 v2(204.26,85.48) ; UV1.F15 v2(177.61,88.13)
FBC_CAS#_H: length 31.9
  IN1 w0.102: 183.97,89.72 183.6,89.72 182.82,88.94 180.62,88.94 180.26,88.58 179.92,88.58 179.47,89.03 v2(179.29,89.03)
  IN1 w0.147: 183.97,89.72 189.9,89.72 194.53,94.35 202.68,94.35 204.66,96.33 204.66,97.79 v2(205.06,98.19)
  BOTTOM w0.102: v2(179.29,89.03) 178.92,89.41 UV1.E17 ; UV9.G3 v2(205.06,98.19)
FBC_CAS#_L: length 29.4
  IN1 w0.147: v2(205.06,85.48) 205.5,85.92 205.5,86.93 205.06,87.37 205.06,88.71 204.51,89.27 185.04,89.27 185.04,89.27 v2(184.43,89.27)
  BOTTOM w0.102: v2(184.43,89.27) 183.95,88.79 181.61,88.79 181.48,88.91 180.98,88.91 UV1.C17 ; UV8.L3 v2(205.06,85.48)
FBC_CKE_H: length 30.3
  TOP w0.13: RV99.2 183.95,89.7 184.51,89.7 184.62,89.82 185.14,89.82 v2(185.57,90.25)
  IN1 w0.147: v2(204.26,97.39) 203.86,96.99 203.86,96.17 202.49,94.8 194.34,94.8 189.72,90.17 185.64,90.17 v2(185.57,90.25)
  BOTTOM w0.102: UV1.B17 181.47,89.41 181.85,89.02 183.4,89.02 184.18,89.8 185.13,89.8 v2(185.57,90.25) ; UV9.J3 v2(204.26,97.39)
FBC_CKE_L: length 27.6
  TOP w0.13: v2(183.26,88.21) 182.86,87.81 182.85,87.81 182.84,87.8 182.09,87.8 RV96.2
  IN1 w0.102: v2(183.26,88.21) 183.16,88.31 183.16,88.57 183.29,88.7 183.83,88.7 183.92,88.61 184.69,88.61 185.03,88.61 185.27,88.36 185.4,88.36
  IN1 w0.147: v2(203.46,86.28) 203.72,86.28 203.86,86.42 203.86,87.67 203.17,88.36 185.4,88.36
  BOTTOM w0.102: v2(183.26,88.21) 182.85,87.8 182.52,87.8 182.24,88.08 181.66,88.08 181.66,88.08 UV1.B15 ; UV8.J3 v2(203.46,86.28)
FBC_CLK0: length 36.4
  TOP w0.102: v2(204.26,78.27) 204.43,78.1 204.43,77.04 204.11,76.72 RV178.2
  IN1 w0.13: v2(204.26,78.27) 204.26,78.57 204.11,78.71 203.93,78.71 203.82,78.6 203.82,77.92 203.95,77.79 204.18,77.79 204.25,77.72 204.25,77.53 203.7,76.98 193.49,76.98 192.4,78.07 187.68,78.07 186.36,79.4 183.51,79.4 182.25,80.65 182.25,82.72 180.07,84.91 178.89,84.91 178.78,85.01 178.78,85.32 179.06,85.6 v2(179.31,85.6)
  BOTTOM w0.102: UV8.J12 203.86,78.67 v2(204.26,78.27)
  BOTTOM w0.114: UV1.D12 179.69,85.22 v2(179.31,85.6)
FBC_CLK0#: length 37.2
  TOP w0.102: v2(204.26,79.09) 204.26,79.08 204.66,78.68 204.66,77 RV178.1
  IN1 w0.13: v2(204.26,79.09) 204.66,78.69 204.66,77.61 203.8,76.75 193.4,76.75 192.3,77.84 187.58,77.84 186.26,79.16 183.42,79.16 182.02,80.56 182.02,82.62 179.97,84.67 178.79,84.67 178.49,84.97 v2(178.49,85.59)
  BOTTOM w0.102: v2(204.26,79.09) 203.87,79.48 UV8.J11
  BOTTOM w0.114: UV1.E12 178.88,85.21 v2(178.49,85.59)
FBC_CLK1: length 40.4
  TOP w0.102: v2(203.46,105.39) 203.46,105.48 204.35,106.37 204.45,106.37 v4(204.64,106.56) 204.87,106.79 204.87,107.35 RV138.2
  IN1 w0.13: v2(179.27,91.5) 179.44,91.67 179.44,91.81 179.34,91.91 178.78,91.91 178.65,92.04 178.65,93.24 180.75,95.35 180.75,96.24 191.42,106.9 203.34,106.9 203.87,106.37 203.87,105.93 203.74,105.8 203.16,105.8 203.05,105.7 203.05,105.45 203.18,105.32 203.39,105.32 v2(203.46,105.39)
  BOTTOM w0.102: UV9.J12 v2(203.46,105.39)
  BOTTOM w0.114: v2(179.27,91.5) 178.89,91.88 UV1.E20
FBC_CLK1#: length 41.3
  TOP w0.102: v2(203.46,104.59) 203.85,104.98 203.85,105.58 204.43,106.16 204.56,106.16 204.58,106.19 204.59,106.19 205.01,106.61 205.01,106.62 205.07,106.68 205.07,107.31 RV138.1
  IN1 w0.13: v2(178.41,91.48) 178.41,93.34 180.52,95.44 180.52,96.33 191.32,107.13 203.44,107.13 204.11,106.46 204.11,105.84 203.85,105.59 203.85,104.99 v2(203.46,104.59)
  BOTTOM w0.102: UV9.J11 v2(203.46,104.59)
  BOTTOM w0.114: v2(178.41,91.48) 178.04,91.86 UV1.F20
FBC_CS#_H: length 32.5
  IN1 w0.102: 181.51,94 181.51,93.87 180.95,93.3 180.95,91.43 180.17,90.66 v2(180.09,90.66)
  IN1 w0.147: v2(202.66,104.59) 202.66,104.35 203.03,103.98 203.03,103.97 203.04,103.96 203.04,103.53 202.92,103.4 202.02,103.4 202.02,103.4 197.7,103.4 197.7,103.4 189.83,103.4 182.57,96.14 182.57,95.25 181.51,94.19 181.51,94
  BOTTOM w0.102: v2(180.09,90.66) 179.69,90.26 UV1.D18 ; UV9.L12 v2(202.66,104.59)
FBC_CS#_L: length 26.6
  IN1 w0.147: v2(180.91,85.65) 180.91,85.34 183.85,82.4 185.85,82.4 188.28,79.97 195.57,79.97 195.97,80.38 201.28,80.38 201.46,80.2 201.46,79.49 201.46,79.48 201.89,79.05 v2(201.89,79.09)
  BOTTOM w0.102: v2(180.91,85.65) 180.1,85.65 UV1.D13
  BOTTOM w0.107: UV8.G12 201.89,79.05 v2(201.89,79.09)
FBC_D0: length 27.6
  IN3 w0.102: 181.16,82.71 180.19,82.71 180.03,82.55 177.38,82.55 v2(176.8,83.13)
  IN3 w0.145: v2(197.86,85.48) 197.81,85.43 195.53,85.43 194.84,84.74 189.57,84.74 188.9,85.41 188.67,85.41 188.43,85.16 188.43,84.93 189.1,84.26 189.1,83.87 187.94,82.71 186.81,82.71 186.51,83.01 186.51,83.6 186.35,83.76 186,83.76 185.84,83.6 185.84,82.88 185.68,82.71 181.16,82.71
  BOTTOM w0.102: UV1.G9 177.19,82.73 176.8,83.12 v2(176.8,83.13) ; UV8.A4 v2(197.86,85.48)
FBC_D1: length 27
  IN3 w0.102: 180.44,83.66 180.34,83.56 179.68,83.56 v2(179.27,83.15)
  IN3 w0.145: v2(197.86,87.08) 197.79,87.01 196.99,87.01 196.59,86.62 196.59,86.52 196.43,86.36 196.09,86.36 195.92,86.52 195.92,86.63 195.8,86.76 194.75,86.76 194.62,86.63 194.62,86.3 194.5,86.17 194.04,86.17 193.91,86.3 193.91,86.68 193.78,86.81 193.37,86.81 193.24,86.68 193.24,85.82 193.11,85.69 192.55,85.69 192.42,85.82 192.42,86.63 192.28,86.78 191.85,86.78 191.7,86.63 191.7,85.84 191.57,85.72 191.1,85.72 190.98,85.84 190.98,86.63 190.83,86.78 190.4,86.78 190.25,86.63 190.25,86.5 190.11,86.36 189.67,86.36 189.53,86.5 189.53,86.63 189.38,86.78 188.95,86.78 188.81,86.63 188.81,86.5 188.66,86.36 187.27,86.36 184.57,83.66 180.44,83.66
  BOTTOM w0.102: UV1.E9 178.89,82.77 v2(179.27,83.15) ; UV8.A2 v2(197.86,87.08)
FBC_D2: length 26.7
  IN3 w0.102: 180.74,82.35 178.53,82.35 v2(177.63,81.45)
  IN3 w0.145: 180.74,82.35 180.84,82.25 189.79,82.25 189.93,82.39 189.93,82.93 190.08,83.07 190.51,83.07 190.65,82.93 190.65,82.39 190.8,82.25 191.23,82.25 191.38,82.39 191.38,82.93 191.52,83.07 191.96,83.07 192.1,82.93 192.1,82.39 192.25,82.25 192.68,82.25 192.83,82.39 192.83,82.93 192.97,83.07 193.4,83.07 193.55,82.93 193.55,82.52 193.83,82.25 194.53,82.25 195.32,83.04 196.21,83.04 v2(197.86,84.68)
  BOTTOM w0.102: UV8.B4 v2(197.86,84.68) ; v2(177.63,81.45) 177.19,81.88 UV1.G8
FBC_D3: length 28
  IN3 w0.102: v2(177.72,83.18) 178.15,82.75 179.68,82.75 180.11,83.18
  IN3 w0.145: 180.11,83.18 184.75,83.18 186.12,84.55 186.51,84.55 187.52,83.54 187.7,83.54 187.99,83.83 187.99,84.01 187.16,84.84 187.16,85.44 187.61,85.89 189.11,85.89 189.79,85.21 194.37,85.21 195.05,85.89 198.1,85.89 198.26,86.05 198.26,86.68 v2(198.66,87.08)
  BOTTOM w0.102: v2(177.72,83.18) 178.04,82.86 UV1.F9 ; UV8.B2 v2(198.66,87.08)
FBC_D4: length 29
  IN3 w0.102: 181.87,86.17 181.76,86.07 181.76,85.33 181.33,84.9 179.38,84.9 v2(178.46,83.98)
  IN3 w0.145: 181.87,86.17 182.27,86.58 183.14,86.58 183.64,86.07 184.52,86.07 187.71,89.27 199,89.27 199.86,88.4 199.86,85.88 v2(200.26,85.48)
  BOTTOM w0.102: UV1.F11 v2(178.46,83.98) ; UV8.E4 v2(200.26,85.48)
FBC_D5: length 30
  IN3 w0.102: v2(177.61,83.98) 177.83,83.98 179.03,85.18 181,85.18 181.36,85.54 181.36,86.32
  IN3 w0.145: v2(200.26,86.28) 200.67,86.69 200.67,88.61 199.55,89.73 187.48,89.73 184.97,87.22 182.25,87.22 181.36,86.32
  BOTTOM w0.102: UV8.E2 v2(200.26,86.28) ; UV1.G11 v2(177.61,83.98)
FBC_D6: length 32.8
  IN3 w0.102: 179.03,86.95 178.37,86.95 178.08,86.65 178.08,85.99 177.62,85.53 v2(177.62,84.85)
  IN3 w0.145: 179.03,86.95 181.43,89.35 183.45,89.35 183.86,89.75 185.73,89.75 186.64,90.67 199.94,90.67 201.69,88.92 201.69,87.59 201.47,87.37 201.47,85.87 v2(201.86,85.48)
  BOTTOM w0.102: v2(177.62,84.85) 177.97,85.21 UV1.F12 ; UV8.F4 v2(201.86,85.48)
FBC_D7: length 30.9
  IN3 w0.102: v2(176.8,84.79) 177.14,84.44 177.92,84.44 178.92,85.44 178.92,85.82 179.17,86.07 180.35,86.07
  IN3 w0.145: 180.35,86.07 180.6,86.32 180.6,86.81 182.56,88.78 185.87,88.78 187.29,90.2 199.74,90.2 201.22,88.72 201.22,87.65 201.06,87.49 v2(201.06,87.08)
  BOTTOM w0.102: UV1.G12 177.19,85.18 v2(176.8,84.79) ; UV8.F2 v2(201.06,87.08)
FBC_D8: length 21.6
  IN3 w0.102: v2(177.61,80.58) 178,80.2 180.39,80.2
  IN3 w0.145: 180.39,80.2 180.47,80.28 182.07,80.28 182.64,79.71 191.28,79.71 191.54,79.97 196.16,79.97 v2(197.06,79.08)
  BOTTOM w0.102: UV1.G6 177.19,80.16 v2(177.61,80.58)
  BOTTOM w0.107: UV8.A11 v2(197.06,79.08)
FBC_D9: length 20.9
  IN3 w0.102: v2(178.39,78.91) 178.85,79.37 179.43,79.37
  IN3 w0.145: 179.43,79.37 180.02,78.78 192.72,78.78 192.97,78.53 194.68,78.53 195.64,77.56 v2(195.64,77.54)
  BOTTOM w0.102: UV1.F5 v2(178.39,78.91) ; v2(195.64,77.54) 195.64,77.56 v1(196.05,77.97) 196.71,77.97 196.84,77.84 197.42,77.84 UV8.A13
FBC_D10: length 22.9
  IN3 w0.102: 197.88,79.1 v2(197.88,79.11) ; 180.34,81.03 179.71,81.03 v2(179.29,80.61)
  IN3 w0.145: 197.88,79.1 198.27,79.49 198.27,80.75 198.08,80.94 191.85,80.94 191.09,80.18 182.83,80.18 181.98,81.03 180.34,81.03
  BOTTOM w0.102: UV8.B11 197.88,79.1 v2(197.88,79.11) ; UV1.E6 v2(179.29,80.61)
FBC_D11: length 21.5
  IN3 w0.102: 180.72,79.8 178.46,79.8 v2(178.41,79.75) ; v2(197.83,78.27) 197.83,78.31
  IN3 w0.145: 180.72,79.8 181.84,79.8 182.4,79.24 191.47,79.24 191.74,79.51 195.91,79.51 196.74,78.68 197.46,78.68 197.83,78.31
  BOTTOM w0.102: v2(197.83,78.27) 197.87,78.27 UV8.B13 ; UV1.F6 178.04,80.12 v2(178.41,79.75)
FBC_D12: length 26.7
  IN3 w0.102: v2(178.39,78.1) 178.41,78.12 178.61,78.12 179.13,77.61 179.27,77.61 179.27,77.61
  IN3 w0.145: 179.27,77.61 182.03,77.61 182.32,77.32 183.46,77.32 183.54,77.4 183.86,77.4 184.33,76.93 192.64,76.93 193.33,76.24 198.94,76.24 199.86,77.16 199.86,79.48 v2(200.26,79.88)
  BOTTOM w0.102: UV8.E11 v2(200.26,79.88) ; UV1.F4 v2(178.39,78.1)
FBC_D13: length 26.8
  IN3 w0.102: 179.33,77.13 179.15,77.13 178.56,77.71 178.03,77.71 177.56,78.18 v2(177.56,78.92)
  IN3 w0.145: v2(200.26,77.48) 200.26,76.79 199.24,75.77 193.16,75.77 192.47,76.46 183.12,76.46 182.71,76.87 182.08,76.87 181.82,77.13 179.33,77.13
  BOTTOM w0.102: v2(177.56,78.92) 177.56,78.97 177.14,78.55 UV1.G4 ; UV8.E13 v2(200.26,77.48)
FBC_D14: length 28.4
  IN3 w0.145: v2(201.04,79.1) 201.46,78.68 201.46,76.44 199.86,74.84 192.67,74.84 191.98,75.52 181.26,75.52 180.63,76.15 178.72,76.15 v2(178.38,76.5)
  BOTTOM w0.102: v2(201.04,79.1) 201.42,79.48 UV8.F11
  BOTTOM w0.127: v2(178.38,76.5) 178.79,76.91 UV1.E2
FBC_D15: length 26.8
  IN3 w0.145: v2(178.39,77.31) 179.08,76.62 180.82,76.62 181.45,75.99 192.18,75.99 192.86,75.31 199.66,75.31 200.66,76.31 200.66,77.88 v2(201.03,78.25)
  BOTTOM w0.102: UV1.F3 v2(178.39,77.31)
  BOTTOM w0.13: v2(201.03,78.25) 201.4,77.88 UV8.F13
FBC_D16: length 37.9
  BOTTOM w0.102: 181.17,75.09 180.63,75.09 179.85,75.87 179.85,76.27 180.49,76.91 UV1.C2
  BOTTOM w0.13: 181.17,75.09 182.46,73.81 v1(198.79,73.81) 208.4,73.81 211.21,76.62 211.21,78.53 UV8.U11
FBC_D17: length 37.4
  BOTTOM w0.102: 181.58,75.47 180.54,75.47 180.05,75.95 180.05,76.19 180.35,76.48 180.78,76.48 180.88,76.58 180.88,77.17 180.74,77.31 180.28,77.31 180.05,77.55 180.05,78.15 UV1.D4
  BOTTOM w0.13: 181.58,75.47 182.71,74.34 v1(194.85,74.34) 208.2,74.34 210.63,76.76 210.63,77.51 UV8.U13
FBC_D18: length 41.9
  BOTTOM w0.102: UV1.D3 179.64,77.53 180.04,77.14 180.04,76.8 179.59,76.36 179.59,75.77 180.7,74.67
  BOTTOM w0.13: UV8.T11 209.88,79.9 210.55,79.9 211.69,78.76 211.69,76.34 208.7,73.35 v1(206.72,73.35) 182.02,73.35 180.7,74.67
FBC_D19: length 31.6
  BOTTOM w0.102: 182.49,75.78 181.54,75.78 181.47,75.72 180.88,75.72 UV1.C1
  BOTTOM w0.13: UV8.T13 209.1,77.52 209.1,76.8 209.16,76.75 209.16,76.19 207.83,74.86 191.95,74.86 v1(191.65,75.17) 191.26,75.56 182.72,75.56 182.49,75.78
FBC_D20: length 30.4
  BOTTOM w0.102: 182.29,78.08 181.81,78.08 181.44,77.71 UV1.B3 ; 182.56,77.81 182.57,77.81 182.79,77.59 183.69,77.59 183.72,77.56
  BOTTOM w0.107: 182.29,78.08 182.56,77.81
  BOTTOM w0.13: UV8.N11 207.4,79.14 207.4,76.4 207.15,76.14 193.09,76.14 v1(192.4,76.83) 184.45,76.83 183.72,77.56
FBC_D21: length 28.1
  BOTTOM w0.102: 184.99,77.84 184.91,77.92 182.79,77.92 182.42,78.29 181.58,78.29 181.44,78.15 180.9,78.15 UV1.C4
  BOTTOM w0.13: UV8.N13 206.62,77.43 205.98,77.43 205.85,77.31 205.85,76.95 205.62,76.71 193.97,76.71 192.84,77.84 v1(190.64,77.84) 184.99,77.84
FBC_D22: length 28.8
  BOTTOM w0.102: UV1.B5 181.66,79.04 182.26,79.04 182.38,79.16 182.94,79.16 182.94,79.16 183.6,79.16
  BOTTOM w0.13: 183.6,79.16 185.07,79.16 185.12,79.12 186.38,79.12 186.43,79.16 191.01,79.16 v1(191.84,79.99) 195.56,79.99 197.39,81.83 205.87,81.83 206.71,81 206.71,80.68 206.67,80.63 206.67,80.19 206.26,79.78 UV8.M11
FBC_D23: length 29.9
  BOTTOM w0.102: 183.47,78.53 183.18,78.82 181.57,78.82 181.4,78.99 180.91,78.99 UV1.C5
  BOTTOM w0.13: UV8.M13 205.85,78.29 205.85,80.56 205.22,81.19 197.65,81.19 194.99,78.53 v1(187.11,78.53) 183.47,78.53
FBC_D24: length 38.9
  BOTTOM w0.102: 185.06,85.78 185.06,85.78 184.88,85.78 184.7,85.6 184.63,85.6 183.32,84.29 182.21,84.29 UV1.A11
  BOTTOM w0.13: 185.06,85.78 187.78,85.78 v1(189.85,87.85) 191.99,89.98 193.16,89.98 195.31,92.14 208.34,92.14 211.72,88.76 211.72,86.07 210.98,85.33 210.51,85.33 UV8.U4
FBC_D25: length 36.4
  BOTTOM w0.102: 184.86,84.5 184.18,83.82 181.53,83.82 ; UV1.C11 180.94,83.96
  BOTTOM w0.107: 180.94,83.96 181.39,83.96 181.53,83.82
  BOTTOM w0.13: UV8.U2 210.68,87.1 210.68,88.12 207.58,91.22 195.91,91.22 193.17,88.48 v1(192.29,88.48) 188.31,84.5 184.86,84.5
FBC_D26: length 44.4
  BOTTOM w0.102: 184.7,86.13 183.14,84.57 182.45,84.57 182.22,84.8 180.08,84.8 UV1.D11
  BOTTOM w0.13: UV8.T4 209.86,84.68 211.17,84.68 212.23,85.74 212.23,89.19 208.82,92.6 194.8,92.6 192.8,90.59 v1(191.7,90.59) 187.56,86.45 185.02,86.45 184.7,86.13
FBC_D27: length 38.3
  BOTTOM w0.102: 185.24,85.14 184.6,85.14 183.51,84.05 181.65,84.05 UV1.B11
  BOTTOM w0.13: UV8.T2 209.86,86.28 210.66,86.28 211.19,86.81 211.19,88.52 208.03,91.68 195.61,91.68 193.31,89.38 192.29,89.38 188.05,85.14 v1(187.54,85.14) 185.24,85.14
FBC_D28: length 34.8
  BOTTOM w0.102: UV1.D8 179.97,81.91 180.36,82.3 182.19,82.3 182.58,82.7 184.94,82.7 185.04,82.59
  BOTTOM w0.13: UV8.N4 207.46,85.48 207.46,87.92 207.53,87.99 207.53,88.34 206.6,89.27 196.87,89.27 193.17,85.57 v1(192.29,85.57) 189.31,82.59 185.04,82.59
FBC_D29: length 29.5
  BOTTOM w0.102: 184.87,82.09 184.71,82.25 182.43,82.25 UV1.A8
  BOTTOM w0.127: 192.97,84.67 192.29,84.67 v1(190.37,82.75) 189.57,81.95 185.01,81.95 184.87,82.09
  BOTTOM w0.13: UV8.N2 206.61,87.13 206.61,87.63 206.58,87.66 206.58,88.21 206.05,88.74 197.24,88.74 193.17,84.67 192.97,84.67
FBC_D30: length 29.6
  BOTTOM w0.102: UV1.C8 180.91,81.49 181.45,81.49 181.65,81.3 182.36,81.3 182.55,81.49 183.18,81.49 183.52,81.15 184.32,81.15 184.79,80.68 184.93,80.68
  BOTTOM w0.13: 184.93,80.68 189.96,80.68 192.12,82.84 v1(194.5,82.84) 194.98,83.33 206.34,83.33 206.64,83.63 206.64,84.7 UV8.M4
FBC_D31: length 29.3
  BOTTOM w0.102: UV1.B8 181.48,81.91 181.85,81.54 182.26,81.54 182.51,81.78 183.53,81.78 183.69,81.63 184.61,81.63 184.84,81.4
  BOTTOM w0.13: UV8.M2 205.91,87.03 205.31,87.03 205.04,87.3 205.04,87.8 204.53,88.31 197.6,88.31 193.17,83.88 192.29,83.88 189.73,81.32 v1(187.61,81.32) 184.92,81.32 184.84,81.4
FBC_D32: length 24.9
  IN3 w0.102: 185.14,96.15 185.01,96.15 184.44,95.58 183.25,95.58 182.71,95.04 177.8,95.04 v2(177.61,94.86)
  IN3 w0.145: 185.14,96.15 188.13,99.15 189.47,99.15 189.63,99.31 189.63,99.51 189.79,99.67 190.14,99.67 190.3,99.51 190.3,99.31 190.46,99.15 190.81,99.15 190.97,99.31 190.97,99.51 191.13,99.67 191.48,99.67 191.64,99.51 191.64,99.31 191.8,99.15 196.75,99.15 197.71,98.19 v2(197.85,98.19)
  BOTTOM w0.102: v2(197.85,98.19) 197.85,98.2 UV9.U4 ; v2(177.61,94.86) 177.96,95.21 UV1.F24
FBC_D33: length 25.7
  IN3 w0.102: 185.79,95.02 185.63,94.86 185.47,94.86 185.29,95.04 183.9,95.04 183.48,94.62 178.42,94.62 177.79,93.98 v2(177.61,93.98)
  IN3 w0.145: 185.79,95.02 185.95,95.19 186.62,95.19 188.75,97.32 189.29,97.32 189.51,97.09 189.51,96.9 189.8,96.61 190.22,96.61 190.41,96.8 190.41,98.04 190.57,98.2 190.92,98.2 191.08,98.04 191.08,97.48 191.24,97.32 191.59,97.32 191.75,97.48 191.75,98.04 191.91,98.2 195.4,98.2 196.28,97.32 196.98,97.32 v2(197.06,97.39)
  BOTTOM w0.102: UV9.U2 v2(197.06,97.39) ; UV1.G23 v2(177.61,93.98)
FBC_D34: length 24.6
  IN3 w0.102: 184.31,95.99 182.88,95.99 182.14,95.25 178.93,95.25 v2(178.47,95.7)
  IN3 w0.145: v2(197.86,98.99) 196.71,100.14 195.32,100.14 195.16,99.98 195.16,99.78 195,99.62 194.52,99.62 194.35,99.78 194.35,99.98 194.19,100.14 193.85,100.14 193.68,99.98 193.68,99.78 193.52,99.62 193.17,99.62 193.01,99.78 193.01,99.98 192.85,100.14 188.46,100.14 184.31,95.99
  BOTTOM w0.102: v2(178.47,95.7) 178.89,95.28 UV1.E24 ; UV9.T4 v2(197.86,98.99)
FBC_D35: length 25.3
  IN3 w0.102: 185.49,95.39 185.36,95.27 183.57,95.27 183.14,94.84 178.23,94.84 177.87,94.48 177.46,94.48 176.79,95.14 v2(176.79,95.63)
  IN3 w0.145: 185.49,95.39 185.67,95.58 186.32,95.58 189.41,98.67 195.59,98.67 196.48,97.78 197.47,97.78 v2(197.86,97.39)
  BOTTOM w0.102: UV1.G24 177.19,95.23 v2(176.79,95.63) ; UV9.T2 v2(197.86,97.39)
FBC_D36: length 24.9
  IN3 w0.102: v2(180.09,93.13) 180.11,93.16 183,93.16 ; v2(201.06,98.19) 200.84,98.19
  IN3 w0.145: 200.84,98.19 200.44,97.79 200.08,97.79 199.85,97.56 199.85,96.35 197.07,93.56 186.3,93.56 186.06,93.33 183.17,93.33 183,93.16
  BOTTOM w0.102: v2(180.09,93.13) 179.69,92.73 UV1.D21 ; UV9.N4 v2(201.06,98.19)
FBC_D37: length 26.4
  IN3 w0.102: 182.11,92.43 181.85,92.69 180.97,92.69 180.72,92.45 179.42,92.45 v2(179.29,92.32)
  IN3 w0.145: 182.11,92.43 183.99,92.43 183.99,92.43 185.48,92.43 185.48,92.43 186.72,92.43 186.87,92.57 197.75,92.57 201.45,96.28 201.45,97 v2(201.06,97.39)
  BOTTOM w0.102: v2(179.29,92.32) 179.28,92.32 178.89,92.71 UV1.E21 ; UV9.N2 v2(201.06,97.39)
FBC_D38: length 29.5
  IN3 w0.102: v2(176.79,93.13) 177.02,92.9 178.42,92.9 178.63,92.7 180.53,92.7 180.75,92.92 182.15,92.92 182.22,92.85 183.21,92.85
  IN3 w0.145: v2(201.86,98.19) 201.45,97.79 200.89,97.79 200.66,97.55 200.66,96.27 197.44,93.06 186.45,93.06 186.28,92.88 185.3,92.88 185.29,92.88 184.18,92.88 184.17,92.88 183.24,92.88 183.21,92.85
  BOTTOM w0.102: UV9.M4 v2(201.86,98.19) ; UV1.G21 176.79,93.11 v2(176.79,93.13)
FBC_D39: length 27.9
  IN3 w0.102: v2(177.63,92.33) 178.03,91.93 182.03,91.93
  IN3 w0.145: v2(201.86,96.6) 201.94,96.51 201.94,96.1 197.96,92.12 187.07,92.12 186.94,91.98 186.91,91.98 185.67,91.98 185.67,91.98 183.8,91.98 183.8,91.98 183.2,91.98 183.2,91.98 182.08,91.98 182.03,91.93
  BOTTOM w0.102: UV1.F21 177.99,92.71 177.63,92.34 v2(177.63,92.33) ; v2(201.86,96.6) 201.86,96.59 UV9.M2
FBC_D40: length 30.8
  IN3 w0.102: 180.74,97.31 177.62,97.31 v2(177.61,97.31)
  IN3 w0.145: 180.74,97.31 181.17,97.74 183.68,97.74 187.75,101.8 192.97,101.8 193.18,102.01 193.18,102.79 193.32,102.94 193.69,102.94 193.84,102.79 193.84,101.92 193.95,101.8 194.31,101.8 194.47,101.97 194.47,102.87 194.63,103.03 195.03,103.03 195.19,102.87 195.19,101.97 195.36,101.8 195.7,101.8 195.86,101.97 195.86,102.87 196.03,103.03 196.37,103.03 196.54,102.87 196.54,101.97 196.7,101.8 196.95,101.8 197.32,102.17 197.32,103.25 v2(197.86,103.79)
  BOTTOM w0.102: UV1.G27 177.21,97.71 v2(177.61,97.31) ; UV9.U11 v2(197.86,103.79)
FBC_D41: length 29.2
  IN3 w0.102: v2(180.09,98.17) 180.4,98.17 180.85,98.62 183.14,98.62
  IN3 w0.145: v2(197.86,105.39) 197.86,105.12 197.73,104.99 197.03,104.99 196.82,105.2 196.56,105.2 196.2,104.84 196.2,104.14 196.03,103.98 195.69,103.98 195.53,104.14 195.53,104.69 195.4,104.82 195.01,104.82 194.88,104.69 194.88,104.14 194.72,103.98 194.44,103.98 194.28,104.14 194.28,104.69 194.15,104.82 193.73,104.82 193.61,104.69 193.61,104.14 193.44,103.98 193.1,103.98 192.94,104.14 192.94,104.69 192.81,104.82 192.39,104.82 192.27,104.69 192.27,104.14 192.1,103.98 191.76,103.98 191.59,104.14 191.59,104.66 191.47,104.79 191.05,104.79 190.92,104.66 190.92,104.14 190.76,103.98 190.42,103.98 190.25,104.14 190.25,104.66 190.13,104.79 189.46,104.79 189.33,104.66 189.33,104.27 189.11,104.05 188.67,104.05 183.24,98.62 183.14,98.62
  BOTTOM w0.102: v2(180.09,98.17) 179.69,97.77 UV1.D27 ; UV9.U13 v2(197.86,105.39)
