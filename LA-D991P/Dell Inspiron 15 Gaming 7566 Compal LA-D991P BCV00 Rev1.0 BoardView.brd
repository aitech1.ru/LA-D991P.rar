# Allegro board Dell Inspiron 15 Gaming 7566 Compal LA-D991P BCV00 Rev1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SUSCLK_R: length 7.3
  BOTTOM w0.102: JNGFF1.42 196.56,30.4 196.86,30.7 196.86,31.41 196.17,32.1 195.49,32.1 194.62,32.96 v1(194.62,33.85) 194.62,34.57 RN1.1
SW_+1.35VS_VGAP: length 8.1
  TOP w0.508: 142.17,117.15 142.87,117.85 142.87,122.85 PR904.1
  vias: v2(141.5,116.75) v2(141.48,116.15) v2(145.93,126.48) v2(145.93,125.47) v2(145.93,124.07) v2(145.93,122.8) v2(146.62,126.49) v2(146.58,125.46) v2(146.62,124.07) v2(146.59,122.76) v3(145.12,126.51)
SWF_BSNL: length 48.6
  TOP w0.102: 306.35,6.12 v3(306.35,7.17)
  IN2 w1.27: 306.21,2.89 306.08,2.76 299.48,2.76 291.45,10.79 291.07,10.79 287.26,14.6 284.46,14.6 280.48,10.61 265.29,10.61
  vias: v2(260.49,11.37) v2(261.74,11.36) v2(262.09,11.85) v2(306,4.77) v2(306.31,4.23) v2(306.59,4.77)
SWF_BSNR: length 53.1
  TOP w0.102: JSPK1.5 v3(304.41,7.53)
  IN2 w1.27: 304.78,5.58 304.17,6.19 298.21,6.19 292.01,12.39 291.73,12.39 288,16.12 283.73,16.12 279.79,12.18 264.42,12.18 263.59,13.02 260.59,13.02 259.98,12.41
  vias: v2(257.21,11.39) v2(257.97,11.47) v2(258.73,11.62) v2(304.55,4.76) v2(304.56,4.16) v2(305.11,4.41)
SYS_PEX_RST_MON#: length 51.4
  TOP w0.102: UV18.1 152.95,74.05 v2(152.79,73.88)
  IN1 w0.114: v2(152.79,73.88) 150.66,73.88 149.13,75.41 149.13,76.95 v2(149.49,77.31) ; v2(154.11,81.04) 154.13,81.04 154.89,80.28 156.25,80.28 157.14,79.38 159.36,79.38 160.31,78.43 170.35,78.43 171.26,79.35 172.75,79.35 172.98,79.12 172.98,78.61 173.14,78.45 173.14,77.46 173.3,77.3 v2(173.38,77.3)
  BOTTOM w0.102: v2(154.11,81.04) 154.09,81.07 151.64,81.07 150.93,81.78 149.36,81.78 148.85,81.27 148.42,81.27 147.91,80.76 146.08,80.76 144.02,78.7 143.32,78.7 RV187.1 143.22,77.87 143.47,77.61 144.21,77.61 ; v2(149.49,77.31) 149.46,77.28 RV532.1 RV208.1 148.37,78.15 148.27,78.04 146.68,78.04 v1(146.42,78.31) 144.9,78.31 144.21,77.61 ; 144.21,77.61 UV14.4 ; UV1.L3 173.79,77.71 v2(173.38,77.3)
SYS_PWROK: length 77.2
  TOP w0.102: UE1.89 236.84,27.34 236.89,27.4 237.8,27.4 238.14,27.06 238.71,27.06 238.95,26.82 239.96,25.81 239.96,25.29 240.43,24.83 241.11,24.83 v2(241.88,24.06)
  IN1 w0.114: v2(241.88,24.06) 241.5,23.68 240.42,23.68 239.09,22.34 236.73,22.34 236.65,22.27 233.47,22.27 232.38,21.17 220.88,21.17 219,23.05 216.77,23.05 216.59,22.87 216.25,22.87 216.06,23.05 214.43,23.05 213.96,22.59 207.33,22.59 207.13,22.39 199.53,22.39 198.83,21.68 196.16,21.68 195.91,21.44 193.54,21.44 193.3,21.2 187.16,21.2 186.03,20.08 181.73,20.08 181.19,20.61 v2(181.19,20.82)
  BOTTOM w0.089: v2(181.19,20.82) 181.19,22.9 179.75,24.34 UH2.AY1
SYS_RESET#: length 19
  TOP w0.102: JAPS.13 179.18,11.96 179.61,12.39 179.61,16.58 v1(180.3,17.26) 181.32,17.26 182.53,18.48 182.53,19.6 182,20.13 v2(182,20.97)
  BOTTOM w0.102: RH193.1 182,20.11 v2(182,20.97) 182.05,21.02 182.05,23.69 181.01,24.73 178.99,24.73 UH2.AW1
TB_STAT#_CHG: length 1.8
  BOTTOM w0.203: PR320.1 32.49,38.14 PU300.16
TESTMODE: length 8.8
  BOTTOM w0.102: UV1.AK11 157.47,83.99 157.47,82.55 157.24,82.31 156.96,82.31 156.7,82.06 156.7,81.68 156.5,81.47 154.52,81.47 154.32,81.67 154.32,82.2 153.98,82.54 v1(153.22,82.54) 153.02,82.34 RV62.1
THERMAL_ALERT#: length 5.8
  BOTTOM w0.102: v1(172.9,72.47) 172.9,72.66 171.88,73.67 RV526.1 171.88,74.3 172.3,74.72 172.63,74.72 173.38,75.47 173.38,76.52 UV1.M2
THERMATRIP_GPU#: length 30.3
  TOP w0.102: v2(151.95,72.91) 151.95,72.95 153.48,71.41 v1(154.19,71.41) 157.64,71.41 159,72.77 164.32,72.77 166.11,74.56 170.6,74.56 v2(170.71,74.67)
  BOTTOM w0.102: UV1.M1 172.99,75.43 172.58,75.02 171.49,75.02 171.13,74.67 v2(170.71,74.67) ; v2(151.95,72.91) 151.61,73.24 151.61,75.28 RV34.1 151.21,78.73 QV88.3
THM_SML1_CLK: length 5.5
  BOTTOM w0.102: RT7.1 53.81,48.83 54,48.65 QT2.4 54.83,48.65 54.89,48.71 RT4.2 55.38,49.15 v1(55.99,49.76) UT1.10
THM_SML1_DATA: length 11.9
  BOTTOM w0.102: UT1.9 56.62,49.26 56.14,48.78 56.14,46.8 v1(55.38,46.04) 54.52,45.17 53.25,45.17 52.89,45.53 RT6.1 51.7,45.96 51.32,46.35 RT5.2 51.38,47.35 QT2.1
TMDS_T_TX0N: length 63.8
  TOP w0.076: JHDMI1.9 301.86,74.49 301.71,74.64 301.54,74.64 301.35,74.45 301.35,69.37 300.96,68.98 300.96,68.9 300.96,68.89
  TOP w0.089: 300.96,68.89 300.83,68.77 299.89,68.77 298.28,70.38 295.37,70.38 294.02,69.03 293.38,69.03 292.83,68.48 292.83,67.83 292.94,67.72 DV5.8 DV5.2 292.94,66.1 292.83,65.99 292.83,65.76 292.65,65.58 292.65,65.32 RV557.1 292.63,64.7 292.63,64.34 292.74,64.24 LV25.1 292.74,63.31 292.63,63.2 292.63,62.83 292.74,62.72 LV25.2 292.74,61.98 292.63,61.87 292.63,61.67 292.04,61.07 289.15,61.07 v4(279.14,51.06) 276.81,48.73 276.15,48.73 274.18,46.76 274.18,39.57 272.22,37.61 272.22,37.26 268.86,33.9 268.55,33.9 UM1.H3
TMDS_T_TX0P: length 63.9
  TOP w0.076: JHDMI1.7 301.83,75.17 301.18,74.52 301.18,69.44 300.85,69.1 300.76,69.1 300.76,69.09
  TOP w0.089: UM1.H4 268.49,34.27 268.58,34.18 268.74,34.18 271.94,37.38 271.94,37.73 273.9,39.69 v4(273.9,45.23) 273.9,46.88 276.03,49.01 276.69,49.01 289.03,61.36 291.92,61.36 292.35,61.78 292.35,61.87 292.24,61.98 LV25.3 292.24,62.73 292.35,62.84 292.35,63.2 292.24,63.31 LV25.4 292.24,64.24 292.35,64.34 292.35,64.7 RV557.2 292.36,65.34 292.36,65.69 292.55,65.88 292.55,66 292.44,66.11 DV5.1 DV5.9 292.44,67.72 292.55,67.83 292.55,68.6 293.26,69.31 293.9,69.31 295.25,70.66 298.39,70.66 300.01,69.05 300.71,69.05 300.76,69.09
TMDS_T_TX1N: length 63.5
  TOP w0.089: UM1.H5 269.45,35.44 271.49,37.48 271.49,37.86 273.49,39.87 273.49,47.04 275.87,49.42 276.49,49.42 v4(283.13,56.06) 290.99,63.92 290.99,67.82 293.98,70.8 294.65,70.8 295.06,71.21 296.01,71.21 296.57,71.77 296.57,72.9 296.68,73.01 LV26.2 296.68,73.81 296.57,73.92 296.57,74.17 296.68,74.28 LV26.1 296.68,75.04 296.57,75.15 296.57,75.62 RV562.1 296.58,76.24 296.58,76.66 296.43,76.81 296.43,76.95 296.54,77.06 DV4.9 296.54,77.48 296.43,77.59 296.43,77.84 296.54,77.95 DV4.1 296.54,78.49 296.38,78.65 296.38,78.83 296.54,78.98 296.93,78.98 300.09,75.82 300.09,75.68 300.26,75.52 300.51,75.52 JHDMI1.6
TMDS_T_TX1P: length 63.5
  TOP w0.089: UM1.H6 268.62,36.11 268.62,35.86 268.75,35.72 269.33,35.72 271.2,37.6 271.2,37.98 273.21,39.99 273.21,47.16 275.75,49.7 276.37,49.7 v4(276.86,50.19) 290.71,64.04 290.71,67.94 293.86,71.08 294.54,71.08 294.94,71.49 295.89,71.49 296.29,71.89 296.29,72.9 296.18,73.01 LV26.3 296.18,73.81 296.29,73.92 296.29,74.18 296.18,74.29 LV26.4 296.18,75.04 296.29,75.15 296.29,75.62 RV562.2 296.3,76.27 296.3,76.55 296.15,76.7 296.15,76.98 296.04,77.09 DV4.8 296.04,77.45 296.15,77.56 296.15,77.87 296.04,77.98 DV4.2 296.04,78.47 296.1,78.53 296.1,78.53 296.1,78.94 296.42,79.27 297.04,79.27 299.88,76.43 300.42,76.43 JHDMI1.4
TMDS_T_TX2N: length 63.3
  TOP w0.089: UM1.H7 269.11,37.04 272.7,40.64 272.7,47.22 275.59,50.1 276.17,50.1 290.08,64.01 v4(290.08,64.68) 290.08,67.97 293.6,71.49 294.38,71.49 294.66,71.78 294.66,72.9 294.77,73.01 LV27.2 294.77,73.78 294.66,73.89 294.66,74.15 294.77,74.26 LV27.1 294.77,75.05 294.66,75.16 294.66,75.62 RV565.1 294.68,76.24 294.68,76.46 294.93,76.71 294.93,76.98 295.04,77.09 DV4.7 295.04,77.45 294.93,77.56 294.93,77.87 295.04,77.98 DV4.4 295.04,78.34 294.93,78.45 294.93,79.26 295.54,79.87 299.32,79.87 301.86,77.34 JHDMI1.3
TMDS_T_TX2P: length 63.3
  TOP w0.089: UM1.H8 268.65,37.69 268.65,37.42 268.74,37.32 268.99,37.32 272.42,40.75 272.42,47.33 275.47,50.38 276.06,50.38 289.8,64.12 289.8,68.08 293.49,71.77 v4(293.86,71.77) 294.26,71.77 294.38,71.89 294.38,72.9 294.27,73.01 LV27.3 294.27,73.79 294.38,73.9 294.38,74.19 294.27,74.29 LV27.4 294.27,75.05 294.38,75.16 294.38,75.62 RV565.2 294.4,76.27 294.4,76.57 294.65,76.83 294.65,76.95 294.54,77.06 DV4.6 294.54,77.48 294.65,77.59 294.65,77.84 294.54,77.95 DV4.5 294.54,78.37 294.65,78.47 294.65,79.38 295.42,80.16 299.44,80.16 301.43,78.17 JHDMI1.1
TMDS_T_TXCN: length 60.6
  TOP w0.089: UM1.H1 269.01,32.24 274.87,38.1 274.87,46.46 276.46,48.05 277.27,48.05 289.51,60.29 293.75,60.29 294.54,61.08 294.54,61.71 294.65,61.81 LV24.2 LV24.1 294.65,64.23 294.54,64.34 294.54,64.7 RV554.2 294.53,65.34 294.53,65.75 294.33,65.94 294.33,66.1 294.44,66.2 DV5.5 DV5.6 294.44,67.56 294.32,67.68 294.32,67.87 294.87,68.41 296.09,68.41 296.4,68.73 296.4,69.31 v2(296.58,69.48)
  IN1 w0.089: JHDMI1.12 300.26,72.67 300.15,72.78 300.15,73.11 300.01,73.25 298.95,73.25 296.3,70.6 296.3,69.76 v2(296.58,69.48)
TMDS_T_TXCP: length 60.6
  TOP w0.089: v2(295.82,69.48) 295.91,69.48 296.12,69.27 296.12,68.85 295.97,68.7 294.75,68.7 294.04,67.99 294.04,67.68 293.94,67.58 DV5.7 DV5.4 293.94,66.25 294.05,66.14 294.05,65.82 294.24,65.63 294.24,65.32 RV554.1 294.25,64.7 294.25,64.34 294.15,64.23 LV24.4 LV24.3 294.15,61.78 294.22,61.71 294.22,61.15 293.63,60.57 289.39,60.57 277.15,48.33 276.34,48.33 274.58,46.57 274.58,38.22 268.89,32.52 268.73,32.52 268.61,32.64 268.61,32.93 UM1.H2
  IN1 w0.089: v2(295.82,69.48) 296.06,69.73 296.06,70.7 298.85,73.49 300.48,73.49 JHDMI1.10
TOUCH_SCREEN_PD#: length 100.5
  TOP w0.102: v2(68.77,31.3) 68.77,29.31 68.46,29.01 67.99,29.01 67.04,28.06 64.08,28.06 DI1.1
  IN2 w0.127: v2(68.77,31.3) 69.8,31.3 71.05,32.55 98.7,32.55 99,32.25 106.43,32.25 109.9,28.77 140.31,28.77 141.56,30.03 v2(144.41,30.03)
  BOTTOM w0.089: UH2.AE44 157.57,31.58 157.17,31.18 155.87,31.18 155.78,31.09 154.92,31.09 RH69.1
  BOTTOM w0.102: RH69.1 153.45,29.71 150.85,29.71 149.65,30.9 149.03,30.9 148.16,30.03 v2(144.41,30.03)
TOUCHPAD_INTR#: length 6.2
  TOP w0.102: RH179.1 167.32,19.29 167.32,20.52 167.9,21.11 167.9,21.77 DH1.2 168.12,22.31 168.12,23.75 v2(168.05,23.82)
  BOTTOM w0.089: UH2.BC23 168.03,23.14 168.03,23.8 v2(168.05,23.82)
TP_PW_EN#: length 108.9
  TOP w0.102: v2(139.76,18.15) 139.76,17.92 140.9,16.78 140.9,15.9 RZ32.1 139.57,15.41 139.26,15.1 UE4.4 ; v2(227.52,14.62) 227.75,14.62 228.25,15.13 UE1.49
  IN2 w0.127: v2(139.76,18.15) 140.56,17.35 142.85,17.35 143.46,17.96 145.87,17.96 148.6,15.23 151.08,15.23 154.81,11.5 158.61,11.5 160.31,13.2 166.55,13.2 167.22,13.2 172.07,8.35 180.2,8.35 182.19,10.34 183.21,10.34 187.18,14.32 188.13,14.32 189.84,16.03 192.59,16.03 193.08,16.51 198.1,16.51 199.74,18.15 206.7,18.15 206.89,18.34 207.46,18.34 208.04,17.77 208.66,17.77 210.4,16.03 214.67,16.03 214.92,16.28 214.92,17.16 215.07,17.31 223.81,17.31 225.22,15.9 226.49,15.9 227.52,14.87 v2(227.52,14.62)
  BOTTOM w0.102: v2(227.52,14.62) v1(227.52,14.06)
TRIP_+1.35VS_VGAP: length 6.7
  BOTTOM w0.102: PR902.2 143.44,108.47 v1(144.79,107.13)
  BOTTOM w0.254: PU900.2 141.18,111.04 141.49,110.73 142.25,110.73 142.88,110.1 PR902.2
U2_BOOT1: length 0.8
  TOP w0.102: v2(174.08,57.55) 174.41,57.22 v1(174.74,57.22)
U2_BOOT2: length 3
  BOTTOM w0.102: PR1015.1 174.38,51.22 175.24,50.36 175.24,49.16 175.19,49.11 v1(175.19,48.78)
U2_BOOT3: length 3.5
  TOP w0.102: PR1031.1 201.09,54.18 v1(201.61,53.66)
  TOP w0.254: 202.04,55.34 202.31,55.6 PU1001.4
  TOP w0.508: PR1031.1 201.94,55.24 202.04,55.34
U2_LGATE1: length 20
  IN1 w0.635: v2(173.07,55.78) 172.61,56.24 v2(172.33,56.24) 171.4,56.24 170.7,55.54 168.83,55.54 167.76,56.61 163.73,56.61 163.54,56.42 ; 160.14,51.72 159.83,52.03 159.83,56.07 160.61,56.86 161.5,56.86 162.11,56.25 v2(162.29,56.25)
  BOTTOM w0.254: PR1014.2 171.92,55.82 172.25,56.15 172.25,56.15 v2(172.33,56.24) ; PU1000.23 173.19,55.66 v2(173.07,55.78)
  vias: v2(160.03,51.04) v2(160.61,51.04) v2(162.91,56.25)
U2_LGATE2: length 34.1
  IN2 w0.635: v2(172.76,53.76) 172.76,53.03 v2(172.75,53.03) 168.98,49.27 150.38,49.27 148.71,50.93 145.95,50.93
  IN3 w0.635: 144.62,55.92 144.62,51.63 144.61,51.62
  vias: v2(144.38,56.56) v2(144.62,50.92) v2(144.97,56.56) v2(145.21,50.92)
U2_LGATE3: length 15.8
  IN1 w0.635: 206,58 205.95,58.05 206.05,58.16 206.05,68.42 205.65,68.82 200.9,68.82
  vias: v2(200.29,69.46) v2(200.29,68.87) v2(205.04,69.56) v2(205.7,69.54) v2(205.78,56.68) v2(205.93,57.27)
U2_PHASE1: length 20.5
  TOP w0.635: PR1009.1 164.6,57.08 164.6,57.1 164.41,57.29 v2(164.41,57.39)
  IN1 w0.635: v2(164.41,57.39) 172.6,57.39 v2(172.88,57.11) 173.14,57.11 v2(173.59,56.66)
  IN3 w0.508: v2(177.56,50.41) 177.56,50.42 177.56,51.12 176.06,52.62 174.56,52.62 174,53.18 174,56.25 v2(173.59,56.66)
  BOTTOM w0.381: PR1027.1 178.02,49.95 v2(177.56,50.41)
U2_PHASE2: length 35.3
  IN2 w0.508: v2(178.95,50.41) 178.95,50.92 176.72,53.15 174.18,53.15
  IN2 w0.635: v2(173.29,52.09) 173.29,50.9 171.9,49.52 170.57,49.52 169.43,48.38 149.67,48.38 147.93,50.11
  BOTTOM w0.508: PR1024.1 179.41,49.95 v2(178.95,50.41)
  vias: v2(146.21,50.22) v2(146.48,56.45) v2(146.67,51.62) v2(147.23,50.22) v2(147.63,51.62) v2(147.84,58.03) v2(147.85,56.45) v2(148.47,58.03) v2(149.11,58.03) v2(149.74,58.03) v2(173.67,52.64) v3(146.92,54.83)
U2_PHASE3: length 26.3
  TOP w0.381: v2(189.57,58.71) 188.63,58.71 182.88,52.96 179.12,52.96 PR1023.1
  IN1 w0.381: v2(189.57,58.71) 189.57,63.69 v2(189.62,63.74)
  IN3 w0.635: 199.27,65.78 199.27,60.7 200.49,59.48 200.49,58.13
  vias: v2(189.24,69.21) v2(189.87,69.21) v2(190.51,69.21) v2(190.56,64.25) v2(190.84,63.69) v2(191.14,69.21) v2(191.14,64.25) v2(191.53,63.62) v2(191.78,69.21) v2(191.78,64.25) v2(192.16,63.62) v2(192.41,69.21) v2(192.41,64.25) v2(193.05,69.21) v2(193.05,64.25) v2(195.17,67.66) v2(195.17,66) v2(200.03,67.66) v2(200.03,66) v2(200.42,57.19) v2(200.39,56.56) v2(200.92,67.66) v2(200.92,66) v3(192.9,66.79)
U2_PWM3: length 37.4
  TOP w0.102: v2(203.87,55.06) v1(203.87,54.45)
  TOP w0.254: PU1001.5 204.42,55.6 v2(203.87,55.06)
  IN2 w0.254: v2(172.83,55.08) 173.19,55.08 174.71,56.61 175.35,56.61 177.53,58.79 181.87,58.79 183.26,57.41 196.59,57.41 199.35,54.65 203.46,54.65 v2(203.87,55.06)
  BOTTOM w0.254: v2(172.83,55.08) 172.91,55.16 PU1000.22
U2_UGATE1: length 26.9
  IN3 w0.635: v2(175.14,57.78) 174.7,58.22 v2(174.63,58.22) 172.29,58.22 170.32,56.25 v2(169.94,56.25) v2(169.17,56.25) 168.82,56.61 163.8,56.61 163.4,57.01 157.93,57.01 154.31,53.39 v2(154.31,50.92) v2(155.08,50.92)
U2_UGATE2: length 35.6
  TOP w0.102: v2(150,50.79) v3(150,51.67)
  IN1 w0.635: 151.27,50.82 152.18,50.82 152.21,50.79 ; v2(175.32,51.76) 175.32,51.04 v2(175.24,50.97) 175.09,51.12 170.77,51.12 169.4,49.75 167.45,49.75 166.68,48.99 161.76,48.99 160.84,48.07 154.92,48.07 152.21,50.79 ; 152.21,50.79 152.35,50.93 152.35,55.42 151.9,55.87 v2(151.65,55.87) v2(150.96,55.87)
  BOTTOM w0.254: v2(175.32,51.76) 175.26,51.81 PU1000.17
  vias: v2(150.58,50.79)
U2_UGATE3: length 12.7
  TOP w0.254: PU1001.3 v2(201.79,56.1)
  IN3 w0.635: v2(200.29,62.86) v2(200.29,63.56) 204.61,63.56 205.24,62.93 ; 205.2,61.41 201.97,58.18 201.97,56.84
  vias: v2(201.15,56.1) v2(205.2,61.62) v2(205.24,62.35)
UART2_RXD: length 86.2
  TOP w0.102: v3(186.01,31.49) 186.01,31.87 186.25,32.1 v2(186.25,32.61) 186.36,32.72 186.36,33.5 189.89,37.04 190.37,37.04 192.31,38.98 193.18,38.98 194.32,40.12 194.32,42.43 v2(194.62,42.74)
  IN3 w0.127: v2(156.25,27.19) 156.98,27.19 157.69,26.48 158.33,26.48 158.56,26.71 161.23,26.71 162.68,28.16 163.13,28.16 164.75,29.78 164.75,30.17 165.15,30.57 170.95,30.57 171.74,29.78 177.15,29.78 177.45,30.09 180.01,30.09 180.45,30.53 180.45,30.7 180.78,31.03 182.51,31.03 182.96,31.49 184.11,31.49 184.46,31.84 185.48,31.84 v2(186.25,32.61)
  BOTTOM w0.089: UH2.AR45 157.15,27.07 156.37,27.07 v2(156.25,27.19)
  BOTTOM w0.102: v2(156.25,27.19) 156.25,27.27 155.86,27.65 155.25,27.65 RH160.2 ; v2(194.62,42.74) 194.8,42.56 198.61,42.56 201.2,45.15 208.87,45.15 210.19,46.47 210.19,47.23 209.86,47.56 209.86,48.05 210.32,48.5 210.32,50.54 209.84,51.02 209.84,54.68 212.66,57.5 212.66,59.88 213.07,60.3 JUART.3
UART2_TXD: length 85.2
  TOP w0.102: v2(185.55,33.29) 185.76,33.29 190.73,38.26 190.73,38.6 191.34,39.21 193.08,39.21 194.02,40.15 194.02,42.84 194.35,43.17 195.03,43.17 v2(195.08,43.12) ; RH159.2 154.72,27.85 156.17,27.85 156.65,27.37 v3(157.46,27.37) 157.96,27.37 158.02,27.43 159.13,27.43 159.39,27.7 159.43,27.7 159.44,27.71 159.82,27.71 v2(160.24,27.29)
  IN3 w0.127: v2(160.24,27.29) 161.45,27.29 162.57,28.41 163.03,28.41 164.5,29.89 164.5,30.28 165.05,30.83 171.05,30.83 171.84,30.04 177.02,30.04 177.33,30.34 178.97,30.34 179.78,31.16 180.55,31.16 181.09,31.69 181.09,32.12 181.49,32.53 185.33,32.53 185.58,32.78 185.58,33.26 v2(185.55,33.29)
  BOTTOM w0.089: v2(160.24,27.29) 159.84,26.89 UH2.AR39
  BOTTOM w0.102: JUART.2 213.48,61.1 212.4,60.02 212.4,57.6 209.59,54.78 209.59,50.91 210.07,50.43 210.07,48.61 209.61,48.15 209.61,47.46 209.94,47.13 209.94,46.58 208.77,45.41 201.1,45.41 198.81,43.12 v2(195.08,43.12)
UG_3V: length 15.9
  IN1 w0.635: v2(59.76,10.34) v2(59.06,10.34) 54.91,10.34 50.94,14.32 v2(50.94,19.09) v2(50.94,19.78)
UG_5V:
  vias: v2(50.68,28.57) v2(50.68,27.93) v2(51.06,23.74) v2(51.06,23.1) v3(50.96,26.66)
UG_+1.35VS_VGAP: length 9.5
  TOP w0.102: v2(145.2,120.67) v3(145.2,119.79)
  IN1 w0.508: v2(144.8,121.16) 144.8,121.06 v2(145.2,120.67) 145.2,117.24 143.27,115.31 v2(141.49,115.31)
USB2_COMP: length 5.4
  TOP w0.102: RH109.1 178.88,30.85 v2(179.16,31.13) 180.16,31.13 180.54,30.74 180.54,30.28 v1(180.78,30.04)
  BOTTOM w0.102: v2(179.16,31.13) 179.08,31.05 178.7,31.05 178.54,30.9 178.1,30.9 177.82,30.62 UH2.AG3
USB2_ID: length 7.1
  BOTTOM w0.076: UH2.AG2 178.55,30.62 178.7,30.77 179.33,30.77 179.51,30.95 180.15,30.95 180.98,31.79 180.98,32.1
  BOTTOM w0.102: 180.98,32.1 181.41,32.52 181.49,32.52 v1(181.72,32.76) 182.18,33.21 182.18,33.92 182.56,34.31 RH113.1
USB2_VBUSSENSE: length 3.6
  TOP w0.102: RH112.1 175.93,33.24 v1(176.06,33.11) 176.06,32.81 v2(175.85,32.6)
  BOTTOM w0.089: v2(175.85,32.6) 175.85,32.15 175.55,31.84 175.3,31.84 175,32.13 UH2.AD10
USB3RN1: length 130.9
  IN1 w0.114: v2(176.29,45.1) 176.44,44.95 176.44,44.68 176.73,44.39 179.55,44.39 183.06,40.88 186.99,40.88 188.8,39.07 191.32,39.07 193.95,36.44 201.94,36.44 202.45,35.93 207.57,35.93 208.49,35.01 210.07,35.01 212.44,32.64 223.37,32.64 223.65,32.36 252.05,32.36 252.68,32.98 262.54,32.98 262.93,32.6 268.12,32.6 268.72,33.2 268.72,33.36 269.02,33.67 269.02,34.71 273.62,39.31 277.51,39.31 277.99,39.8 277.99,40.05 v2(278.19,40.25)
  BOTTOM w0.076: UH2.B7 175.92,43.11 175.48,43.54 175.48,43.79 175.81,44.12 175.96,44.12 176.39,44.55 176.39,45 v2(176.29,45.1)
  BOTTOM w0.102: v2(278.19,40.25) 277.82,40.25 277.69,40.12 277.69,39.74 277.95,39.48 278.3,39.48 278.72,39.06 278.72,35.07 279.44,34.36 279.94,34.36 280.5,33.8 285.47,33.8 285.93,34.25 287.64,34.25 RI40.1
USB3RN1_D-: length 10.7
  BOTTOM w0.102: JUSB1.5 297.91,34.15 297.56,33.8 297.32,33.8 296.74,33.21 295.43,33.21 294.65,33.99 v4(294.22,33.99) 293.25,33.99 293.22,34.01 292.62,34.01 292.6,33.99 292.38,33.99 292.23,34.14 DI9.1 DI9.9 290.77,34.14 290.62,33.99 290.42,33.99 290.15,34.26 289.36,34.26 RI40.2
USB3RN2: length 136.3
  IN1 w0.114: v2(286.65,53.58) 286.44,53.38 286.13,53.38 285.89,53.13 285.89,49.37 285.25,48.73 283.95,48.73 283.7,48.98 277.31,48.98 275.35,47.02 275.35,43.59 269.08,37.32 264.59,37.32 261.16,33.89 252.58,33.89 252.17,34.31 218.22,34.31 217.71,33.79 212.57,33.79 210.48,35.89 208.96,35.89 208.03,36.82 202.8,36.82 202.29,37.33 200.27,37.33 199.67,37.93 197.18,37.93 196.58,37.33 194.37,37.33 191.7,40 189.2,40 187.43,41.77 183.45,41.77 182.89,42.33 182.89,43.63 182.49,44.03 181.36,44.03 179.63,45.76 176.03,45.76 175.62,45.35 175.47,45.35 175.22,45.1 175.22,44.77 v2(175.02,44.57)
  BOTTOM w0.076: UH2.C8 175.03,43.11 175.03,43.35 175.1,43.44 175.1,44.48 v2(175.02,44.57)
  BOTTOM w0.102: RI44.1 288.71,53.3 286.93,53.3 v2(286.65,53.58)
USB3RN2_D-: length 9.7
  BOTTOM w0.102: JUSB2.5 297.91,54.62 297.81,54.52 297.38,54.52 296.87,54.02 295.49,54.02 294.51,53.04 v4(294.17,53.04) 293.72,53.04 293.58,53.19 DI7.1 DI7.9 291.95,53.19 291.84,53.07 291.77,53.07 291.53,53.31 290.43,53.31 RI44.2
USB3RN3: length 204.2
  TOP w0.102: JIO1.20 10.49,32.25 10.64,32.1 11.83,32.1 12.07,32.34 12.72,32.34 v2(12.95,32.56)
  IN3 w0.127: v2(12.95,32.56) 12.31,32.56 12.06,32.32 12.06,30.48 13.27,29.28 13.27,26.7 12.28,25.71 12.28,23 19.03,16.25 21.85,16.25 23.12,14.98 24.04,14.98 25.84,13.17 42.07,13.17 43.07,14.17 48.22,14.17 52.97,18.92 55.31,18.92 57.8,21.4 61.58,21.4 63.56,23.38 63.56,26.33 65.88,28.65 111.56,28.65 112.28,27.93 116.85,27.93 117.57,28.65 139.72,28.65 141.93,30.86 141.93,33.92 145.23,37.22 146.52,37.22 147.05,37.75 147.05,40.48 150.76,44.19 155.18,44.19 157,46 160.35,46 161.18,46.83 173.75,46.83 174.4,46.19 174.4,45.98 v2(174.25,45.84)
  BOTTOM w0.076: v2(174.25,45.84) 174.44,45.65 174.44,45.57 174.25,45.38 174.25,44.92 174.44,44.73 174.44,44.12 174.58,43.98 174.58,43.45 174.72,43.31 UH2.B10
USB3RP1: length 130.9
  IN1 w0.114: v2(177.05,45.1) 176.84,45.1 176.66,44.92 176.66,44.78 176.82,44.61 179.64,44.61 183.15,41.11 187.08,41.11 188.9,39.3 191.41,39.3 194.05,36.66 202.03,36.66 202.54,36.15 207.66,36.15 208.58,35.24 210.16,35.24 212.53,32.87 223.47,32.87 223.75,32.59 251.96,32.59 252.58,33.21 262.64,33.21 263.02,32.83 268.03,32.83 268.49,33.3 268.49,33.46 268.8,33.76 268.8,34.8 273.53,39.54 273.72,39.54 277.42,39.54 277.77,39.89 277.77,40.26 277.62,40.4 277.42,40.4 v2(277.27,40.26)
  BOTTOM w0.076: v2(177.05,45.1) 176.77,45.1 176.67,45 176.67,44.92 176.55,44.81 176.55,44.48 176.03,43.96 175.88,43.96 175.64,43.72 175.64,43.61 175.75,43.51 175.86,43.51 175.89,43.54 UH2.A7
  BOTTOM w0.102: v2(277.27,40.26) 277.49,40.04 277.49,39.66 277.86,39.28 278.22,39.28 278.52,38.98 278.52,34.98 279.35,34.15 279.86,34.15 280.42,33.59 285.56,33.59 286.01,34.05 287.64,34.05 RI39.1
USB3RP1_D+: length 10.6
  BOTTOM w0.102: RI39.2 289.37,34.06 290.06,34.06 290.34,33.79 290.6,33.79 290.75,33.64 DI9.8 DI9.2 292.24,33.64 292.39,33.79 v4(292.92,33.79) 293.89,33.79 293.92,33.76 294.59,33.76 295.34,33.01 296.82,33.01 297.41,33.59 297.64,33.59 297.91,33.32 JUSB1.6
USB3RP2: length 136.2
  IN1 w0.114: v2(175.78,44.57) 175.55,44.57 175.44,44.68 175.44,45.01 175.56,45.13 175.71,45.13 176.12,45.53 179.54,45.53 181.26,43.81 182.4,43.81 182.67,43.53 182.67,42.24 183.36,41.54 187.33,41.54 189.11,39.77 191.61,39.77 194.28,37.1 196.67,37.1 197.27,37.71 199.58,37.71 200.18,37.1 202.2,37.1 202.71,36.59 207.94,36.59 208.87,35.66 210.39,35.66 212.48,33.57 217.8,33.57 218.31,34.08 252.08,34.08 252.49,33.67 261.25,33.67 264.68,37.1 269.17,37.1 275.57,43.5 275.57,46.92 277.4,48.76 283.61,48.76 283.86,48.51 285.35,48.51 286.11,49.27 286.11,53.04 286.22,53.15 286.52,53.15 286.65,53.03 v2(286.65,52.82)
  BOTTOM w0.076: UH2.B8 175.35,43.32 175.35,43.42 175.26,43.51 175.26,44.31 175.4,44.44 175.4,44.64 175.47,44.72 175.63,44.72 v2(175.78,44.57)
  BOTTOM w0.102: RI43.1 288.71,53.1 286.93,53.1 v2(286.65,52.82)
USB3RP2_D+: length 9.7
  BOTTOM w0.102: RI43.2 290.42,53.08 v4(291.23,53.08) 291.45,53.08 291.67,52.87 291.84,52.87 292.02,52.69 DI7.8 DI7.2 293.58,52.69 293.72,52.83 293.85,52.83 293.87,52.81 294.57,52.81 295.57,53.81 296.96,53.81 297.46,54.32 297.81,54.32 297.91,54.22 JUSB2.6
USB3RP3: length 204.1
  TOP w0.102: JIO1.19 10.49,31.75 10.64,31.9 11.92,31.9 12.15,32.13 12.78,32.13 v2(12.95,31.96)
  IN3 w0.127: v2(12.95,31.96) 12.6,32.31 12.41,32.31 12.32,32.22 12.32,30.58 13.52,29.38 13.52,26.59 12.53,25.6 12.53,23.1 19.14,16.5 21.96,16.5 23.23,15.23 24.14,15.23 25.95,13.42 41.97,13.42 42.96,14.42 48.12,14.42 52.87,19.17 55.2,19.17 57.69,21.66 61.48,21.66 63.31,23.49 63.31,26.43 65.77,28.9 111.67,28.9 112.38,28.18 116.75,28.18 117.47,28.9 139.62,28.9 141.68,30.97 141.68,34.03 145.12,37.47 146.42,37.47 146.8,37.85 146.8,40.58 150.65,44.44 155.07,44.44 156.89,46.26 160.25,46.26 161.07,47.08 173.86,47.08 174.65,46.29 174.65,45.97 174.79,45.84 v2(175.02,45.84)
  BOTTOM w0.076: v2(175.02,45.84) 175.02,45.87 174.82,46.06 174.69,46.06 174.61,45.98 174.61,45.5 174.42,45.31 174.42,44.99 174.61,44.8 174.61,44.19 174.75,44.05 174.75,43.78 174.85,43.68 UH2.A9
USB3T_N1: length 4.3
  BOTTOM w0.102: CI16.2 284.34,32.1 284.87,32.1 284.9,32.12 285.47,32.12 285.5,32.1 v4(286.78,32.1) 287.64,32.1 RI38.1
USB3T_N2: length 2.1
  BOTTOM w0.102: CI9.2 287.66,51.25 288.68,51.25 RI42.1
USB3T_P1: length 4.3
  BOTTOM w0.102: RI37.1 287.64,31.89 287.08,31.89 287.06,31.87 286.49,31.87 286.47,31.89 v4(285.19,31.89) 284.46,31.89 CI20.2
USB3T_P2: length 2.1
  BOTTOM w0.102: CI10.2 287.74,51.04 288.73,51.04 RI41.1
USB3TN1: length 125.8
  IN1 w0.114: v2(173.81,44.4) 173.88,44.47 174.24,44.47 174.36,44.35 174.36,44.08 174.71,43.73 179.28,43.73 182.81,40.2 186.69,40.2 189.2,37.68 190.54,37.68 192.43,35.78 201.66,35.78 202.18,35.27 207.03,35.27 209.42,32.88 211.29,32.88 212.17,32 223.11,32 223.39,31.72 252.45,31.72 253.06,32.32 262.1,32.32 262.48,31.94 268.37,31.94 269.36,32.94 269.36,33.04 274.52,38.21 276.93,38.21 277.18,38.46 277.18,38.63 v2(277.39,38.83)
  BOTTOM w0.076: UH2.C11 174.21,42.81 173.98,43.04 173.98,43.37 174.03,43.41 174.03,43.41 174.16,43.54 174.16,43.92 174.09,43.99 174.09,44.31 174,44.4 v2(173.81,44.4)
  BOTTOM w0.102: v2(277.39,38.83) 277.08,38.83 276.96,38.72 276.96,35.96 279.23,33.7 279.67,33.7 281.39,31.98 282.75,31.98 CI16.1
USB3TN1_D-: length 13.2
  BOTTOM w0.102: RI38.2 289.37,32.1 290.05,32.1 290.45,32.49 290.62,32.49 290.77,32.64 DI9.7 DI9.4 292.22,32.64 292.36,32.49 292.86,32.49 v4(293.12,32.23) 293.37,31.98 294.51,30.84 294.51,29.74 294.54,29.71 294.54,29.07 295.24,28.36 296.9,28.36 297.44,27.82 297.81,27.82 297.91,27.92 JUSB1.8
USB3TN2: length 139.6
  IN1 w0.114: v2(172.98,45.84) 172.78,46.04 172.78,46.17 172.95,46.33 175.82,46.33 175.97,46.17 182.16,46.17 183.27,47.28 186.76,47.28 187.52,46.53 187.52,43.24 188.55,42.21 191.01,42.21 192.36,40.85 192.36,40.11 194.13,38.35 201.72,38.35 202.12,37.95 202.83,37.95 203.08,37.7 207.74,37.7 209.14,36.31 210.69,36.31 212.77,34.23 217.35,34.23 217.86,34.74 239.22,34.74 240.15,35.68 242.31,35.68 243.25,34.74 252.51,34.74 252.92,34.33 260.89,34.33 262.11,35.55 262.11,36.1 263.2,37.19 263.86,37.19 264.41,37.74 268.83,37.74 274.71,43.63 274.71,47.31 277.46,50.06 284.84,50.06 285.46,50.68 285.46,51.73 285.18,52.01 284.79,52.01 v2(284.62,52.19)
  BOTTOM w0.076: UH2.B12 173.59,43.25 173.82,43.47 173.82,43.49 173.82,43.73 173.82,43.74 173.82,43.88 172.86,44.85 172.86,45.71 v2(172.98,45.84)
  BOTTOM w0.102: CI9.1 286.1,51.21 285.85,51.21 285.15,51.91 284.9,51.91 v2(284.62,52.19)
USB3TN2_D-: length 11.1
  BOTTOM w0.102: RI42.2 290.43,51.27 291.24,51.27 291.5,51.54 291.77,51.54 291.91,51.69 DI7.7 DI7.4 293.55,51.69 293.69,51.54 293.92,51.54 v4(294.27,51.19) 294.62,50.84 294.62,50.12 294.65,50.1 294.65,49.63 294.91,49.37 296.65,49.37 297.49,48.52 297.81,48.52 297.91,48.62 JUSB2.8
USB3TN3: length 199.5
  TOP w0.102: v2(11.73,29.34) 11.73,29.97 11.46,30.25 JIO1.16
  IN3 w0.127: v2(171.33,45.08) 171.16,45.25 171.16,45.25 170.34,46.07 161.83,46.07 161,45.23 157.19,45.23 155.32,43.36 150.99,43.36 147.74,40.11 147.74,37.06 144.6,33.92 144.6,31.89 140.68,27.97 117.9,27.97 117.18,27.25 111.9,27.25 111.28,27.87 70.23,27.87 68.29,25.93 66.51,25.93 64.37,23.79 64.37,22.32 62.78,20.72 58.36,20.72 55.82,18.18 53.33,18.18 47.64,12.49 25.51,12.49 23.76,14.24 22.84,14.24 21.95,15.13 19.16,15.13 10.08,24.21 10.08,29.72 10.64,30.28 11.45,30.28 11.73,30 v2(11.73,29.34)
  BOTTOM w0.076: v2(171.33,45.08) 171.5,45.24 171.62,45.24 171.7,45.16 171.7,44.91 171.74,44.87 171.74,44.31 172.14,43.91 172.76,43.91 173.19,43.47 173.19,43.03 173.15,42.86 UH2.C13
USB3TP1: length 125.9
  IN1 w0.114: v2(173.8,45) 173.83,45 174.13,44.7 174.33,44.7 174.58,44.44 174.58,44.17 174.8,43.95 179.38,43.95 182.91,40.42 186.78,40.42 189.3,37.91 190.63,37.91 192.53,36.01 201.76,36.01 202.27,35.49 207.12,35.49 209.51,33.11 211.38,33.11 212.27,32.22 223.2,32.22 223.48,31.94 252.36,31.94 252.96,32.55 262.19,32.55 262.58,32.17 268.27,32.17 269.14,33.03 269.14,33.14 274.43,38.43 276.83,38.43 276.96,38.56 276.96,38.75 276.86,38.85 v2(276.57,38.85)
  BOTTOM w0.076: v2(173.8,45) 173.93,45 174.16,44.77 174.16,44.47 174.25,44.38 174.25,44.06 174.32,43.99 174.32,43.48 174.21,43.36 UH2.B11
  BOTTOM w0.102: CI20.1 282.85,31.78 281.3,31.78 279.59,33.49 279.15,33.49 276.76,35.88 276.76,38.65 v2(276.57,38.85)
USB3TP1_D+: length 13.2
  BOTTOM w0.102: RI37.2 289.37,31.89 290.14,31.89 290.53,32.29 290.62,32.29 290.77,32.14 DI9.6 DI9.5 292.23,32.14 292.38,32.29 292.74,32.29 293.21,31.82 293.24,31.82 294.31,30.75 v4(294.31,29.42) 294.31,29.01 295.16,28.16 296.82,28.16 297.36,27.62 297.81,27.62 297.91,27.52 JUSB1.9
USB3TP2: length 139.6
  IN1 w0.114: v2(284.62,51.43) 284.62,51.64 284.76,51.79 285.08,51.79 285.23,51.64 285.23,50.77 284.74,50.28 277.37,50.28 274.49,47.4 274.49,43.72 268.73,37.97 264.32,37.97 263.76,37.41 263.11,37.41 261.89,36.19 261.89,35.64 260.8,34.55 253.01,34.55 252.6,34.97 243.34,34.97 242.41,35.9 240.06,35.9 239.13,34.97 217.77,34.97 217.26,34.45 212.86,34.45 210.78,36.53 209.23,36.53 207.83,37.93 203.17,37.93 202.92,38.18 202.21,38.18 201.81,38.57 194.22,38.57 192.59,40.2 192.59,40.94 191.1,42.43 188.65,42.43 187.74,43.33 187.74,46.62 186.86,47.51 183.18,47.51 182.07,46.4 176.07,46.4 175.91,46.56 172.85,46.56 172.56,46.26 172.56,46.13 172.56,46.13 172.56,45.97 172.43,45.84 v2(172.22,45.84)
  BOTTOM w0.076: UH2.A12 173.66,43.68 173.66,43.81 172.69,44.78 172.69,45.62 172.63,45.68 172.63,45.91 172.54,46 172.38,46 v2(172.22,45.84)
  BOTTOM w0.102: CI10.1 286.1,51.01 285.76,51.01 285.07,51.7 284.9,51.7 v2(284.62,51.43)
USB3TP2_D+: length 11
  BOTTOM w0.102: JUSB2.9 297.91,48.22 297.81,48.32 297.41,48.32 296.56,49.16 294.83,49.16 294.42,49.57 v4(294.42,49.8) 294.42,50.72 294.32,50.82 294.32,50.82 293.8,51.34 293.69,51.34 293.55,51.19 DI7.5 DI7.6 291.92,51.19 291.77,51.34 291.59,51.34 291.32,51.07 290.43,51.07 RI41.2
USB3TP3: length 199.5
  TOP w0.102: JIO1.15 10.55,29.75 10.64,29.84 10.64,29.95 10.74,30.05 11.37,30.05 11.53,29.89 11.53,29.72 v2(11.14,29.33)
  IN3 w0.127: v2(11.14,29.33) 11.14,29.37 11.48,29.71 11.48,29.89 11.35,30.03 10.74,30.03 10.33,29.62 10.33,24.31 19.26,15.38 22.06,15.38 22.95,14.49 23.86,14.49 25.61,12.74 47.53,12.74 53.22,18.43 55.71,18.43 58.25,20.97 62.67,20.97 64.12,22.42 64.12,23.89 66.41,26.18 68.18,26.18 70.12,28.12 111.38,28.12 112,27.5 117.08,27.5 117.8,28.22 140.57,28.22 144.35,32 144.35,34.03 147.48,37.17 147.48,40.21 150.89,43.61 155.22,43.61 157.08,45.48 160.89,45.48 161.73,46.32 170.45,46.32 171.26,45.5 171.6,45.5 171.75,45.35 171.75,45.12 171.88,45 172.02,45 v2(172.09,45.08)
  BOTTOM w0.076: v2(172.09,45.08) 171.9,44.88 171.9,44.38 172.21,44.07 172.82,44.07 173.35,43.54 173.35,43.01 173.26,42.64 UH2.D13
USB20_N1: length 126.3
  IN1 w0.114: v2(176.95,30.57) 176.9,30.57 176.74,30.72 176.74,30.92 176.88,31.05 177.24,31.05 179.7,28.6 182.06,28.6 182.36,28.9 185.12,28.9 186.15,27.87 186.15,26.7 186.45,26.41 187.31,26.41 188.15,25.57 197.22,25.57 198.1,26.46 198.1,26.95 199.42,28.27 204.11,28.27 206.01,26.36 210.47,26.36 211.02,26.91 220.42,26.91 221.23,26.11 223.48,26.11 223.99,26.61 228.28,26.61 228.99,25.9 234.25,25.9 235.91,27.56 240.49,27.56 241.39,26.67 246.99,26.67 247.8,27.48 251.96,27.48 253.13,26.31 254.19,26.31 255.02,27.14 255.02,27.3 255.81,28.09 256.76,28.09 257.05,27.8 268.88,27.8 270.83,29.76 271.28,29.76 274.74,33.22 277.59,33.22 277.99,33.62 281.29,33.62 281.7,34.03 286.26,34.03 286.62,34.39 286.62,35.04 v2(286.75,35.17)
  BOTTOM w0.102: LI2.1 287.51,35.81 287.21,36.1 286.7,36.1 286.34,35.75 286.34,35.55 286.73,35.17 v2(286.75,35.17) ; v2(176.95,30.57) 176.88,30.63 UH2.AF5
USB20_N2: length 114.5
  TOP w0.102: v2(280.15,36.01) 280.34,35.81 280.59,35.81 280.78,36 US1.2
  IN1 w0.114: v2(280.15,36.01) 279.94,35.8 278.95,35.8 278.47,35.32 275.61,35.32 270.92,30.63 270.47,30.63 269.25,29.4 255.52,29.4 254.51,28.39 247.31,28.39 246.59,27.68 241.93,27.68 241.13,28.48 235.19,28.48 234.39,27.68 221.12,27.68 221.02,27.78 210.65,27.78 210.14,27.27 206.35,27.27 204.47,29.14 198.96,29.14 196.28,26.46 189.48,26.46 187.32,28.62 186.7,28.62 185.31,30.01 179.66,30.01 178.62,31.04 178.62,31.79 178.09,32.32 176.79,32.32 v2(176.57,32.55)
  BOTTOM w0.102: UH2.AD5 176.94,32.18 v2(176.57,32.55)
USB20_N3: length 200.1
  TOP w0.102: JIO1.12 9.47,28.25 9.33,28.1 8.2,28.1 3.1,23 3.1,18.77 v2(2.89,18.57)
  IN3 w0.127: v2(175.12,30.62) 174.91,30.83 171.74,30.83 171.3,31.26 163.94,31.26 163.69,31.01 158.25,31.01 157.14,29.89 156.04,29.89 155.7,29.55 148.25,29.55 144.55,25.84 144.55,24.46 142.28,22.19 139.03,22.19 136.51,19.68 80.3,19.68 79.94,19.32 69.06,19.32 68.51,18.77 63.42,18.77 62.84,19.36 60.65,19.36 57.65,16.35 54.86,16.35 49.62,11.12 49.62,11.12 49.42,10.91 23.83,10.91 20.99,13.76 17.84,13.76 15.83,15.77 4.63,15.77 3.05,17.35 3.05,18.42 v2(2.89,18.57)
  BOTTOM w0.102: UH2.AG8 175.24,31.03 175.12,30.9 v2(175.12,30.62)
USB20_N4: length 79.6
  TOP w0.102: v2(179.89,31.8) 179.74,31.95 179.74,32.45 180.25,32.96 180.85,32.96 181.04,32.77 181.04,31.33 181.38,30.98 182,30.98 182.18,30.8 182.18,30.35 181.99,30.17 181.76,30.17 181.52,29.92 181.52,29.28 181.75,29.05 182.04,29.05 182.18,28.91 182.18,28.52 182.07,28.41 181.59,28.41 181.21,28.04 181.21,26.5 181.74,25.97 183.29,25.97 183.58,25.69 183.58,25.45 183.34,25.21 182.7,25.21 182.41,24.92 182.41,24.04 182.99,23.45 182.99,22.93 182.41,22.35 182.41,20.41 182.94,19.88 183.63,19.88 183.73,19.78 183.73,18.9 183.95,18.68 184.43,18.68 184.65,18.9 184.65,19.78 184.75,19.88 185.05,19.88 185.16,19.78 185.16,18.93 185.38,18.71 185.85,18.71 186.07,18.93 186.07,19.78 186.17,19.88 186.66,19.88 186.76,19.78 186.76,18.93 186.98,18.71 187.46,18.71 187.68,18.93 187.68,19.78 187.78,19.88 188.29,19.88 188.4,19.77 188.4,18.29 188.01,17.9 182.78,17.9 182.48,17.6 182.48,16.93 182.2,16.65 180.34,16.65 180.1,16.41 180.1,15.86 180.37,15.58 182.71,15.58 182.81,15.48 182.81,15.17 182.71,15.07 180.32,15.07 180.1,14.85 180.1,14.38 180.32,14.16 183.25,14.16 183.35,14.06 183.35,13.75 183.25,13.65 180.32,13.65 180.1,13.43 180.1,12.86 180.39,12.56 182.23,12.56 182.51,12.28 182.51,11.79 182.93,11.37 183.73,11.37 183.93,11.57 183.93,12.21 184.03,12.31 184.33,12.31 184.43,12.21 184.43,11.36 184.66,11.14 185.13,11.14 185.35,11.36 185.35,12.21 185.45,12.31 185.76,12.31 185.86,12.21 185.86,11.36 186.08,11.14 186.6,11.14 186.88,11.42 186.88,13.02 186.29,13.6 185.05,13.6 184.6,14.06 184.6,16.92 v2(184.79,17.12)
  BOTTOM w0.076: v2(179.89,31.8) 179.87,31.8 179.52,32.15 179.12,32.15 178.81,31.84 UH2.AE1
  BOTTOM w0.102: LN1.1 185.24,17.56 v2(184.79,17.12)
USB20_N4_R: length 2.7
  BOTTOM w0.102: LN1.2 185.24,19.73 185.1,19.87 185.1,20.68 185.16,20.74 185.16,20.96 185.31,21.1 JNGFF1.5
USB20_N7: length 205.1
  TOP w0.102: v2(4.49,19.52) 4.69,19.72 4.69,23.74 7.58,26.62 9.38,26.62 9.5,26.75 JIO1.9
  IN3 w0.127: v2(179.16,33.65) 179.33,33.82 179.33,33.96 179.14,34.16 178.9,34.16 178.65,33.9 178.65,33.52 178.27,33.14 173.75,33.14 170.95,35.93 165.08,35.93 164.85,35.7 163.28,35.7 160.85,33.27 157.74,33.27 157.41,33.6 155.97,33.6 154.41,32.04 149.48,32.04 143.74,26.3 143.74,24.67 142,22.93 136.87,22.93 134.3,20.36 79.94,20.36 79.8,20.23 68.72,20.23 68.15,19.66 63.62,19.66 63.25,20.04 60.32,20.04 57.75,17.47 54.46,17.47 54.2,17.21 54.2,16.66 49.34,11.8 25.13,11.8 23.43,13.51 22.59,13.51 21.65,14.45 18.88,14.45 15.82,17.5 5.5,17.5 4.76,18.24 4.76,19.26 v2(4.49,19.52)
  BOTTOM w0.076: v2(179.16,33.65) 178.97,33.46 178.86,33.46 178.68,33.64 178.01,33.64 177.89,33.52 UH2.AB3
USB20_N9: length 130.4
  IN3 w0.127: v2(179.89,34.91) 179.76,35.04 179.77,35.04 179.77,35.35 179.49,35.62 178.75,35.62 178.07,34.94 173.92,34.94 172.96,35.91 172.96,36.95 171.82,38.09 169.7,38.09 169.61,38.19 167.37,38.19 166.2,37.02 164.55,37.02 164.22,36.69 162.09,36.69 161.33,35.93 154.69,35.93 154.31,35.55 151.2,35.55 144.85,29.2 142.83,29.2 141.13,27.49 118.22,27.49 117.3,26.58 111.95,26.58 111.1,27.43 74.9,27.43 73.67,26.21 73.67,23.28 73.03,22.65 70.7,22.65 70.56,22.51 70.32,22.51 v2(70.11,22.71)
  BOTTOM w0.076: v2(179.89,34.91) 179.63,34.65 179.63,34.53 179.41,34.31 178.74,34.31 178.66,34.23 178.66,34.11 178.74,34.03 UH2.AA1
  BOTTOM w0.102: v2(70.11,22.71) 69.72,22.32 69.45,22.32 69,21.87 69,20.01 68.48,19.49 68.48,18.01 68.45,17.99 68.45,17.39 68.3,17.24 68.11,17.24 67.96,17.39 LI1.1
USB20_N9_R: length 15.8
  BOTTOM w0.102: JEDP1.10 63.2,28.51 63.88,27.82 63.88,24.11 63.88,24.09 63.81,23.34 63.74,22.59 63.66,22.18 63.27,20.08 63.26,20.07 63.21,19.87 63.21,18.43 63.64,18 63.74,18 63.87,18.13 63.87,18.56 DI3.2 65.01,18.02 65.32,18.02 65.62,17.73 65.62,17.47 65.85,17.24 66.02,17.24 66.17,17.39 LI1.2
USB20_N12: length 64
  IN1 w0.114: v2(229.68,36.16) 229.54,36.03 229.54,35.69 229.23,35.38 217.6,35.38 217.08,34.87 213.89,34.87 211.35,37.41 209.09,37.41 208.03,38.46 203.34,38.46 203.21,38.6 202.49,38.6 202.05,39.03 194.63,39.03 193.79,39.88 193.79,40.58 193.63,40.73 193.41,40.73 v2(193.3,40.63)
  BOTTOM w0.076: 180.11,32.76 180.1,32.75 180.07,32.75 179.7,32.38 178.78,32.38 178.57,32.17 178.07,32.17 UH2.AD3
  BOTTOM w0.102: v2(229.68,36.16) 229.3,36.55 229.3,37.07 230.18,37.95 230.76,37.95 230.85,37.86 230.85,37.74 230.94,37.65 LV22.1 ; 180.11,32.76 181.11,33.76 181.11,35.26 182.14,36.29 184.39,36.29 184.85,36.74 185.59,36.74 186.89,38.04 186.89,38.48 187.62,39.21 191,39.21 192.7,40.91 193.07,40.91 193.3,40.67 v2(193.3,40.63)
USB20_N12_R: length 17.3
  BOTTOM w0.102: LV22.2 233.17,37.65 233.32,37.8 235.17,37.8 236.08,36.88 236.55,36.88 236.65,36.78 DV12.3 237.49,36.86 238.07,36.86 238.38,37.17 238.38,39.19 237.96,39.61 237.47,39.61 237.44,39.64 236.87,39.64 236.85,39.61 v4(235.59,39.61) 235.21,39.61 234.96,39.87 234.96,40.95 235.76,41.75 235.76,42.41 236.02,42.67 JCAM1.6
USB20_P1: length 126.4
  IN1 w0.114: v2(286.14,35.17) 286.39,34.92 286.39,34.48 286.17,34.25 281.61,34.25 281.2,33.84 277.89,33.84 277.49,33.44 274.65,33.44 271.19,29.98 270.74,29.98 268.78,28.03 257.14,28.03 256.85,28.31 255.72,28.31 254.8,27.39 254.8,27.23 254.1,26.53 253.22,26.53 252.05,27.7 247.71,27.7 246.9,26.89 241.48,26.89 240.59,27.79 235.81,27.79 234.15,26.13 229.08,26.13 228.37,26.83 223.89,26.83 223.39,26.33 221.32,26.33 220.51,27.14 210.92,27.14 210.37,26.58 206.11,26.58 204.2,28.49 199.32,28.49 197.88,27.05 197.88,26.55 197.12,25.79 188.24,25.79 187.4,26.63 186.54,26.63 186.37,26.8 186.37,27.97 185.21,29.12 182.27,29.12 181.96,28.82 179.79,28.82 177.33,31.28 176.79,31.28 176.52,31.01 176.52,30.73 v2(176.34,30.55)
  BOTTOM w0.102: LI2.4 286.61,36.31 286.14,35.84 v2(286.14,35.17) ; UH2.AG7 176.34,30.87 v2(176.34,30.55)
USB20_P2: length 114.5
  TOP w0.102: v2(280.15,35.37) 280.39,35.61 280.61,35.61 280.72,35.5 US1.3
  IN1 w0.114: v2(280.15,35.37) 279.94,35.58 279.05,35.58 278.56,35.09 275.7,35.09 271.01,30.4 270.57,30.4 269.34,29.18 255.62,29.18 254.6,28.17 247.4,28.17 246.69,27.45 241.83,27.45 241.03,28.25 235.28,28.25 234.48,27.45 221.02,27.45 220.92,27.55 210.74,27.55 210.24,27.05 206.25,27.05 204.38,28.92 199.06,28.92 196.37,26.23 189.39,26.23 187.23,28.39 186.61,28.39 185.22,29.78 179.56,29.78 178.4,30.95 178.4,31.7 178,32.1 176.88,32.1 v2(176.59,31.82)
  BOTTOM w0.102: UH2.AD7 176.27,32.13 v2(176.59,31.82)
USB20_P3: length 200.2
  TOP w0.102: v2(3.68,18.57) 3.6,18.49 3.4,18.49 3.3,18.6 3.3,22.92 8.28,27.9 9.31,27.9 9.46,27.75 JIO1.11
  IN3 w0.127: v2(175.04,31.51) 175.04,31.22 174.9,31.08 171.84,31.08 171.41,31.51 163.84,31.51 163.59,31.26 158.15,31.26 157.03,30.14 155.94,30.14 155.6,29.8 148.15,29.8 144.3,25.95 144.3,24.57 142.17,22.44 138.92,22.44 136.4,19.93 80.2,19.93 79.83,19.57 68.95,19.57 68.41,19.02 63.53,19.02 62.94,19.61 60.55,19.61 57.54,16.6 54.75,16.6 49.52,11.37 49.51,11.37 49.31,11.17 23.94,11.17 21.09,14.01 17.94,14.01 15.94,16.02 4.73,16.02 3.3,17.45 3.3,18.46 3.41,18.57 v2(3.68,18.57)
  BOTTOM w0.102: UH2.AG10 175.04,31.42 v2(175.04,31.51)
USB20_P4: length 79.7
  TOP w0.102: v2(179.29,31.79) 179.54,32.04 179.54,32.54 180.16,33.16 180.93,33.16 181.24,32.86 181.24,31.41 181.47,31.18 182.09,31.18 182.38,30.88 182.38,30.27 182.08,29.96 181.85,29.96 181.72,29.84 181.72,29.36 181.83,29.25 182.13,29.25 182.38,29 182.38,28.44 182.15,28.21 181.67,28.21 181.42,27.96 181.42,26.58 181.82,26.18 183.37,26.18 183.78,25.77 183.78,25.36 183.42,25.01 182.79,25.01 182.61,24.83 182.61,24.12 183.19,23.54 183.19,22.85 182.61,22.27 182.61,20.5 183.03,20.08 183.72,20.08 183.94,19.86 183.94,18.99 184.04,18.89 184.34,18.89 184.44,18.99 184.44,19.86 184.67,20.08 185.14,20.08 185.36,19.86 185.36,19.01 185.46,18.91 185.77,18.91 185.87,19.01 185.87,19.86 186.09,20.08 186.74,20.08 186.96,19.86 186.96,19.01 187.07,18.91 187.37,18.91 187.47,19.01 187.47,19.86 187.69,20.08 188.38,20.08 188.6,19.85 188.6,18.2 188.1,17.69 182.86,17.69 182.69,17.52 182.69,16.85 182.29,16.45 180.43,16.45 180.3,16.32 180.3,15.94 180.46,15.78 182.8,15.78 183.02,15.56 183.02,15.09 182.8,14.87 180.4,14.87 180.3,14.77 180.3,14.46 180.4,14.36 183.33,14.36 183.55,14.14 183.55,13.67 183.33,13.45 180.4,13.45 180.3,13.34 180.3,12.94 180.48,12.77 182.31,12.77 182.71,12.37 182.71,11.88 183.02,11.57 183.64,11.57 183.72,11.65 183.72,12.29 183.94,12.51 184.42,12.51 184.64,12.29 184.64,11.45 184.74,11.34 185.04,11.34 185.15,11.45 185.15,12.29 185.37,12.51 185.84,12.51 186.06,12.29 186.06,11.45 186.16,11.34 186.51,11.34 186.67,11.5 186.67,12.94 186.21,13.4 184.96,13.4 184.39,13.97 184.39,16.93 v2(184.2,17.12)
  BOTTOM w0.076: v2(179.29,31.79) 179.26,31.79 178.88,31.42 178.42,31.42 178.31,31.53 UH2.AE2
  BOTTOM w0.102: LN1.4 184.74,17.65 v2(184.2,17.12)
USB20_P4_R: length 2.7
  BOTTOM w0.102: LN1.3 184.74,19.73 184.87,19.87 v4(184.87,20.37) 184.87,20.74 184.96,20.82 184.96,20.97 184.81,21.12 JNGFF1.3
USB20_P7: length 205.1
  TOP w0.102: v2(5.28,19.52) 5.23,19.47 5.01,19.47 4.9,19.59 4.9,23.65 7.67,26.42 9.36,26.42 9.53,26.25 JIO1.8
  IN3 w0.127: v2(179.76,33.63) 179.58,33.8 179.58,34.07 179.24,34.41 178.8,34.41 178.4,34 178.4,33.62 178.16,33.39 173.85,33.39 171.06,36.19 164.98,36.19 164.75,35.95 163.18,35.95 160.74,33.52 157.85,33.52 157.52,33.85 155.86,33.85 154.31,32.3 149.37,32.3 143.48,26.41 143.48,24.77 141.9,23.19 136.77,23.19 134.2,20.61 79.83,20.61 79.7,20.48 68.61,20.48 68.05,19.92 63.73,19.92 63.35,20.29 60.21,20.29 57.64,17.72 54.36,17.72 53.95,17.31 53.95,16.77 49.23,12.05 25.23,12.05 23.53,13.76 22.69,13.76 21.75,14.7 18.98,14.7 15.92,17.75 5.6,17.75 5.01,18.35 5.01,19.25 v2(5.28,19.52)
  BOTTOM w0.076: v2(179.76,33.63) 179.42,33.29 178.79,33.29 178.61,33.48 178.46,33.48 UH2.AB2
USB20_P9: length 130.4
  IN3 w0.127: v2(70.11,21.75) 70.11,22.14 70.23,22.26 70.67,22.26 70.81,22.4 73.14,22.4 73.92,23.18 73.92,26.1 75,27.18 110.99,27.18 111.85,26.33 117.41,26.33 118.32,27.24 141.23,27.24 142.94,28.95 144.96,28.95 151.31,35.3 154.42,35.3 154.8,35.68 161.43,35.68 162.19,36.44 164.32,36.44 164.65,36.77 166.3,36.77 167.47,37.94 169.5,37.94 169.6,37.84 171.71,37.84 172.7,36.85 172.7,35.8 173.82,34.69 178.17,34.69 178.85,35.37 179.38,35.37 179.52,35.24 179.52,35.14 179.41,35.04 179.41,35.04 v2(179.27,34.9)
  BOTTOM w0.076: v2(179.27,34.9) 179.46,34.7 179.46,34.6 179.34,34.48 178.68,34.48 178.5,34.3 178.5,34.1 178.42,34.03 UH2.AA2
  BOTTOM w0.102: LI1.4 67.96,16.89 68.11,17.03 68.39,17.03 68.68,17.33 v4(68.68,17.71) 68.68,19.41 69.2,19.93 69.2,21.78 69.53,22.11 69.75,22.11 v2(70.11,21.75)
USB20_P9_R: length 15.9
  BOTTOM w0.102: JEDP1.9 63.41,28.01 63.68,27.74 63.68,24.11 63.54,22.61 63.35,21.6 63.07,20.13 63.07,20.12 63,19.9 63,18.35 63.55,17.8 63.94,17.8 64.04,17.69 64.04,17.06 DI3.3 65.06,17.82 65.24,17.82 65.41,17.64 65.41,17.39 65.77,17.03 66.02,17.03 66.17,16.89 LI1.3
USB20_P12: length 64
  IN1 w0.114: v2(229.1,36.16) 229.32,35.94 229.32,35.79 229.14,35.61 217.5,35.61 216.99,35.1 213.98,35.1 211.45,37.63 209.18,37.63 208.12,38.69 203.44,38.69 203.3,38.82 202.58,38.82 202.14,39.26 194.73,39.26 194.01,39.97 194.01,40.67 193.73,40.96 193.56,40.96 193.48,41.04 193.38,41.04 193.26,41.17 193.26,41.35 v2(193.3,41.39)
  BOTTOM w0.076: 179.97,32.91 179.96,32.9 179.96,32.87 179.63,32.54 178.68,32.54 178.56,32.67 178.29,32.67 178.21,32.59 178.21,32.49 178.29,32.41 UH2.AD2
  BOTTOM w0.102: v2(193.3,41.39) 193.03,41.11 192.62,41.11 190.92,39.41 187.53,39.41 186.69,38.56 186.69,38.13 185.51,36.95 184.76,36.95 184.3,36.49 182.05,36.49 180.91,35.35 180.91,33.85 179.97,32.91 ; LV22.4 230.1,38.15 229.1,37.15 v2(229.1,36.16)
USB20_P12_R: length 17.2
  BOTTOM w0.102: JCAM1.7 235.02,42.6 235.14,42.48 235.46,42.48 235.56,42.38 235.56,41.83 234.76,41.03 234.76,39.78 235.13,39.41 235.29,39.41 235.31,39.39 235.88,39.39 235.9,39.41 v4(237.16,39.41) 237.87,39.41 238.17,39.11 238.17,37.25 237.98,37.06 237.54,37.06 DV12.2 236.65,37.19 236.55,37.09 236.17,37.09 235.25,38 233.32,38 233.17,38.15 LV22.3
USB_EN#: length 366.1
  TOP w0.102: v2(293.28,35.37) 293.58,35.07 293.58,33.62 293.13,33.17 US2.4 ; v2(213.17,20.31) 213.24,20.39 213.24,23.61 214.36,24.73 214.36,26.79 v3(214.79,27.22) 215.3,27.73 216.75,27.73 RE29.1 217.43,27.04 218.5,27.04 219.01,26.53 219.01,25.59 219.26,25.34 UE1.13 ; v2(4.9,33.37) 5.28,33.75 JIO1.23
  IN3 w0.127: v2(293.28,35.37) 293,35.37 292.69,35.07 292.69,34.61 292.41,34.33 282.71,34.33 282.23,33.85 278.37,33.85 275.14,30.62 275.14,27.9 273.01,25.77 263.97,25.77 261.79,23.59 260.66,23.59 259.72,24.53 252.42,24.53 251.89,24 246.3,24 245.5,23.21 244.94,23.21 244.71,23.43 244.03,23.43 243.42,22.83 239.69,22.83 239.11,22.25 239.11,21.68 237.99,20.55 236.26,20.55 234.36,18.66 232.05,18.66 230.37,16.98 225.87,16.98 225.59,17.26 220.8,17.26 219.86,18.2 216.38,18.2 215.41,19.18 214.6,19.18 213.7,20.08 213.4,20.08 v2(213.17,20.31) 212.48,20.31 211.85,19.68 206.07,19.68 205.09,18.7 199.51,18.7 198.2,17.39 189.05,17.39 187.47,15.8 185.34,15.8 183.86,14.32 182.67,14.32 181.02,12.68 181.02,11.81 180.53,11.32 180.53,10.21 179.03,8.7 175.02,8.7 173.29,10.43 172.15,10.43 171.74,10.84 169.85,10.84 166.65,14.03 160.46,14.03 158.89,15.6 158.89,16.8 158.49,17.2 154.44,17.2 153.81,17.83 150.57,17.83 149.74,18.66 143.39,18.66 142.16,17.43 116.68,17.43 114.89,15.64 110.65,15.64 109.43,16.86 100.36,16.86 99.91,17.31 62.87,17.31 61.42,15.87 59.57,15.87 58.35,14.65 55.56,14.65 50.33,9.42 48.01,7.1 25.21,7.1 21.15,11.17 16.71,11.17 13.56,14.32 3.76,14.32 1.78,16.29 1.78,30.98 4.17,33.37 v2(4.9,33.37)
USB_OC0#: length 180.7
  TOP w0.102: v2(155.61,31.49) RH131.1 ; v2(288.02,42.1) 289.39,40.73 v1(290.08,40.73) 291.32,39.49 291.32,38.04 293.94,35.42 293.94,31.94 293.13,31.14 US2.3
  IN2 w0.127: v2(155.61,31.49) 153.81,29.68 153.81,25.31 155.66,23.45 156.17,23.45 156.23,23.39 156.84,23.39 156.98,23.25 156.99,23.25 158.23,22.01 158.23,21.4 159.14,20.49 161.25,20.49 162.57,19.17 164.2,19.17 165.08,18.28 168.89,18.28 169.32,17.86 170.74,17.86 171.22,17.37 171.22,14.49 171.95,13.76 178.47,13.76 180.2,15.48 180.64,15.48 183.38,18.22 186.72,18.22 187.79,19.29 191.35,19.29 191.86,19.8 194.32,19.8 195.97,21.45 198.18,21.45 199.45,22.72 207.05,22.72 207.65,23.33 212.55,23.33 212.6,23.38 212.61,23.38 214.31,25.09 218.35,25.09 220.06,26.8 220.06,27.69 221.32,28.95 230.52,28.95 231.27,29.69 247.47,29.69 247.47,29.7 247.68,29.7 250.26,32.27 253.6,32.27 254.01,32.67 254.01,34.29 255.89,36.17 255.9,36.17 256.42,36.69 257.75,36.69 258.69,37.63 258.69,38.43 259.02,38.76 261.9,38.76 263.14,40 268.43,40 268.79,39.64 275.42,39.64 276.62,40.83 286.75,40.83 v2(288.02,42.1)
  BOTTOM w0.089: UH2.AD43 157.99,32.19 157.61,31.81 155.93,31.81 v2(155.61,31.49)
USB_OC1#: length 164.3
  TOP w0.102: US1.13 283.44,38.56 283.27,38.73 283.27,39.23 v1(281.16,41.34) v2(276.62,41.34)
  IN2 w0.127: v2(156.02,32.55) 156.03,32.54 156.03,31.27 154.12,29.37 154.12,25.35 155.77,23.71 156.27,23.71 156.33,23.65 156.99,23.65 158.37,22.27 160.26,22.27 160.51,22.01 160.51,21.61 162.6,19.52 164.22,19.52 165.21,18.53 169.02,18.53 169.44,18.11 170.91,18.11 171.51,17.51 171.51,14.59 172.09,14.01 178.36,14.01 180.63,16.27 181.07,16.27 183.28,18.48 186.45,18.48 187.62,19.65 191.32,19.65 191.73,20.06 194.22,20.06 195.87,21.71 198.05,21.71 199.32,22.98 206.89,22.98 207.5,23.59 212.45,23.59 214.33,25.47 218.37,25.47 219.81,26.9 219.81,27.79 221.22,29.2 230.41,29.2 231.16,29.95 247.58,29.95 250.15,32.52 253.5,32.52 253.75,32.78 253.75,34.4 256.3,36.94 257.64,36.94 258.43,37.74 258.43,38.54 258.91,39.02 261.8,39.02 263.08,40.3 268.51,40.3 268.92,39.89 275.3,39.89 276.62,41.21 v2(276.62,41.34)
  BOTTOM w0.089: UH2.AD42 158.37,32.32 158.26,32.43 157.46,32.43 157.32,32.29 156.39,32.29 156.13,32.55 v2(156.02,32.55)
  BOTTOM w0.102: RH132.1 155.83,32.74 v2(156.02,32.55)
USB_OC2#: length 190.7
  TOP w0.102: v2(149.29,29) 149.29,29.36 149.81,29.88 149.81,32.36 150.06,32.61 150.06,34.14 v3(150.66,34.74) 154.54,34.74 154.74,34.54 RH135.1 155.13,34.2 155.74,33.59 158.91,33.59 160.06,32.45 160.06,31.89 v2(160.21,31.74) ; v2(4.89,34.06) 5.09,34.25 JIO1.24
  IN2 w0.127: v2(149.29,29) 148.74,29 147.47,27.73 141.54,27.73 141.21,27.4 117.56,27.4 117.18,27.02 109.66,27.02 108.16,28.51 68.16,28.51 67.65,28.01 60.89,28.01 v2(60.72,28.18)
  IN3 w0.127: v2(60.72,28.18) 60.49,27.96 60.49,26.08 57.62,23.21 57.62,22.29 54.95,19.62 52.59,19.62 47.89,14.92 41.64,14.92 41.06,14.34 36.82,14.34 35.9,15.26 27.7,15.26 27.52,15.43 24.59,15.43 24.36,15.66 23.43,15.66 22.16,16.93 20.03,16.93 14.11,22.85 14.11,32.76 13.16,33.7 5.25,33.7 v2(4.89,34.06)
  BOTTOM w0.102: UH2.AD39 v2(160.21,31.74)
USB_OC3#: length 3.4
  BOTTOM w0.089: UH2.AC44 157.47,32.71 157.33,32.57 156.63,32.57 156.21,32.99
  BOTTOM w0.102: 156.21,32.99 v1(155.81,33.39) 155.57,33.63 RH134.1
USB_OC4#: length 4.2
  BOTTOM w0.076: UH2.Y43 157.88,34.7 157.46,34.7 157.39,34.64 156.89,34.64 156.72,34.47 156.28,34.47 156.12,34.64
  BOTTOM w0.102: RP8.3 154.69,35.24 155.21,34.72 156.03,34.72 156.12,34.64
USB_OC5#: length 6.5
  TOP w0.102: v2(159.4,35.02) 158.39,35.02 157.24,33.87 156.75,33.87 156.3,34.33 156.02,34.33 155.99,34.31 v2(155.86,34.31)
  BOTTOM w0.089: UH2.Y41 159.11,34.74 v2(159.4,35.02)
  BOTTOM w0.102: RP8.4 154.68,34.74 155.09,34.33 155.84,34.33 v2(155.86,34.31)
USB_OC6#: length 3.9
  BOTTOM w0.076: UH2.W44 157.68,34.89 157.38,34.89 157.29,34.8 156.82,34.8 156.69,34.67 156.39,34.67 156.12,34.94 156.11,34.94 156.09,34.95
  BOTTOM w0.102: RP8.2 154.64,35.74 155.42,34.95 156.09,34.95
USB_OC7#: length 4.5
  BOTTOM w0.089: 155.2,35.68 155.56,35.32 v1(155.76,35.32) 156.24,35.32 156.4,35.48 156.73,35.48 156.89,35.32 157.33,35.32 157.44,35.21 157.91,35.21 158.15,34.98 UH2.W43
  BOTTOM w0.102: 155.2,35.68 154.64,36.24 RP8.1
USB_POWERSHARE_VBUS_EN: length 55.7
  TOP w0.102: RI51.2 279.28,34.46 280.4,34.46 280.45,34.51 v2(280.48,34.51) 280.65,34.69 281.68,34.69 281.94,34.43 US1.5 ; UE1.71 237.3,20.14 238.08,20.92 240.54,20.92 v1(240.94,21.32) 241.73,22.11 v2(242.02,22.11)
  IN2 w0.127: v2(280.48,34.51) 280.45,34.53 279.54,34.53 278.08,35.99 273.47,35.99 267.69,30.22 260.52,30.22 259.83,29.53 256.2,29.53 254.78,28.11 250.94,28.11 248.94,26.11 248.93,26.11 248.69,25.87 248.69,25.86 245.98,23.15 244.15,23.15 243.11,22.11 v2(242.02,22.11)
