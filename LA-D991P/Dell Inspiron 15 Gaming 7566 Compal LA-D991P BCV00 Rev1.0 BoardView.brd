# Allegro board Dell Inspiron 15 Gaming 7566 Compal LA-D991P BCV00 Rev1.0 BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on IN2 (solid shape): outline of 201 points within 295.46,35.91 307.49,46.07
GND on IN2 (solid shape): outline of 521 points within 44.56,33.56 57.5,44.34
GND on IN2 (solid shape): outline of 305 points within 0.25,0.25 309.42,134.55
GND on IN2 (solid shape): outline of 3081 points within 52.8,49.89 89.62,97.48
GND on IN2 (solid shape): outline of 24761 points within 150.96,74.54 212.23,133.09
GND on IN3 (solid shape): 177.56,17.26 177.56,15.1 177.3,14.85 173.7,14.85 172.6,15.94 172.6,16.76 173.21,17.36 177.45,17.36
GND on IN3 (solid shape): 269.63,44.19 269.63,40.38 269.25,40 265.06,40 264.8,40.25 264.8,43.68 265.57,44.44 269.38,44.44
GND on IN3 (solid shape): 281.44,46.98 281.44,42.92 281.7,42.66 281.7,42.41 281.06,41.77 278.39,41.77 277.63,42.54 277.63,46.47 278.27,47.11 281.31,47.11
GND on IN3 (solid shape): 179.97,72.91 179.97,69.61 179.66,69.31 175.47,69.31 175.35,69.43 175.35,72.58 175.83,73.07 179.81,73.07
GND on IN3 (solid shape): 187.21,46.35 187.21,42.38 186.85,42.03 182.38,42.03 182,42.41 182,42.79 182.13,42.92 182.51,42.92 182.64,43.04 182.64,46.35 183.27,46.98 186.57,46.98
GND on IN3 (solid shape): 224.55,38.09 224.55,36.06 224.42,35.93 219.92,35.93 219.82,36.03 219.82,36.49 219.97,36.64 219.97,38.14 220.2,38.37 221.9,38.37 222.01,38.47 224.16,38.47
GND on IN3 (solid shape): 139.2,124.6 139.2,123.74 139.96,122.98 139.96,118.86 139.71,118.61 137.42,118.61 137.17,118.86 137.17,121.33 136.66,121.83 136.66,124.45 137.07,124.86 138.95,124.86
GND on IN3 (solid shape): 83.83,119.75 83.83,114.16 83.45,113.78 77.35,113.78 75.45,111.88 75.45,105.78 75.07,105.4 71.76,105.4 71.38,105.78 71.38,107.31 70.49,108.19 70.49,112.39 72.02,113.91 72.02,119.62 72.27,119.88 83.7,119.88
GND on IN3 (solid shape): 204.35,71.11 204.35,68.7 204.1,68.44 201.3,68.44 201.05,68.7 201.05,69.84 200.92,69.97 198.76,69.97 198.64,69.84 198.64,68.7 198.38,68.44 195.21,68.44 194.83,68.82 194.83,71.62 194.95,71.75 203.72,71.75
GND on IN3 (solid shape): 298.56,25.18 298.07,24.34 298.81,23.72 306.36,23.72 307.4,23.72 307.57,23.64 307.65,23.47 307.65,22.53 307.65,21.86 293.38,21.86 292.72,22.52 292.72,23.1 293.35,23.74 293.35,25.01 293.63,25.29 298.56,25.29
GND on IN3 (solid shape): outline of 143 points within 296.71,37.72 307.49,44.42
GND on IN3 (solid shape): 309.17,95.49 309.34,95.41 309.42,95.24 309.42,94.07 309.32,93.7 309.05,93.43 308.35,93.01 307.9,92.55 307.74,91.93 307.74,84.48 307.83,84 308.1,83.6 309.26,82.44 309.32,82.36 309.34,82.26 309.34,81.92 309.26,81.75 309.09,81.67 303.16,81.67 302.67,81.3 302.91,80.73 302.91,66.61 302.67,66.04 303.16,65.67 309.09,65.67 309.26,65.59 309.34,65.42 309.34,64.48 309.32,64.38 309.26,64.3 307.71,62.75 307.54,62.5 307.49,62.21 307.49,58.67 307.41,58.5 307.24,58.42 298.81,58.42 298.23,58.15 298.07,57.52 297.57,57.52 296.94,57.52 296.66,57.8 296.66,59.73 297.01,60.09 299.4,60.09 301.03,61.71 301.03,64.23 299.63,65.62 299.63,66.87 299.93,67.17 302.22,67.17 302.4,67.35 302.4,79.95 302.14,80.2 299.93,80.2 299.6,80.53 299.6,81.32 301.08,82.79 303.67,82.79 305.83,84.95 305.83,86.86 307.23,88.26 307.23,91.93 307.23,92.04 307.23,92.62 305.83,94.02 305.83,95.49
GND on IN3 (solid shape): outline of 286 points within 92.72,116.7 130.95,128.32
GND on IN3 (solid shape): outline of 304 points within 0.25,0.25 309.42,134.55
GND on GND1: outline of 316 points within 0.26,0.26 309.41,134.55 ; 1 cut-out
GND on VCC: outline of 101 points within 287.7,21.22 309.42,95.49
GND on VCC: outline of 135 points within 141.74,41.65 229.09,72.25
GND on VCC: outline of 277 points within 131.58,75.94 213.84,134.53
GND on VCC: 182.3,46.73 187.92,46.73 188.48,46.18 188.48,42.28 188.48,42.28 181.66,42.28 181.36,42.58 181.36,45.79
GND on VCC: outline of 441 points within 55,21.33 140.47,81.65
GND on GND2: outline of 312 points within 0.26,0.26 309.41,134.55 ; 2 cut-outs
VBATT on TOP (solid shape): 44,18.79 44,15.79 43.7,15.48 41.28,15.48 41.03,15.74 41.03,18.79 41.16,18.91 43.88,18.91
VBATT on BOTTOM (solid shape): 41.28,17.83 41.33,17.78 41.33,17.41 41.67,17.08 42,17.41 42,17.78 42.05,17.83 42.05,18.79 43.9,18.79 43.93,18.76 43.93,17.16 44.08,17.01 44.08,14.34 43.82,14.09 41.67,14.09 40.9,14.85 40.9,15.74 40.52,16.12 40.01,16.12 39.63,16.5 39.63,18.02 40.4,18.79 41.28,18.79
VCCGT_B+ on TOP (solid shape): 99.83,131.3 99.83,127.37 99.7,127.24 95.26,127.24 95.01,127.5 95.01,130.76 95.87,131.63 99.5,131.63
VCCGT_B+ on TOP (solid shape): 64.23,119.81 64.46,119.81 64.46,119.3 65.17,119.3 65.17,119.81 65.66,119.81 65.66,119.3 66.37,119.3 66.37,119.81 68.27,119.81 68.34,119.75 71.13,119.75 72.02,118.86 72.02,114.8 71.64,114.42 68.34,114.42 68.21,114.54 68.21,115.43 67.95,115.69 66.3,115.69 66.05,115.43 66.05,114.04 65.92,113.91 64.4,113.91 63.87,114.44 63.87,119.73 63.96,119.82 64.23,119.82
VCCGT_B+ on BOTTOM (solid shape): 72.15,118.02 72.15,112.26 72.02,112.13 70.88,112.13 70.88,113.53 70.75,113.66 69.73,113.66 69.61,113.78 69.61,114.04 69.35,114.29 68.34,114.29 68.21,114.42 68.21,115.31 68.08,115.43 66.33,115.43 66.33,115.15 65.92,114.75 64.48,114.75 64.14,115.08 64.14,118.13 64.58,118.56 71.61,118.56
VCCGT_B+ on BOTTOM (solid shape): 99.83,130.67 99.83,129.2 99.68,129.05 99.68,128.79 99.83,128.64 99.83,127.37 99.59,127.13 99.56,127.14 99.43,127.15 99.3,127.12 99.29,127.12 98.98,127.12 98.97,127.12 98.82,127.16 98.66,127.12 98.65,127.12 98.34,127.12 98.33,127.12 98.18,127.16 98.03,127.12 98.02,127.12 94.62,127.12 94.5,127.24 94.5,128.26 94.62,128.39 96.02,128.39 96.15,128.51 96.15,128.83 96.2,128.93 96.22,129.05 96.22,129.47 96.91,130.17 96.91,131.18 97.16,131.44 99.07,131.44
VCCGT_B+ on IN1 (solid shape): outline of 1112 points within 64.27,114.8 99.96,132.71
VCCST on TOP (solid shape): 132.24,96.1 132.24,95.77 132.02,95.31 132.51,95.18 132.55,95.13 132.6,95.08 132.6,93.34 132.47,93.21 131.58,93.21 131.5,93.29 131.5,94.14 131.41,94.23 131.19,94.23 130.82,94.61 130.82,95.62 130.57,95.88 130.57,96.13 130.69,96.26 132.09,96.26
VCCSTG on BOTTOM (solid shape): 136.06,100.46 136.23,100.46 136.4,100.29 136.4,97.68 135.19,96.46 135.19,96.18 134.97,95.96 134.57,95.96 134.42,96.11 134.42,97.89 135.01,98.48 135.01,100.28 135.19,100.46 136.06,100.46
VIN on TOP (solid shape): 23.2,41.85 23.2,37.99 22.97,37.76 18.93,37.76 18.22,37.05 17.49,37.05 17.47,37.07 17.18,37.07 17.08,37.18 15.96,37.18 15.81,37.33 15.81,39.66 15.95,39.81 16.67,40.57 16.6,41.62 16.6,41.77 17.13,42.31 22.74,42.31
VIN on BOTTOM (solid shape): 23.28,42.09 23.28,37.99 23,37.71 19.31,37.71 18.81,37.2 18.17,37.2 17.79,36.82 17.7,36.79 17.63,36.85 17.1,36.98 17.06,36.44 17.09,36.36 17.05,36.29 16.9,35.86 17.28,35.63 17.28,34.53 17.15,34.41 16.52,34.41 16.39,34.53 16.39,35.42 16.27,35.55 15.25,35.55 15.12,35.68 15.12,39 15.15,39.06 15.17,39.12 15.17,39.14 15.78,39.75 16.59,40.39 16.68,41.43 17.66,42.41 22.96,42.41
+AMP on TOP (solid shape): outline of 310 points within 259,13.96 272.11,20.67
+AMP on BOTTOM (solid shape): 259.67,20.51 259.67,19.9 259.85,19.73 259.85,18.91 260.11,18.66 261.38,18.66 261.45,18.58 261.45,18 261.35,17.9 261.12,17.9 261.04,17.91 260.99,17.92 259.28,17.92 258.93,17.57 258.51,17.57 258.49,17.58 258.39,17.58 258.28,17.69 258.28,20.23 258.51,20.46 259.12,20.46 259.24,20.59 259.37,20.59 259.39,20.62 259.57,20.62
+AMP on BOTTOM (solid shape): 271.39,19.13 271.39,18.22 271.26,18.09 271.12,18.09 271.06,18.1 270.98,18.11 270.9,18.09 267.61,18.09 267.44,17.92 266.54,17.92 266.53,17.92 265.69,17.92 265.62,18 265.62,19.07 265.72,19.17 266.61,19.17 266.73,19.29 266.81,19.29 267.76,19.29 267.93,19.12 269.36,19.12 269.7,19.47 271.05,19.47
+CHGRTC on BOTTOM (solid shape): 152.54,18.6 152.54,17.77 153.3,17.01 153.3,16.82 152.28,16.82 152.28,17.2 151.77,17.71 151.77,18.6 151.9,18.72 152.41,18.72
+DC_IN on BOTTOM (solid shape): outline of 217 points within 5.29,34.41 16.27,42.64
+EDPVDD on TOP (solid shape): outline of 139 points within 60.49,33.52 65.22,42.51
+EDPVDD on BOTTOM (solid shape): 62.11,34.66 63.26,34.66 63.38,34.53 63.38,33.52 63.26,33.39 62.74,33.39 62.69,33.39 61.58,33.39 61.57,33.39 61.1,33.39 60.84,33.65 60.84,34.53 61.1,34.79 61.99,34.79
+FB_PLLAVDD on BOTTOM (solid shape): 149.49,106.67 149.49,105.4 149.74,105.15 149.74,100.07 149.62,99.94 148.22,99.94 147.96,100.19 147.96,106.29 148.47,106.8 149.36,106.8
+FB_PLLAVDD on IN1 (solid shape): outline of 260 points within 172.73,89.14 177.05,97.27
+FB_PLLAVDD on IN3 (solid shape): outline of 1562 points within 147.71,94.94 176.03,103.5
+GPU_CORE on TOP (solid shape): 185.3,71.62 185.3,68.9 186.32,67.88 186.32,63.46 186.09,63.24 175.03,63.24 174.95,63.27 174.93,63.34 174.73,63.68 174.35,63.64 174.28,63.62 174.21,63.66 173.96,63.78 173.7,63.69 173.63,63.67 173.56,63.7 173.13,63.77 172.96,63.36 172.94,63.28 172.86,63.24 171.9,63.24 168.48,59.81 147.71,59.81 147.33,60.19 147.33,66.79 147.46,66.92 149.11,66.92 149.62,67.43 149.62,70.48 150.25,71.11 153.35,71.11 158.12,71.11 158.35,71.11 161.17,71.11 161.48,71.41 165.36,71.41 165.88,70.89 167.59,70.89 167.78,70.7 167.78,68.06 168.03,67.81 177.81,67.81 178.8,68.8 179.59,68.8 180.25,69.46 180.25,71.75 180.63,72.13 184.79,72.13
+GPU_CORE on TOP (solid shape): outline of 783 points within 163.1,76.65 175.4,96.1
+GPU_CORE on BOTTOM (solid shape): 185.56,70.6 185.56,62.98 184.92,62.35 176.54,62.35 175.08,63.81 173.35,63.81 173.3,63.81 173.25,63.81 168.98,63.81 168.73,63.55 168.73,61.9 168.41,61.59 166.38,61.59 165.36,62.6 149.11,62.6 148.47,61.97 147.71,61.97 146.44,63.24 144.28,63.24 144.03,63.49 144.03,67.68 144.15,67.81 146.44,67.81 149.95,71.32 151.11,71.32 151.15,71.36 151.89,71.36 151.97,71.28 155.41,71.28 155.49,71.36 159.07,71.36 159.09,71.36 159.94,71.36 160.89,71.36 164.31,71.36 168.03,71.36 168.67,70.73 168.67,68.57 169.17,68.06 173.35,68.06 173.56,67.99 173.76,68.06 175.04,68.06 175.37,67.73 177.54,67.73 178.66,68.85 179.66,68.85 179.69,68.87 179.72,68.87 180.15,69.3 180.15,69.33 180.24,69.42 180.24,70.23 181.49,71.49 184.67,71.49
+GPU_CORE on IN1 (solid shape): 168.63,69.68 168.63,63.34 168.64,63.33 168.64,61.99 168.39,61.74 147.71,61.74 147.33,62.12 147.33,67.44 147.39,67.49 147.39,68.78 149.36,70.75 160.92,70.75 161.66,71.49 166.81,71.49
+GPU_CORE on IN1 (solid shape): 187.18,69.59 187.18,64.35 185.66,62.83 180.6,62.83 175.83,67.6 175.83,67.82 175.88,67.91 175.98,67.91 176.2,67.86 176.4,67.95 176.46,67.97 176.53,67.95 176.78,67.86 177.02,67.96 177.09,67.99 177.16,67.96 177.66,67.96 177.66,68.46 177.63,68.53 177.66,68.6 177.75,68.78 177.74,68.98 179.75,68.98 180.27,69.5 180.27,71.07 180.49,71.29 185.48,71.29
+GPU_CORE on IN2 (solid shape): outline of 8117 points within 147.34,59.68 186.7,96.21
+GPU_CORE on IN3 (solid shape): 165.94,71.15 166.75,71.15 168.09,69.81 168.09,68.23 168.53,67.79 168.53,67.38 168.66,67.25 168.66,63.21 168.75,63.12 168.75,63.1 169.15,62.71 169.15,61.25 167.4,59.5 147.69,59.5 146.03,61.15 146.03,68.95 147.97,70.88 156.93,70.88 156.97,70.92 159.38,70.92 159.77,71.31 165.77,71.31
+GPU_CORE on IN3 (solid shape): 181.49,72.46 181.85,72.15 182.2,72.46 182.21,72.51 182.38,72.51 182.63,72.4 182.88,72.51 183.27,72.51 183.52,72.4 183.77,72.51 185.18,72.51 187.61,70.07 187.61,63.82 187.03,63.24 180.3,63.24 175.57,67.96 175.57,69.05 175.71,69.05 175.79,69.01 175.81,68.93 175.82,68.75 175.9,68.6 175.93,68.53 175.9,68.46 175.9,67.97 176.4,67.95 176.46,67.97 176.53,67.95 176.78,67.86 177.02,67.96 177.09,67.99 177.16,67.96 177.66,67.96 177.66,68.46 177.63,68.53 177.66,68.6 177.72,68.68 177.75,68.77 177.76,68.84 177.75,68.92 179.73,68.92 180.29,69.48 180.29,72.31 180.49,72.51 181.49,72.51
+GPU_CORE on IN3 (solid shape): outline of 3960 points within 157.72,79.61 174.61,95.27
+GPU_CORE on VCC: outline of 160 points within 143.77,61.46 186.45,95.49
+INV_PWR_SRC on TOP (solid shape): outline of 94 points within 59.62,20.06 63.76,25.29
+INV_PWR_SRC on BOTTOM (solid shape): 63.33,25.07 63.33,24.12 63.28,23.63 63,23.36 61.97,23.36 60.92,24.4 60.92,24.83 61.22,25.14 63.26,25.14
+LAN_IO on TOP (solid shape): outline of 1030 points within 281.54,40.76 290.69,50.59
+LAN_IO on BOTTOM (solid shape): 285.12,43.03 285.12,41.11 285.02,41.01 284.35,41.01 284.3,41.06 284.3,41.86 284.54,42.1 284.76,42.1 284.9,42.24 284.9,43.02 284.97,43.09 285.06,43.09
+LAN_IO on BOTTOM (solid shape): 290.61,47.82 290.61,47.49 290.51,47.39 290.03,47.39 289.95,47.31 289.95,45.84 289.82,45.71 289.44,45.71 289.32,45.84 289.32,45.92 289.33,45.93 289.33,47.06 289.38,47.11 289.38,47.32 289.38,47.32 289.38,47.83 289.49,47.93 290.5,47.93
+LAN_IO on BOTTOM (solid shape): 283.35,51.62 283.35,49.01 283.5,48.86 283.5,46.42 283.73,46.19 284.34,46.19 284.39,46.14 284.39,46.04 284.34,45.99 284.17,45.99 284.17,45.99 283.47,45.99 283.38,46.08 283.31,46.08 282.88,46.51 282.88,46.89 281.9,47.87 281.8,47.87 281.51,48.16 281.51,48.76 281.82,49.08 281.82,49.9 281.44,50.28 280.24,50.28 280.04,50.47 280.04,51.68 280.24,51.87 283.09,51.87
+LAN_VDD on BOTTOM (solid shape): 288.03,47.71 288.03,46.78 287.85,46.6 287.84,46.6 287.67,46.48 287.56,46.31 287.54,46.29 287.36,46.29 287.28,46.37 287.28,47.21 287.37,47.3 287.38,47.3 287.52,47.38 287.6,47.52 287.6,47.53 287.84,47.77 287.97,47.77
+LAN_VDD on BOTTOM (solid shape): 285.52,43.04 285.52,42.23 285.62,42.13 285.62,40.72 285.62,40.72 285.62,40.43 285.54,40.35 282.15,40.35 282.13,40.38 282.13,41.34 282.42,41.62 282.42,41.66 283.75,42.99 284.09,42.99 284.19,43.09 284.67,43.09 284.72,43.04 284.72,42.26 284.66,42.2 284.47,42.2 284.16,41.89 284.16,41.05 284.3,40.91 284.76,40.91 284.77,40.91 285.02,40.91 285.07,40.91 285.16,40.99 285.23,41.07 285.23,42.14 285.31,42.22 285.31,43.04 285.37,43.1 285.47,43.1
+LAN_VDD on IN2 (solid shape): outline of 654 points within 282.46,41.27 288.81,47.84
+PLLVDD on TOP (solid shape): 163.59,82.57 163.59,82.16 163.46,82.03 161.76,82.03 161.73,82.06 161.73,82.62 161.76,82.64 163.51,82.64
+SP_PLLVDD on TOP (solid shape): 161.63,82.51 161.63,81.8 161.73,81.7 162.75,81.7 162.87,81.57 162.87,81.07 162.75,80.94 162.72,80.96 162.51,80.99 162.32,80.89 162.12,80.89 161.7,80.89 161.4,80.59 161.4,80.17 161.5,80.07 161.5,79.19 162.01,78.68 162.33,78.68 162.35,78.66 162.44,78.61 162.54,78.58 162.58,78.57 162.58,77.94 162.49,77.85 161.57,77.85 160.92,78.5 159.78,78.5 159.62,78.35 158.15,78.35 158.12,78.37 158.12,78.55 158.23,78.65 158.23,79.21 158.73,79.21 158.91,79.39 158.91,79.97 159.06,80.13 159.88,80.13 160.59,80.84 160.59,81.19 160.66,81.27 160.66,82.51 160.79,82.64 161.5,82.64
+VDISPLAY_VCC on BOTTOM (solid shape): outline of 151 points within 295.83,63.36 301.05,70.09
+VGA_B+ on TOP (solid shape): outline of 416 points within 168.16,53.58 202.57,62.98
+VGA_B+ on BOTTOM (solid shape): 199.78,64.76 199.78,64.13 199.65,64 199.15,64 198.89,63.74 198.89,62.73 199.27,62.35 200.92,62.35 201.05,62.47 201.05,64.63 201.3,64.89 205.37,64.89 205.5,64.76 205.5,64.13 205.37,64 204.73,64 204.61,63.87 204.61,61.46 203.97,60.82 195.95,60.82 195.08,60.82 194.57,61.33 194.57,64.38 195.08,64.89 199.65,64.89
+VGA_B+ on BOTTOM (solid shape): outline of 156 points within 146.44,40.88 170.57,56.25
+VGA_B+ on IN2 (solid shape): outline of 1207 points within 148.85,50.66 170.95,61.59
-DC_IN on BOTTOM (solid shape): outline of 370 points within 5.53,25.12 16.27,34.15
ACDRV_CHG on TOP (solid shape): 26.8,37.89 26.81,37.89 27.13,37.57 27.13,37.41 26.92,37.2 26.78,37.2 26.5,36.91 26.5,35.88 26.48,35.86 26.48,35.16 26.46,35.15 25.78,35.15 25.67,35.27 25.67,37.56 25.84,37.73 25.84,37.73 26.1,38 26.69,38
ACDRV_CHG on BOTTOM (solid shape): 27.19,37.46 28.2,37.46 28.28,37.38 28.28,37.3 28.2,37.23 26.45,37.23 26.14,37.54 26.14,37.75 26.36,37.98 26.67,37.98
AUD_AGND on GND1: outline of 81 points within 276.68,7.36 309.79,30.6
AUD_AGND on VCC: 298.69,7.36 297.98,8.06 297.79,8.06 296.47,9.39 296.47,9.58 294.78,11.27 294.78,12.67 293.99,13.45 293.1,13.45 292.47,14.09 291.71,14.09 288.46,17.34 286.81,17.34 286.05,18.13 279.25,18.13 278.9,17.77 277.04,17.77 276.68,18.13 276.68,20.14 276.98,20.44 278.31,20.44 278.77,20.9 278.77,21.86 279.01,22.09 283.45,22.09 283.98,22.62 283.98,25.67 284.09,25.77 285.36,25.77 286.5,26.91 287.26,26.91 287.73,27.38 287.73,29.56 287.2,30.09 285.65,30.09 284.77,29.2 283.88,29.2 283.09,28.42 283.09,27.53 282.99,27.42 282.39,27.42 282.39,29.92 282.56,30.09 284.09,30.09 284.6,30.6 289.08,30.6 290.08,29.6 290.08,24.27 292.34,22.01 292.34,21.27 292.89,20.72 295.95,20.72 296.54,21.33 307.67,21.33 307.74,21.14 307.87,20.98 309.71,19.14 309.77,19.06 309.79,18.96 309.79,17.82 309.71,17.65 309.54,17.58 304.19,17.58 304.19,18.12 303.24,19.08 302.28,18.12 302.28,17.58 299.74,17.58 299,16.95 299.48,16.11 299.48,11.13 299,10.29 299.74,9.66 309.54,9.66 309.71,9.59 309.79,9.42 309.79,8.28 309.77,8.18 309.71,8.1 308.97,7.36
AUD_AGND on GND2: 260.56,19.9 260.28,20.18 260.28,21.05 259.75,21.58 259.11,21.58 259.01,21.48 257.39,21.48 256.78,20.87 256.12,20.87 255.99,21 255.99,22.01 257.54,23.56 257.54,23.84 257.59,23.89 259.14,23.89 259.32,23.71 259.32,22.65 261.15,20.82 261.3,20.82 261.48,20.64 261.48,19.98 261.4,19.9
AUD_AGND on GND2: outline of 81 points within 276.68,7.36 309.79,30.6
AUD_HP1_JACK_L on TOP (solid shape): 287.53,25.76 287.53,25.35 287.41,25.24 284.06,25.24 283.96,25.34 283.96,25.39 284.01,25.44 285.99,25.44 286.47,25.92 287.36,25.92
AUD_HP1_JACK_L on TOP (solid shape): 296.75,13.45 296.75,12.82 296.7,12.77 296.67,12.78 296.57,12.81 296.48,12.82 295.79,12.82 295.67,12.8 295.56,12.76 295.55,12.75 295.48,12.75 295.35,12.88 295.35,13.39 295.48,13.52 296.68,13.52
AUD_HP1_JACK_L on IN1 (solid shape): 295.97,13.33 295.97,13.07 295.77,12.87 294.98,12.87 294.27,13.58 293.71,13.58 293.66,13.63 293.66,14.47 293.76,14.57 294.73,14.57
AUD_HP1_JACK_L on IN1 (solid shape): 287.79,25.41 287.79,24.25 287.58,24.04 287,24.04 286.78,24.27 286.77,24.3 286.75,24.33 286.75,25.01 286.32,25.44 286.32,25.69 286.53,25.91 287.28,25.91
AUD_HP1_JACK_L1 on TOP (solid shape): 297.82,15.23 297.82,14.46 297.72,14.21 297.82,13.96 297.82,13.83 297.72,13.58 297.82,13.33 297.82,12.18 297.57,11.93 297.19,11.93 297.04,12.08 297.04,15.23 297.11,15.31 297.75,15.31
AUD_HP1_JACK_R on TOP (solid shape): 287.28,26.53 287.28,26.28 287.16,26.15 286.27,26.15 285.76,25.64 284.01,25.64 283.93,25.72 283.93,25.8 283.98,25.85 285.25,25.85 286.06,26.66 287.16,26.66
AUD_HP1_JACK_R on IN1 (solid shape): 293.79,16.65 293.79,15.31 293.63,15.15 293.25,15.15 292.77,15.64 292.77,16.68 293.76,16.68
AUD_HP1_JACK_R on IN1 (solid shape): 288.92,26.24 288.92,25.87 287.84,25.87 287.59,26.13 286.27,26.13 286.12,26.28 286.12,26.48 286.55,26.91 288.25,26.91
AUD_HP1_JACK_R1 on TOP (solid shape): 291.98,14.21 291.86,14.09 291.45,14.09 291.37,14.16 291.37,15.48 290.92,15.94 289.87,15.94 289.85,15.92 289.75,16.02 289.75,16.53 289.8,16.58 291.98,16.58
AUD_PORTA_L_R_B on TOP (solid shape): 296.83,18.02 296.83,14.82 296.71,14.7 296.22,14.7 296.07,14.85 296.07,16.58 295.44,17.21 295.44,18.1 295.74,18.41 296.45,18.41
AUD_PORTA_R_R_B on TOP (solid shape): 296.12,20.51 296.12,19.83 296,19.7 294.27,19.7 293.76,19.19 293.76,16.93 292.82,15.99 292.31,15.99 292.24,16.07 292.24,20.21 292.74,20.72 295.92,20.72
AUD_PORTA_R_R_B on BOTTOM (solid shape): 293.51,20.61 293.51,19.73 292.74,18.96 292.01,18.96 291.78,19.19 291.78,19.77 291.78,20.44 292.06,20.72 293.41,20.72
AUD_SPK_L+ on TOP (solid shape): 281.67,30.27 281.67,27.4 281.62,27.35 281.47,27.35 281.39,27.42 281.39,28.39 281.2,28.58 281.2,30.28 281.29,30.37 281.57,30.37
AUD_SPK_L+ on TOP (solid shape): 276.5,17.58 276.5,16.44 276.31,16.25 275.6,16.25 275.6,17.14 275.37,17.36 275.37,17.69 275.45,17.77 276.09,17.77 276.1,17.78 276.3,17.78
AUD_SPK_L+ on IN3 (solid shape): 276.11,19.29 276.11,18.02 276.49,17.64 276.49,17.39 276.36,17.26 275.48,17.26 275.09,17.65 275.09,19.29 275.22,19.42 275.98,19.42
AUD_SPK_L+ on IN3 (solid shape): 281.75,30.37 281.75,27.55 281.62,27.42 280.73,27.42 280.48,27.68 280.48,28 281.26,28.79 281.26,30.34 281.37,30.44 281.67,30.44
AUD_SPK_L+_C on TOP (solid shape): 302.7,6.57 302.7,4.92 302.83,4.79 302.83,4.18 302.6,3.95 302.08,3.95 301.95,4.08 301.95,4.83 302.07,4.94 302.07,6.54 302.22,6.7 302.57,6.7
AUD_SPK_L+_C on TOP (solid shape): 275.05,17.63 275.05,17.3 275.35,17.01 275.35,16.27 275.35,16.12 275.73,15.74 275.73,14.85 275.8,14.85 275.8,14.82 276.26,14.36 276.42,14.25 276.62,14.21 276.87,14.21 276.87,13.07 276.74,12.94 275.61,12.94 274.46,14.09 274.46,17.57 274.66,17.77 274.91,17.77
AUD_SPK_L+_C on IN3 (solid shape): 277.12,14.21 277.12,13.2 277.94,12.39 277.94,11.52 277.91,11.5 277.35,11.5 276.13,12.72 276.13,14.19 276.29,14.34 277,14.34
AUD_SPK_L+_C on IN3 (solid shape): 302.78,4.89 302.78,3.29 302.4,2.91 300.9,2.91 300.75,3.06 300.75,3.77 300.92,3.95 301.71,3.95 301.86,4.1 301.86,4.59 302.32,5.04 302.63,5.04
AUD_SPK_L- on TOP (solid shape): 277.89,17.64 277.89,17.11 277.89,16.35 277.77,16.24 276.88,16.24 276.77,16.35 276.77,17.64 276.9,17.77 277.76,17.77
AUD_SPK_L- on TOP (solid shape): 281.04,30.34 281.04,28.54 281.21,28.36 281.21,27.45 281.14,27.37 281.09,27.37 281.01,27.45 281.01,28.29 280.83,28.46 280.83,29.15 280.55,29.43 280.55,30.34 280.65,30.44 280.93,30.44
AUD_SPK_L- on IN3 (solid shape): 280.99,30.36 280.99,28.91 280.32,28.23 279.97,28.23 279.79,28.41 279.79,29.02 279.94,29.17 280.3,29.17 280.55,29.43 280.55,30.24 280.76,30.44 280.91,30.44
AUD_SPK_L- on IN3 (solid shape): 277.89,17.64 277.89,16.56 277.32,15.99 274.84,15.99 274.71,16.12 274.71,16.88 274.84,17.01 276.47,17.01 276.74,17.28 276.74,17.64 276.87,17.77 277.76,17.77
AUD_SPK_L-_C on TOP (solid shape): 303.72,6.59 303.72,5.01 303.97,4.76 303.97,4.13 303.77,3.93 303.26,3.93 303.08,4.1 303.08,6.52 303.26,6.7 303.62,6.7
AUD_SPK_L-_C on TOP (solid shape): 279.16,17.01 279.16,15.74 278.77,15.36 278.77,15.29 278.71,15.22 278.6,14.92 278.75,14.64 278.77,14.63 278.77,14.6 279.03,14.34 279.03,13.2 278.77,12.94 277.38,12.94 277.12,13.2 277.12,14.34 277.81,15.03 277.81,15.92 278.14,16.25 278.14,17.01 278.27,17.14 279.03,17.14
AUD_SPK_L-_C on IN3 (solid shape): 304.1,4.56 304.1,3.95 304,3.85 303.29,3.85 303.08,4.05 303.08,4.46 303.1,4.47 303.1,4.96 303.13,4.99 303.67,4.99
AUD_SPK_L-_C on IN3 (solid shape): 279.23,14.21 279.23,13.48 279.38,13.33 279.71,13.33 279.84,13.2 279.84,12.36 279.77,12.28 278.83,12.28 278.22,12.89 278.22,14.29 278.39,14.47 278.98,14.47
AUD_SPK_R+ on TOP (solid shape): 271.66,17.9 271.66,16.42 271.49,16.25 270.77,16.25 270.77,17.97 270.8,18 271.57,18
AUD_SPK_R+ on TOP (solid shape): 279.79,30.19 279.79,29.25 280.4,28.64 280.4,27.45 280.35,27.4 280.27,27.4 280.22,27.45 280.22,28.34 279.33,29.23 279.33,30.24 279.49,30.39 279.59,30.39
AUD_SPK_R+ on IN1 (solid shape): 279.82,30.27 279.82,29.42 279.09,28.69 278.5,28.69 278.37,28.82 278.37,29.48 279.28,30.39 279.69,30.39
AUD_SPK_R+ on IN1 (solid shape): 271.54,19.95 271.54,17.74 271.54,17.74 271.7,17.58 271.7,17.22 271.56,17.08 271,17.08 270.7,17.39 270.71,17.42 270.74,17.61 270.67,17.78 270.67,18 270.52,18.15 270.52,19.83 270.82,20.13 271.36,20.13
AUD_SPK_R+_C on TOP (solid shape): 300.7,6.52 300.7,4.92 300.57,4.79 300.57,4.46 300.34,4.23 299.58,4.23 299.43,4.38 299.43,5.86 300.21,6.64 300.57,6.64
AUD_SPK_R+_C on TOP (solid shape): 270.52,17.01 270.52,16.14 270.89,15.77 270.89,15.03 271.54,14.38 271.71,14.21 271.99,14.21 272.12,14.09 272.12,13.07 271.97,12.92 270.84,12.92 270.83,12.93 270.56,12.93 269.05,14.44 269.05,14.98 269.25,15.18 269.25,16.75 269.74,17.25 269.77,17.24 269.84,17.24 269.92,17.26 270.27,17.26
AUD_SPK_R+_C on IN1 (solid shape): 272.5,13.93 272.5,11.52 272.42,11.45 271.66,11.45 271.26,11.85 271.26,13.81 271.61,14.16 272.27,14.16
AUD_SPK_R+_C on IN1 (solid shape): 300.54,4.71 300.54,4.23 300.21,3.9 298.51,3.9 298.33,4.08 298.33,4.79 298.49,4.94 300.31,4.94
AUD_SPK_R- on TOP (solid shape): 272.93,18.27 272.93,16.25 272.91,16.22 272.04,16.22 271.92,16.35 271.92,17.94 272.33,18.36 272.84,18.36
AUD_SPK_R- on TOP (solid shape): 280.4,30.34 280.4,29.33 280.71,29.02 280.71,28.34 280.81,28.23 280.81,27.45 280.73,27.37 280.68,27.37 280.63,27.42 280.63,28.13 280.53,28.23 280.53,28.82 279.94,29.4 279.94,30.34 280.04,30.44 280.3,30.44
AUD_SPK_R- on IN1 (solid shape): 280.43,30.37 280.43,27.78 280.01,27.36 279.09,27.36 278.7,27.75 279.97,29.02 279.97,30.29 280.12,30.44 280.35,30.44
AUD_SPK_R- on IN1 (solid shape): 273.59,19.01 273.52,18.94 273.24,18.94 272.93,18.63 272.93,17.52 272.68,17.26 272.37,17.26 271.79,17.85 271.79,18.94 272.65,19.8 273.59,19.8
AUD_SPK_R-_C on TOP (solid shape): 301.69,6.54 301.69,4.89 301.7,4.88 301.7,4.22 301.43,3.95 300.97,3.95 300.82,4.1 300.82,4.69 301.05,4.92 301.05,6.52 301.2,6.67 301.56,6.67
AUD_SPK_R-_C on TOP (solid shape): 274.2,17.01 274.2,13.54 274.1,13.43 274.1,13.12 273.89,12.91 272.74,12.91 272.37,13.27 272.37,14.29 272.91,14.83 272.91,15.86 273.19,16.14 273.19,17.14 274.08,17.14
AUD_SPK_R-_C on IN1 (solid shape): 301.71,5.63 301.71,4.21 301.56,4.05 301,4.05 300.8,4.26 300.8,4.82 300.7,4.92 300.7,5.93 300.87,6.11 301.23,6.11
AUD_SPK_R-_C on IN1 (solid shape): 274.24,13.99 274.24,12.98 274.41,12.82 274.63,12.82 274.69,12.77 274.69,11.83 274.63,11.78 273.9,11.78 273.29,12.39 273.29,13.99 273.52,14.21 274.01,14.21
B+ on TOP (solid shape): 76.84,78.48 76.84,75.68 74.81,73.65 72.4,73.65 70.49,75.56 70.49,78.22 71.26,78.98 76.34,78.98
B+ on TOP (solid shape): 65.62,24.15 65.62,23.1 65.62,22.82 64.93,22.14 64.27,22.14 64.09,22.32 64.09,24.25 64.27,24.42 65.34,24.42
B+ on TOP (solid shape): 221.62,49.77 221.62,47.62 221.5,47.49 219.26,47.49 218.26,48.49 218.26,50.22 218.45,50.41 220.99,50.41
B+ on TOP (solid shape): 122.56,133.59 122.56,133.34 122.44,133.21 122.18,133.21 121.8,132.83 121.8,132.32 121.68,132.2 114.82,132.2 114.69,132.32 114.69,133.59 114.82,133.72 122.44,133.72
B+ on TOP (solid shape): 238.2,45.03 238.2,43.88 237.92,43.6 233.39,43.6 233.13,43.86 233.13,45.1 233.77,45.74 237.5,45.74
B+ on TOP (solid shape): 251.84,28.4 251.84,25.38 251.85,25.36 251.85,25.03 251.52,24.7 250.14,24.7 249.73,25.11 249.73,27.54 249.46,27.8 249.46,28.54 250,29.07 251.17,29.07
B+ on TOP (solid shape): 139.78,117.76 139.23,117.76 139.23,117.21 139.78,117.21 139.78,116.96 139.23,116.96 139.23,116.41 139.78,116.41 139.78,116.14 139.73,116.09 136.75,116.09 136.55,116.28 136.55,117.17 137.47,118.09 139.78,118.09
B+ on TOP (solid shape): 139.07,133.47 139.07,132.2 138.87,131.99 138.11,131.99 138.09,131.97 136.75,131.97 136.72,131.97 136.72,131.45 136.28,131.45 136.28,131.97 136.25,131.97 135.55,131.97 135.52,131.97 135.52,131.45 135.08,131.45 135.08,131.97 135.05,131.97 134.27,131.97 134.02,132.22 134.02,133.49 134.22,133.7 138.85,133.7
B+ on TOP (solid shape): 68.72,123.31 68.72,119.88 68.39,119.88 68.26,120.01 67.04,120.01 67.04,119.98 66.96,119.98 66.93,119.95 66.26,119.95 66.26,119.94 66.24,119.94 66.24,119.6 65.79,119.6 65.79,119.94 65.77,119.94 65.77,119.95 65.06,119.95 65.06,119.94 65.04,119.94 65.04,119.6 64.59,119.6 64.59,119.94 64.57,119.94 64.57,119.95 63.91,119.95 63.85,119.95 63.85,123.14 64.4,123.69 68.34,123.69
B+ on TOP (solid shape): outline of 306 points within 168.79,47.72 194.09,56.99
B+ on TOP (solid shape): outline of 3962 points within 20.2,6.52 145.31,30.34
B+ on BOTTOM (solid shape): 75.83,77.21 75.83,75.05 74.43,73.65 72.4,73.65 71.79,74.26 71.79,76.6 72.65,77.46 75.57,77.46
B+ on BOTTOM (solid shape): 70.95,122.77 70.95,119.65 70.23,118.94 64.37,118.94 64.37,121.88 64.65,122.16 64.65,123.18 64.78,123.31 70.41,123.31
B+ on BOTTOM (solid shape): 220.86,50.28 220.86,48.78 219.95,47.87 218.8,47.87 218.29,48.38 218.29,50.01 218.69,50.41 220.74,50.41
B+ on BOTTOM (solid shape): 95.49,8.65 95.49,6.72 95.23,6.47 94.37,6.47 93.99,6.85 93.99,8.63 94.12,8.75 95.39,8.75
B+ on BOTTOM (solid shape): 139.78,118.78 139.78,116.5 139.67,116.39 139.67,116.39 139.38,116.11 136.98,116.11 136.65,116.44 136.65,117.17 137.23,117.75 137.23,118.83 137.36,118.96 139.61,118.96
B+ on BOTTOM (solid shape): 154.31,41.14 154.31,40.25 154.44,40.12 155.2,40.12 155.33,40 155.33,39.11 155.2,38.98 148.88,38.98 148.65,39.21 148.65,40.73 149.18,41.27 154.19,41.27
B+ on BOTTOM (solid shape): 44.15,27.48 44.15,22.34 44.15,20.24 44.15,20.06 43.32,20.06 43.19,20.18 43.19,23.1 42.55,23.74 41.41,23.74 41.03,24.12 41.03,27.55 41.16,27.68 43.95,27.68
B+ on BOTTOM (solid shape): 135.91,133.71 136.34,133.71 136.36,133.72 138.95,133.72 139.1,133.57 139.1,132.15 138.34,131.38 135.49,131.38 134.86,132.02 134.86,133.47 135.11,133.72 135.9,133.72
B+ on BOTTOM (solid shape): 122.56,133.59 122.56,133.21 122.44,133.09 122.42,133.09 122.29,133.11 122.16,133.09 122.15,133.09 121.95,133.09 121.31,132.45 116.85,132.45 116.63,132.67 116.63,132.68 116.62,132.68 116.6,132.71 116.33,132.71 116.22,132.75 116.09,132.77 115.13,132.77 114.69,133.21 114.69,133.59 114.82,133.72 122.44,133.72
B+ on BOTTOM (solid shape): 253.59,26.28 253.59,22.93 253.74,22.78 254.95,22.78 254.95,22.77 255.33,22.77 255.45,22.48 255.76,22.4 255.76,21.89 255.76,21.02 255.89,20.89 255.89,20.67 253.76,20.67 253.4,20.31 251.34,20.31 249.8,21.86 249.8,26.3 250.01,26.51 253.36,26.51
B+ on BOTTOM (solid shape): 28.08,30.49 28.91,30.49 28.95,30.45 29.29,30.35 29.57,30.57 29.58,30.6 31.27,30.6 31.52,30.6 31.89,30.23 32.01,30.1 32.01,28.06 31.76,27.8 27.07,27.8 26.6,28.28 26.6,29.07 27.56,29.07 27.61,29.12 27.98,29.12 28.31,29.45 27.98,29.79 27.61,29.79 27.56,29.84 26.68,29.84 26.68,30.6 27.98,30.6
B+ on BOTTOM (solid shape): outline of 440 points within 191.75,53.94 208.75,60.26
B+ on IN1 (solid shape): outline of 163 points within 191.88,46.27 220.25,58
B+ on IN1 (solid shape): outline of 926 points within 143.84,38.98 160.86,61.01
B+ on IN1 (solid shape): outline of 5067 points within 41.03,20.06 76.65,77.72
B+ on IN2 (solid shape): 68.49,23.71 68.49,20.61 68.07,20.2 66.82,20.2 66.81,20.21 65.31,20.21 64.7,20.82 64.7,23.64 65.03,23.97 68.23,23.97
B+ on IN2 (solid shape): outline of 110 points within 218.2,43.55 235.81,50.66
B+ on IN2 (solid shape): outline of 1061 points within 26.3,16.25 47.13,32.25
B+ on IN2 (solid shape): outline of 1856 points within 76.08,6.59 148.85,16.47
B+ on IN2 (solid shape): outline of 9462 points within 62.77,113.02 140.6,133.72
B+ on VCC: 140.07,12.94 139.71,13.3 139.71,18.89 138.82,19.78 138.82,23.37 139.23,24.07 138.82,24.77 138.82,26.25 138.83,26.29 138.87,26.3 138.99,26.33 139.09,26.4 139.16,26.43 139.23,26.4 139.84,26.66 139.23,26.92 139.16,26.89 139.09,26.92 138.99,26.99 138.87,27.02 138.83,27.03 138.82,27.07 138.82,29.06 138.87,29.06 139.17,29.35 138.99,29.73 138.95,29.8 138.97,29.89 139.71,30.62 139.71,30.62 140.98,31.89 140.98,39.38 142.74,41.14 155.46,41.14 155.46,39.47 150.76,34.77 150.76,25.08 150.56,24.76 150.76,24.44 150.76,23.6 150.7,23.51 150.59,23.52 150,23.26 150.59,22.99 150.7,23.01 150.76,22.91 150.76,21.96 150.25,21.45 150.25,12.94
B+ on VCC: outline of 313 points within 15.76,27.42 140.6,133.72
B+ on VCC: 168.16,51.66 167.01,52.8 167.01,56.61 166.1,57.52 164.75,57.52 164.73,57.55 164.41,57.75 164.09,57.55 164.08,57.52 154.69,57.52 154.19,58.12 154.19,60.95 171.05,60.95 172.86,59.15 172.86,57.47 172.82,57.46 172.53,57.11 172.82,56.76 172.86,56.76 172.86,55.98 172.78,55.77 172.85,55.55 172.86,55.54 172.86,55.49 172.84,55.45 172.81,55.44 172.55,55.3 172.48,55 172.49,54.97 171.71,54.2 171.71,53.31 170.06,51.66
B++ on BOTTOM (solid shape): 50.05,30.22 50.05,29.45 49.92,29.33 49.54,29.33 49.16,28.95 49.16,28.31 48.27,27.42 48.27,23.92 48.18,23.79 48.14,23.64 48.14,23.61 47.76,23.23 47.76,19.68 48.59,18.85 49.48,18.85 50.68,17.64 50.68,16.37 51.06,15.99 52.08,15.99 52.59,16.5 53.62,16.5 53.98,16.14 55.74,16.14 56.1,16.5 56.52,16.5 56.65,16.37 56.65,15.87 57.16,15.36 57.16,13.63 57.34,13.45 58.5,13.45 58.94,13.01 58.94,10.84 58.43,10.33 58.43,8.12 58.18,7.86 55.38,7.86 52.59,10.66 48.52,10.66 48.27,10.91 48.27,16.25 48.24,16.27 48.24,16.63 44.97,19.9 44.58,19.9 44.4,20.09 44.4,20.65 44.89,20.65 44.89,21.31 44.4,21.31 44.4,21.85 44.89,21.85 44.89,22.51 44.4,22.51 44.4,29.02 45.73,30.34 49.92,30.34
B+_AMP on TOP (solid shape): outline of 283 points within 253.65,19.85 268.23,28.01
B+_AMP on BOTTOM (solid shape): 255.61,29.83 255.61,29.63 255.61,29.63 255.61,28.54 256.27,27.88 256.27,27.02 256.13,26.87 252.05,26.87 251.78,27.14 251.78,29.07 251.98,29.26 254.3,29.26 254.61,29.57 254.61,29.92 254.7,30.01 255.43,30.01
B+_AMP on BOTTOM (solid shape): 267.85,21.35 267.85,21.17 268.03,21 269.27,21 269.36,20.9 269.37,20.9 269.42,20.86 269.42,20.09 269.31,19.98 268.47,19.98 268.46,19.98 267.79,19.98 267.66,19.85 267.4,19.85 267.19,20.06 267.19,21.33 267.37,21.5 267.7,21.5
B+_CAM on BOTTOM (solid shape): 211.52,60.92 211.52,58.54 210.98,58 209.79,58 209.15,58.64 209.15,60.87 209.26,60.98 211.46,60.98
B+_CAM on BOTTOM (solid shape): 227.59,45.96 228.28,45.96 228.43,45.81 228.43,44.34 228.31,44.21 228.31,42.79 228.23,42.71 227.8,42.71 227.72,42.79 227.72,44.34 226.7,45.35 226.7,45.91 226.93,46.14 227.42,46.14
B+_CAM on IN3 (solid shape): 212.58,58.69 212.58,57.83 212.43,57.67 210.78,57.67 210.54,57.92 210.28,57.92 210.14,57.95 210.01,57.94 209.81,58.13 209.81,58.33 209.81,58.34 209.81,58.64 210.13,58.96 210.43,58.96 210.44,58.97 212.3,58.97
B+_CAM on IN3 (solid shape): 226.65,46.24 227.54,46.24 227.72,46.07 227.72,45.2 227.49,44.97 227.02,44.97 226.83,45.03 226.65,44.97 226.53,44.97 225.43,46.07 225.43,46.6 225.46,46.62 226.27,46.62
BATDRV_CHG on TOP (solid shape): 40.01,16.5 40.01,15.87 40.14,15.74 40.52,15.74 40.65,15.61 40.65,15.23 40.52,15.1 39.51,15.1 39.25,15.36 39.25,16.5 39.38,16.63 39.89,16.63
BATDRV_CHG on BOTTOM (solid shape): 34.66,37.58 34.66,37.33 34.55,37.23 31.53,37.23 31.46,37.3 31.46,37.38 31.53,37.46 32.83,37.46 33.06,37.68 34.55,37.68
BATDRV_CHG on IN1 (solid shape): 34.74,37.65 34.74,37.26 34.65,37.17 34.57,37.14 33.98,37.14 33.6,36.76 33.6,36.31 32.97,36.31 32.97,37.14 33.6,37.77 34.62,37.77
BATSRC_CHG on TOP (solid shape): 39,16.5 39,15.36 38.74,15.1 37.73,15.1 37.6,15.23 37.6,15.61 37.73,15.74 38.11,15.74 38.24,15.87 38.24,16.5 38.36,16.63 38.87,16.63
BATSRC_CHG on BOTTOM (solid shape): 34.27,38.5 34.27,38.17 34.2,38.09 33.13,38.09 32.67,37.63 31.53,37.63 31.46,37.71 31.46,37.79 31.53,37.86 32.57,37.86 33.31,38.6 34.17,38.6
BATT++ on BOTTOM (solid shape): 46.05,16.82 46.81,16.82 47.19,16.44 47.19,12.25 45.86,10.91 45.86,8.25 45.55,7.94 42.02,7.94 41.79,8.17 41.79,13.54 42.02,13.77 43.76,13.77 44.46,14.47 44.46,16.5 44.84,16.88 45.98,16.88
BST1_5V on BOTTOM (solid shape): 52.21,26.28 52.21,25.77 52.08,25.64 50.17,25.64 50.05,25.77 50.05,26.41 50.17,26.53 51.95,26.53
BST_1VALWP on BOTTOM (solid shape): 249.12,18.72 249.12,18.21 249.69,17.64 249.69,16.75 249.64,16.7 249.49,16.7 249.41,16.78 249.41,17.29 248.49,18.21 248.49,18.72 248.54,18.77 249.07,18.77
BST_1VALWP_R on BOTTOM (solid shape): 249.07,19.1 248.49,19.1 248.1,18.72 247.72,18.72 247.66,18.79 247.66,19.23 248.1,19.68 249.07,19.68
BST_3V on BOTTOM (solid shape): 52.05,20.51 52.05,20.29 52,20.18 51.98,20.07 51.98,18.78 52,18.67 52.05,18.57 52.05,18.05 51.9,17.9 50.99,17.9 50.96,17.92 50.96,18.51 51.83,19.37 51.83,20.54 51.88,20.59 51.98,20.59
BST_+1.05VSP on BOTTOM (solid shape): 222.13,46.85 222.13,46.22 222.39,45.96 222.39,44.83 222.31,44.76 222.21,44.76 221.69,45.27 221.69,45.9 221.37,46.22 221.37,46.81 221.47,46.92 222.07,46.92
BST_+1.35VS_VGAP on BOTTOM (solid shape): 143.93,114.87 143.93,114.14 143.88,114.09 141.61,114.09 141.54,114.16 141.54,114.85 141.61,114.93 143.88,114.93
BTST_CHG on BOTTOM (solid shape): 29.98,35.68 29.98,33.62 30.31,33.29 30.31,32.63 30.29,32.6 29.42,32.6 29.4,32.63 29.4,33.26 29.75,33.62 29.75,35.68 29.83,35.75 29.91,35.75
CHG_B+ on TOP (solid shape): 19.31,26.53 19.31,23.99 19.95,23.36 19.95,22.85 19.44,22.85 19.44,21.33 19.95,21.33 19.95,17.64 19.31,17.01 17.54,17.01 17.15,17.39 17.15,18.68 17.33,18.86 17.33,26.35 17.15,26.53 17.28,26.66 19.19,26.66
CHG_B+ on BOTTOM (solid shape): 19.31,26.53 19.31,24.12 20.46,22.98 23.5,22.98 23.76,22.72 23.76,18.66 23.5,18.41 18.55,18.41 17.28,19.68 17.28,25.52 18.42,26.66 19.19,26.66
CMSRC_CHG on BOTTOM (solid shape): 26.36,37.1 27.01,37.1 27.06,37.05 28.23,37.05 28.28,37 28.28,36.87 28.23,36.82 27.27,36.82 27.09,36.64 25.36,36.64 25.36,37.53 25.93,37.53
DH_CHG on BOTTOM (solid shape): 26.43,18.79 26.43,17.39 26.3,17.26 24.65,17.26 24.39,17.52 24.39,19.04 24.65,19.29 25.92,19.29
DH_CHG on BOTTOM (solid shape): 29.58,35.7 29.58,33.59 29.45,33.47 29.25,33.47 29.12,33.59 29.12,34.38 29.37,34.64 29.37,35.7 29.42,35.75 29.52,35.75
DH_CHG on IN1 (solid shape): 29.66,34.47 29.66,32.18 29.03,32.18 29.03,34.47 29.16,34.6 29.54,34.6
DL_CHG on BOTTOM (solid shape): 23,27.68 23,27.42 22.87,27.3 22.87,26.79 22.74,26.66 22.23,26.66 21.85,27.04 21.85,27.68 21.98,27.8 22.87,27.8
DL_CHG on BOTTOM (solid shape): 30.77,35.7 30.77,34.84 31.48,34.13 31.48,33.8 31.35,33.67 31.15,33.67 30.57,34.25 30.57,35.68 30.64,35.75 30.72,35.75
DL_CHG on IN3 (solid shape): 31.58,34.15 31.58,33.52 30.74,32.68 30.36,32.68 30.36,33.21 30.92,33.77 30.92,33.9 30.54,34.28 30.54,34.53 30.74,34.74 31,34.74
DTH_VDD12 on BOTTOM (solid shape): outline of 117 points within 264.8,35.42 273.34,39.33
DTH_VDD12 on IN2 (solid shape): outline of 212 points within 265.19,35.17 271.54,39.32
DTH_VDD33 on BOTTOM (solid shape): 268.09,33.72 268.16,33.72 268.23,33.65 268.87,33.65 269.12,33.39 269.12,32.5 269.38,32.25 269.38,29.96 269.25,29.84 268.36,29.84 268.23,29.96 268.23,32.88 268.21,32.91 268.21,32.93 267.73,33.41 267.73,33.65 267.85,33.77 268.04,33.77
DTH_VDD33 on IN3 (solid shape): outline of 234 points within 263.03,29.96 269.12,34.79
DTH_VDDA12 on BOTTOM (solid shape): 266.96,34.41 266.96,34.03 267.12,33.87 267.15,33.79 267.11,33.71 267.06,33.21 267.57,33.25 267.64,33.3 267.72,33.27 268.11,32.88 268.11,30.34 267.98,30.22 263.79,30.22 263.66,30.34 263.66,31.23 263.92,31.49 264.68,31.49 266.07,32.88 266.07,34.28 266.33,34.53 266.84,34.53
DTH_VDDRX12 on BOTTOM (solid shape): 262.98,41.28 262.98,38.72 262.75,38.24 263.25,38.07 263.26,38.07 263.3,38.07 263.66,37.71 263.66,34.53 263.6,34.44 263.49,34.46 263.04,34.44 263.03,33.98 263.03,33.6 262.99,33.52 262.26,33.52 262.01,33.77 262.01,41.24 262.18,41.4 262.85,41.4
DTH_VDDTX12 on BOTTOM (solid shape): 270.01,37.07 270.27,36.97 270.53,37.07 272.61,37.07 272.63,37.07 273.19,37.07 273.31,36.95 273.31,35.55 273.19,35.42 271.15,35.42 270.27,34.53 268.28,34.53 268.23,34.56 268.18,34.59 267.85,34.92 267.85,35.17 267.98,35.3 268.23,35.3 268.36,35.42 268.36,35.59 268.42,35.91 268.18,36.13 268.16,36.13 267.96,36.34 267.96,37.05 267.98,37.07
EDPVDD on TOP (solid shape): 68.23,40.67 68.23,39.54 67.86,39.17 67.66,39.17 67.62,39.13 67.4,39.13 67.17,39.37 67.17,39.66 66.74,40.1 65.64,40.1 65.48,40.26 65.48,41.16 65.87,41.16 65.87,41.55 65.48,41.55 65.48,42.34 65.59,42.46 66.45,42.46
GPU_PVCC on BOTTOM (solid shape): 172.43,54.7 173.01,54.7 173.09,54.78 174.04,54.78 174.1,54.79 174.17,54.8 174.27,54.8 174.34,54.74 174.34,54.6 174.26,54.52 174.16,54.52 174.09,54.54 174.04,54.54 173.38,54.54 173.21,54.37 172.83,54.37 172.7,54.24 172.5,54.24 172.35,54.09 172.35,53.33 172.22,53.2 171.46,53.2 171.33,53.33 171.33,53.91 171.38,53.96 171.38,54.02 171.6,54.23 171.6,54.84 171.66,54.9 172.22,54.9
LDO_1VALWP on BOTTOM (solid shape): 249.36,15.2 249.36,14.65 249.06,14.34 249.06,13.96 248.29,13.2 248.29,12.56 248.17,12.44 247.53,12.44 247.53,13.33 248.42,14.21 248.42,15.2 248.5,15.28 249.29,15.28
LDO_+0.95VSP on TOP (solid shape): 70.88,67.05 70.88,66.54 70.8,66.46 68.67,66.46 68.59,66.54 68.59,67.1 68.67,67.17 70.75,67.17
LDO_+1.05VSP on BOTTOM (solid shape): 222.05,43.25 222.05,42.71 221.62,42.28 219.97,42.28 219.85,42.41 219.85,42.77 219.94,42.87 220.78,42.87 221.24,43.33 221.98,43.33
LG_3V on BOTTOM (solid shape): 61.56,10.76 61.56,9.85 61.07,9.36 61.07,8.98 60.97,8.88 59.32,8.88 59.06,9.13 59.06,9.52 59.19,9.64 60.46,9.64 60.84,10.02 60.84,10.79 60.97,10.91 61.41,10.91
LG_3V on BOTTOM (solid shape): 51.37,20.79 51.37,20.72 50.35,19.7 50.35,19.65 50.12,19.42 49.92,19.42 49.79,19.55 49.79,20.39 49.97,20.56 50.05,20.56 50.26,20.63 50.4,20.79 50.41,20.8 50.85,20.8 50.96,20.82 51.06,20.87 51.29,20.87
LG_5V on TOP (solid shape): 50.3,37.07 50.3,35.3 50.17,35.17 49.54,35.17 49.41,35.3 49.41,37.07 49.54,37.2 50.17,37.2
LG_5V on TOP (solid shape): 50.43,23.36 50.43,22.6 50.3,22.47 49.16,22.47 49.03,22.6 49.03,23.36 49.16,23.49 50.3,23.49
LG_5V on BOTTOM (solid shape): 50.38,36.92 50.38,34.15 50.13,33.9 49.77,33.9 49.54,34.13 49.54,36.95 49.75,37.16 50.14,37.16
LG_5V on BOTTOM (solid shape): 50.66,22.47 51.29,22.47 51.37,22.39 51.37,22.32 51.31,22.25 51.04,22.25 50.95,22.3 50.85,22.31 50.05,22.31 49.9,22.47 49.34,22.47 49.18,22.62 49.18,22.85 49.29,22.95 50.17,22.95
LG_+1.35VS_VGAP on BOTTOM (solid shape): 139.67,114.93 139.71,114.93 139.81,114.82 139.81,114.16 139.63,113.98 138.91,113.98 138.82,114.07 138.82,114.92 138.93,115.03 139.57,115.03
LG_+1.35VS_VGAP on BOTTOM (solid shape): 140.19,127.77 140.19,127.45 140.09,127.35 139.96,127.35 139.81,127.21 139.81,126.74 139.68,126.61 139.25,126.61 139.09,126.77 139.09,127.75 139.22,127.88 140.08,127.88
LG_+1.35VS_VGAP on IN1 (solid shape): 139.7,115.83 139.7,115.71 139.5,115.51 139.5,114.14 139.32,113.96 139.06,113.96 138.9,114.12 138.9,115.73 139.27,116.1 139.43,116.1
LINE1-L_R on TOP (solid shape): 293.51,14.6 294.52,14.6 294.65,14.47 294.65,13.83 294.52,13.71 293.25,13.71 293.06,13.52 292.81,13.52 292.81,13.64 292.24,14.21 292.24,14.6 292.36,14.72 293.38,14.72
LX_1VALWP on TOP (solid shape): 253.12,17.39 253.12,16.5 252.99,16.37 252.74,16.37 252.49,16.63 247.91,16.63 247.79,16.75 247.79,17.64 247.91,17.77 252.74,17.77
LX_1VALWP on BOTTOM (solid shape): 253.12,17.39 253.12,16.5 252.99,16.37 251.62,16.37 251.55,16.45 251.55,16.55 251.88,16.88 251.98,16.88 252.61,17.52 252.99,17.52
LX_1VALWP on BOTTOM (solid shape): 248.17,18.53 248.17,18.02 249.18,17.01 249.18,16.73 249.36,16.55 249.36,16.02 249.29,15.94 248.37,15.94 248.12,15.69 248.12,14.42 247.28,13.58 247.28,12.99 246.97,12.69 243.62,12.69 243.44,12.87 243.44,16.8 245.23,18.6 248.1,18.6
LX_3V on BOTTOM (solid shape): 70.62,14.47 70.62,10.28 70.37,10.02 65.49,10.02 64.39,11.13 60.97,11.13 60.79,11.31 59.27,11.31 59.13,11.45 59.13,13.64 60.33,14.85 70.24,14.85
LX_3V on BOTTOM (solid shape): 52.29,19.22 52.32,19.27 52.38,19.25 52.44,19.2 52.44,19.19 52.62,19 52.66,18.94 52.7,18.9 53.55,18.04 53.55,16.68 53.5,16.63 53.2,16.63 53.1,16.73 53.1,17.67 52.84,17.92 52.36,17.92 52.23,18.05 52.23,18.5 52.29,18.56
LX_3V on IN1 (solid shape): 53.73,17.71 53.73,16.69 54.38,16.05 54.38,15.72 53.82,15.72 53.1,16.44 53.1,17.71 53.22,17.83 53.6,17.83
LX_5V on TOP (solid shape): 47.63,32.88 47.63,30.97 46.93,30.26 45.83,30.26 45.35,30.75 45.35,31.99 46.36,33.01 47.51,33.01
LX_5V on BOTTOM (solid shape): 50.05,33.52 50.05,30.85 49.92,30.72 45.35,30.72 43.45,28.83 39.95,28.83 39.89,28.89 39.89,32.76 40.78,33.65 49.92,33.65
LX_5V on IN3 (solid shape): 52.16,24.58 52.61,24.12 52.61,23.87 52.41,23.66 52.13,23.66 51.5,24.3 51.5,25.57 52.16,25.57
LX_+0.95VSP on TOP (solid shape): 70.41,69.77 71.07,69.77 71.64,69.21 71.64,68.44 71.38,68.19 71.26,68.19 70.88,67.81 68.66,67.81 68.59,67.88 68.59,68.44 68.82,68.67 68.82,69.53 69.09,69.81 70.37,69.81
LX_+0.95VSP on BOTTOM (solid shape): 72.02,73.14 72.02,68.7 71.13,67.81 68.67,67.81 68.27,68.2 66.04,68.2 65.8,68.44 65.8,69.21 66.56,69.97 67.93,69.97 69.99,72.03 69.99,73.14 70.11,73.27 71.89,73.27
LX_+1.05VSP on TOP (solid shape): 225.31,45.71 225.31,45.08 225.05,44.82 221.12,44.82 220.99,44.95 220.99,45.84 221.12,45.96 225.05,45.96
LX_+1.05VSP on BOTTOM (solid shape): 225.23,45.92 225.23,44.57 225.08,44.43 224.34,44.43 224.27,44.5 224.27,44.67 224.67,45.08 224.67,45.84 224.8,45.96 225.18,45.96
LX_+1.05VSP on BOTTOM (solid shape): 220.55,47.5 220.7,47.43 220.86,47.4 221.12,47.4 221.12,46.22 221.5,45.84 221.5,45.16 222.05,44.6 222.05,44.11 221.92,43.98 217.38,43.98 216.95,44.41 216.95,47.23 217.23,47.51 220.54,47.51
LX_CHG on TOP (solid shape): 25.79,23.99 25.79,22.6 25.66,22.47 24.14,22.47 24.01,22.6 24.01,23.99 24.27,24.25 25.54,24.25
LX_CHG on BOTTOM (solid shape): 31.12,24.76 31.12,19.17 30.74,18.79 26.93,18.79 25.92,19.8 24.39,19.8 24.14,20.06 24.14,22.85 23.12,23.87 23.12,27.3 23.38,27.55 28.33,27.55
LX_CHG on BOTTOM (solid shape): 29.17,35.7 29.17,34.66 28.99,34.48 28.99,32.68 28.94,32.63 28.23,32.63 28.15,32.71 28.15,34.23 28.56,34.64 28.76,34.64 28.97,34.84 28.97,35.7 29.02,35.75 29.12,35.75
LX_CHG on IN1 (solid shape): 28.78,34.47 28.78,33.03 28.77,33.01 28.77,32.69 28.39,32.31 28.08,32.31 28.08,32.88 28.14,32.95 28.14,34.47 28.27,34.6 28.65,34.6
LX_DDR on BOTTOM (solid shape): 106.56,13.02 106.56,12.61 106.59,12.59 106.59,9.41 107.2,8.8 107.2,7.1 105.5,7.1 105.04,7.56 105.04,8.6 104.96,8.68 104.96,8.74 103.32,10.37 103.32,10.49 102.92,10.89 101.32,10.89 101.1,11.11 101.1,12.33 101.15,12.39 103.08,12.39 103.49,12.79 104.61,12.79 105.14,13.33 106.26,13.33
PQ703_S on TOP (solid shape): 38.49,20.44 38.49,19.29 39,18.79 39,17.01 38.87,16.88 34.93,16.88 34.68,17.14 34.68,20.31 34.93,20.56 38.36,20.56
PQ703_S on BOTTOM (solid shape): 42.81,22.98 42.81,19.93 42.68,19.8 42.25,19.8 42.17,19.88 42.05,19.88 42.05,21.33 41.79,21.58 41.54,21.58 41.28,21.33 41.28,19.8 40.52,19.8 39.25,18.53 38.24,18.53 37.73,18.02 37.73,17.26 37.47,17.01 34.81,17.01 34.68,17.14 34.68,22.98 35.06,23.36 42.43,23.36
REGN_CHG on BOTTOM (solid shape): 30.39,35.7 30.39,34.2 31.3,33.29 31.56,33.29 31.61,33.24 31.61,33.03 31.59,32.93 31.61,32.84 31.61,32.63 31.58,32.6 31.35,32.6 30.74,31.99 30.36,31.99 30.24,32.12 30.24,32.38 30.36,32.5 30.52,32.5 30.62,32.6 30.62,33.31 30.16,33.77 30.16,35.68 30.24,35.75 30.34,35.75
RING2 on TOP (solid shape): 280.53,20.21 280.65,20.09 280.65,20.08 280.81,19.93 280.81,19.04 280.68,18.91 280.21,18.91 280.21,18.96 280.04,19.12 280.04,19.93 280.48,20.36 280.53,20.36
RING2 on BOTTOM (solid shape): 291.73,19.04 291.73,17.9 291.27,17.9 291.27,18.35 290.99,18.63 289.24,18.63 289.14,18.74 289.14,19.27 289.57,19.7 289.57,20.31 289.7,20.44 290.33,20.44
RING2 on IN1 (solid shape): 290.08,19.12 290.08,18.79 289.85,18.56 288.88,18.56 288.53,18.91 288.02,18.91 287.97,18.96 287.97,19.88 288.05,19.95 289.24,19.95
RING2 on IN1 (solid shape): 280.81,19.75 280.81,19.57 281.21,19.17 282.33,19.17 282.52,18.98 282.52,18.33 282.34,18.15 280.04,18.15 279.66,18.53 279.66,19.55 280.17,20.06 280.5,20.06
RING2_R on BOTTOM (solid shape): 295.46,20.36 295.46,19.42 294.9,19.42 294.65,19.17 294.65,18.2 294.32,17.87 292.16,17.87 292.11,17.92 292.11,18.48 292.29,18.66 292.87,18.66 293.84,19.62 293.84,20.44 294.12,20.72 295.11,20.72
SLEEVE on BOTTOM (solid shape): 298.33,14.34 298.33,12.69 298.21,12.56 297.57,12.56 297.57,14.34 297.7,14.47 298.21,14.47
SLEEVE on BOTTOM (solid shape): 286.9,20.41 286.9,19.68 286.65,19.42 285.35,19.42 285.1,19.17 281.21,19.17 280.93,19.45 280.93,19.93 281.19,20.18 284.16,20.18 284.54,20.56 286.75,20.56
SLEEVE on IN2 (solid shape): 283.45,19.5 283.45,19.19 283.42,19.17 281.14,19.17 280.96,19.34 280.96,20.08 281.06,20.18 282.76,20.18
SLEEVE on IN2 (solid shape): 298.43,14.37 298.43,13.48 298.28,13.33 297.49,13.33 297.24,13.58 296.5,13.58 296.3,13.78 296.3,14.42 296.48,14.6 298.21,14.6
SLEEVE_R on BOTTOM (solid shape): 297.24,10.3 298.97,8.58 298.97,8.07 299.3,7.73 299.3,7.53 299.32,7.42 299.23,7.36 298.69,7.36 297.99,8.06 297.8,8.06 296.47,9.39 296.47,9.57 296.17,9.87 296.17,13.02 296.35,13.2 297.24,13.2
SNUB_1VALWP on TOP (solid shape): 255.15,11.6 254.95,11.39 254.3,11.39 254.18,11.52 254.18,14.38 254.21,14.42 255.15,14.42
SNUB_3V on BOTTOM (solid shape): 66.3,9.39 66.3,7.1 66.18,6.98 65.54,6.98 65.29,7.23 65.29,8.12 65.03,8.37 64.53,8.37 64.4,8.5 64.4,9.39 64.53,9.52 66.18,9.52
SNUB_5V on TOP (solid shape): 45.22,34.22 45.22,32.88 44.84,32.5 44.84,31.23 44.71,31.11 43.7,31.11 43.57,31.23 43.57,33.52 44.38,34.33 45.11,34.33
SNUB_+0.95VSP on BOTTOM (solid shape): 64.86,69.91 64.86,68.29 64.81,68.24 62.53,68.24 62.35,68.42 62.35,69.89 62.47,70 64.76,70
SNUB_CHG on TOP (solid shape): 25.79,26.15 25.79,25.26 25.66,25.14 23.25,25.14 23.12,25.26 23.12,26.15 23.25,26.28 25.66,26.28
SW_+1.35VS_VGAP on TOP (solid shape): 146.95,126.99 146.95,122.67 146.57,122.29 142.88,122.29 142.88,126.86 143.14,127.12 146.82,127.12
SW_+1.35VS_VGAP on TOP (solid shape): 142.18,117.23 142.18,116.93 141.77,116.52 141.77,116.1 141.62,115.96 141.34,115.96 141.21,116.08 141.21,116.79 141.8,117.38 142.03,117.38
SW_+1.35VS_VGAP on BOTTOM (solid shape): 151.14,128.01 151.14,122.42 150.38,121.66 144.03,121.66 143.8,121.43 143.8,120.89 143.79,120.88 143.79,120.65 143.65,120.51 141.87,120.51 141.71,120.67 141.71,121.4 141.15,121.96 140.75,121.96 140.6,122.11 140.6,127.88 141.11,128.39 150.76,128.39
SW_+1.35VS_VGAP on BOTTOM (solid shape): 141.74,116.91 141.74,116.18 141.71,116.11 141.69,116.04 141.68,116.02 141.58,115.92 141.47,115.92 140.82,115.27 140.82,114.17 140.74,114.09 140.62,114.09 140.53,114.19 140.53,115.42 140.46,115.49 140.46,116.41 140.59,116.54 140.64,116.54 140.65,116.53 140.95,116.53 141.41,116.98 141.67,116.98
SW_+1.35VS_VGAP on IN3 (solid shape): 151.15,128.04 151.15,122.43 150.37,121.65 144.01,121.65 143.8,121.44 143.8,120.66 143.65,120.51 141.88,120.51 141.6,120.78 141.6,121.25 141.51,121.34 141.52,121.37 141.41,121.67 141.12,121.77 141.09,121.77 140.56,122.3 140.56,127.9 141.08,128.42 150.77,128.42
SWF_BSNL on TOP (solid shape): 306.87,5.93 306.87,4.08 306.66,3.88 306,3.88 305.7,4.18 305.7,4.73 305.08,5.35 305.08,5.89 305.06,5.91 305.06,6.59 305.17,6.7 306.11,6.7
SWF_BSNL on BOTTOM (solid shape): 262.24,13.68 262.24,10.43 262.01,10.2 260.44,10.2 260.31,10.33 260.31,11.47 260.82,11.98 260.82,13.96 260.89,14.04 261.88,14.04
SWF_BSNL on IN2 (solid shape): 306.94,4.79 306.94,2.53 306.59,2.17 306.13,2.17 305.7,2.61 305.7,4.84 305.98,5.12 306.61,5.12
SWF_BSNL on IN2 (solid shape): 263.43,11.24 265.49,11.24 265.64,11.09 265.64,10.15 265.47,9.97 260.49,9.97 260.18,10.28 260.18,11.22 261.07,12.11 262.57,12.11
SWF_BSNR on TOP (solid shape): 304.71,6.57 304.71,5.29 305.42,4.58 305.42,4.21 305.12,3.91 304.39,3.91 304.3,4 304.3,4.77 304.23,4.84 304.23,4.86 304.07,5.02 304.07,6.54 304.25,6.72 304.56,6.72
