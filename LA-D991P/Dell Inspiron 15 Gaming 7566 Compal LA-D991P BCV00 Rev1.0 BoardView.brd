# Allegro board Dell Inspiron 15 Gaming 7566 Compal LA-D991P BCV00 Rev1.0 BoardView.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
TPS51285BRUKR_QFN20_3X3-S
  oval 0.203x1.016 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 11(1.6,2.975) 12(1.2,2.975) 13(0.8,2.975) 14(0.4,2.975) 15(0,2.975)
  oval 1.016x0.203 smd: 6(2.288,0.688) 7(2.288,1.088) 8(2.288,1.488) 9(2.288,1.888) 10(2.288,2.288) 16(-0.688,2.288) 17(-0.688,1.888) 18(-0.688,1.488) 19(-0.688,1.088) 20(-0.688,0.688)
  rect 1.702x1.702 smd: 21(0.8,1.488)
TVNST52302AB0_SOT523-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.5,-1.4) 3(0.5,-1.4)
W25Q128FVSIQ_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
W25X20CLSNIG_SO8
  oval 0.635x1.854 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.165) 6(2.54,5.165) 7(1.27,5.165) 8(0,5.165)
Y_5YEA27000102IF50Q3_4P
  rect 1.295x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
Y_7V25000014_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
Y_7V27000011_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
Y_CM31532768DZFT_2P
  rect 1.092x1.905 smd: 1(0,0) 2(2.5,0)
Y_X1A000141000200_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_X3G024000DC1H_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)

## Nets
1.2V_DDR_OT: PR500.1 PU500.19
1.2V_DTH: RZ98.1 UZ22.7 UZ22.8
1.2V_VCCPLL_OC: RZ67.1 UZ16.7 UZ16.8
1.2V_VDDQ_EN: CZ102.1 PR507.1 RZ102.2
1.05V_DGPU_PG: DV13.2 PR801.2 UV11.1
1.35V_DGPU_PG: PR908.1 UV11.2
3.3V_CAM_EN#: PR113.1 QZ9.2 RZ38.1 UH2.AR27
3V3_MAIN_EN: PR806.1 PR1008.2 RV55.1 UV1.L7 UZ17.3
3V/5VALW_EN: PC422.1 PD401.2 PD401.3 PQ403.1 PR407.1 PR409.2 PR418.2
3V_GFX_AON: QV85.1 RV533.1
3V_GFX_RUN: RZ69.1 UZ17.7 UZ17.8
3VS: PJP15.1 UZ1.8 UZ1.9
3VS_TP: RE93.1 UE4.1
5VS: RZ13.1 UZ1.13 UZ1.14
5VS_FAN1: JFAN1.2 RE104.2
5VS_FAN2: JFAN2.2 RE105.2
+0.6VS: CD12.1 CD13.1 CD14.1 CD15.1 CD32.1 CD88.1 CD89.1 CD90.1 JDIMM1.258 JDIMM2.258 PJP501.2
+0.6VSP: PC515.1 PC516.1 PJP501.1 PU500.5 PU500.6
+0.95VSP: PC706.1 PC707.1 PC708.1 PC709.1 PC712.1 PJ701.1 PL701.2 PR703.1
+1.2V_DDR: CD1.1 CD2.1 CD5.1 CD6.1 CD7.1 CD8.1 CD11.1 CD19.1 CD20.1 CD21.1 CD22.1 CD23.1 CD24.1 CD25.1 CD26.1 CD33.1 CD70.1 CD71.1 CD72.1 CD73.1 CD74.1 CD75.1 CD76.1 CD77.1 CD78.1 CD79.1 CD80.1 CD81.1 CD82.1 CD83.1 CD84.1 CD85.1 CD86.1 CD87.1 CH118.1 CH119.1 CH120.1 CH121.1 CH122.1 CH123.1 CH124.1 CH125.1 CH126.1 CH127.1 CH128.1 CH129.1 CH130.1 CH131.1 CH132.1 CH197.1 JDIMM1.12 JDIMM1.33 JDIMM1.54 JDIMM1.75 JDIMM1.96 JDIMM1.111 JDIMM1.112 JDIMM1.117 JDIMM1.118 JDIMM1.123 JDIMM1.124 JDIMM1.129 JDIMM1.130 JDIMM1.135 JDIMM1.136 JDIMM1.141 JDIMM1.142 JDIMM1.147 JDIMM1.148 JDIMM1.153 JDIMM1.154 JDIMM1.159 JDIMM1.160 JDIMM1.163 JDIMM1.178 JDIMM1.199 JDIMM1.220 JDIMM1.241 JDIMM2.12 JDIMM2.33 JDIMM2.54 JDIMM2.75 JDIMM2.96 JDIMM2.111 JDIMM2.112 JDIMM2.117 JDIMM2.118 JDIMM2.123 JDIMM2.124 JDIMM2.129 JDIMM2.130 JDIMM2.135 JDIMM2.136 JDIMM2.141 JDIMM2.142 JDIMM2.147 JDIMM2.148 JDIMM2.153 JDIMM2.154 JDIMM2.159 JDIMM2.160 JDIMM2.163 JDIMM2.178 JDIMM2.199 JDIMM2.220 JDIMM2.241 PJP500.2 RD35.1 RH34.1 RH107.2 RH206.1 RH207.1 UC1.5 UH1.AA6 UH1.AE12 UH1.AF5 UH1.AF6 UH1.AG5 UH1.AG9 UH1.AJ12 UH1.AL11 UH1.AP6 UH1.AP7 UH1.AR6 UH1.AR12 UH1.AT12 UH1.AW6 UH1.AY6 UH1.J5 UH1.J6 UH1.K6 UH1.K12 UH1.L6 UH1.L12 UH1.R6 UH1.T6 UH1.W6 UZ16.1 UZ16.2 UZ22.1 UZ22.2
+1.2V_DDRP: PC508.1 PC509.1 PC510.1 PC511.1 PC512.1 PC513.1 PJP500.1 PL501.2 PR503.1 PU500.7 PU500.8
+1.2V_DTH: CM8.1 CM22.1 CM26.1 CM37.1 CZ99.1 LM2.1 LM3.1 LM4.1 LM5.1 RZ98.2
+1.2V_PWROK: PR501.1 PU500.18
+1.2V_VCCPLL_OC: CZ49.1 RH107.1 RZ67.2 UH1.BH13 UH1.G11
+1.05VS_VGA: CV87.1 CV88.1 CV89.1 CV90.1 CV91.1 CV92.1 CV93.2 CV94.2 CV95.2 CV96.1 CV97.1 CV98.1 CV99.1 CV111.2 CV121.1 CV122.1 CV123.1 LV7.1 LV8.2 LV13.1 PJ801.2 RZ9.1 UV1.AG13 UV1.AG15 UV1.AG16 UV1.AG18 UV1.AG19 UV1.AG21 UV1.AG22 UV1.AG24 UV1.AG25 UV1.AG26 UV1.AH15 UV1.AH18 UV1.AH21 UV1.AH25 UV1.AH26 UV1.AH27 UV1.AJ27 UV1.AK27 UV1.AL27 UV1.AM28 UV1.AN28
+1.05VSP: PC806.1 PC807.1 PC808.1 PC809.1 PC810.1 PJ801.1 PL801.2 PR805.1
+1.8V_AVDD: CA1.1 CA2.1 CA63.2 HDA1.40 RA1.1
+1.8V_DVDD: CA3.1 HDA1.36 RA1.2 RA3.1
+1.8VS: CA7.1 RA3.2 UA1.5
+1.35VS_VGA: CV74.1 CV75.1 CV76.1 CV77.1 CV78.1 CV79.2 CV80.2 CV83.1 CV84.1 CV85.1 CV86.1 CV100.1 CV101.1 CV102.1 CV103.1 CV104.1 CV105.1 CV106.1 CV107.1 CV108.1 CV109.1 CV110.1 CV112.1 CV113.1 CV160.2 CV161.1 CV162.1 CV163.1 CV164.1 CV165.1 CV166.1 CV167.1 CV168.2 CV169.1 CV170.1 CV171.1 CV172.1 CV173.1 CV174.1 CV175.1 CV179.2 CV180.1 CV181.1 CV182.1 CV183.1 CV184.1 CV185.1 CV186.1 CV187.2 CV188.1 CV189.1 CV190.1 CV191.1 CV192.1 CV193.1 CV194.1 CV203.1 CV204.1 CV205.1 CV206.1 CV207.1 CV208.1 CV209.1 CV210.1 CV211.1 CV215.1 CV373.2 CV374.1 CV375.1 CV376.1 CV377.1 CV378.1 CV379.1 CV380.1 CV381.2 CV382.1 CV383.1 CV384.1 CV385.1 CV386.1 CV387.1 CV388.1 CV389.2 CV390.1 CV391.1 CV392.1 CV393.1 CV394.1 CV395.1 CV396.1 CV397.2 CV398.1 CV399.1 CV400.1 CV401.1 CV402.1 CV403.1 CV404.1 PJP901.2 PJP902.2 RV77.1 RV95.1 RV96.1 RV98.1 RV99.1 RV117.2 RV125.1 RV128.1 RV131.2 RV140.1 RV143.1 RZ8.1 UV1.AA27 UV1.AA30 UV1.AB27 UV1.AB33 UV1.AC27 UV1.AD27 UV1.AE27 UV1.AF27 UV1.AG27 UV1.B13 UV1.B16 UV1.B19 UV1.E13 UV1.E16 UV1.E19 UV1.H8 UV1.H9 UV1.H10 UV1.H11 UV1.H12 UV1.H13 UV1.H14 UV1.H15 UV1.H16 UV1.H18 UV1.H19 UV1.H20 UV1.H21 UV1.H22 UV1.H23 UV1.H24 UV1.L27 UV1.M27 UV1.N27 UV1.P27 UV1.R27 UV1.T27 UV1.T30 UV1.T33 UV1.V27 UV1.W27 UV1.W30 UV1.W33 UV1.Y27 UV6.B1 UV6.B3 UV6.B12 UV6.B14 UV6.C5 UV6.C10 UV6.D1 UV6.D3 UV6.D11 UV6.D12 UV6.D14 UV6.E5 UV6.E10 UV6.F1 UV6.F3 UV6.F12 UV6.F14 UV6.G1 UV6.G2 UV6.G4 UV6.G11 UV6.G13 UV6.G14 UV6.H3 UV6.H12 UV6.K3 UV6.K12 UV6.L1 UV6.L2 UV6.L4 UV6.L11 UV6.L13 UV6.L14 UV6.M1 UV6.M3 UV6.M12 UV6.M14 UV6.N5 UV6.N10 UV6.P1 UV6.P3 UV6.P11 UV6.P12 UV6.P14 UV6.R5 UV6.R10 UV6.T1 UV6.T3 UV6.T12 UV6.T14 UV7.B1 UV7.B3 UV7.B12 UV7.B14 UV7.C5 UV7.C10 UV7.D1 UV7.D3 UV7.D11 UV7.D12 UV7.D14 UV7.E5 UV7.E10 UV7.F1 UV7.F3 UV7.F12 UV7.F14 UV7.G1 UV7.G2 UV7.G4 UV7.G11 UV7.G13 UV7.G14 UV7.H3 UV7.H12 UV7.K3 UV7.K12 UV7.L1 UV7.L2 UV7.L4 UV7.L11 UV7.L13 UV7.L14 UV7.M1 UV7.M3 UV7.M12 UV7.M14 UV7.N5 UV7.N10 UV7.P1 UV7.P3 UV7.P11 UV7.P12 UV7.P14 UV7.R5 UV7.R10 UV7.T1 UV7.T3 UV7.T12 UV7.T14 UV8.B1 UV8.B3 UV8.B12 UV8.B14 UV8.C5 UV8.C10 UV8.D1 UV8.D3 UV8.D11 UV8.D12 UV8.D14 UV8.E5 UV8.E10 UV8.F1 UV8.F3 UV8.F12 UV8.F14 UV8.G1 UV8.G2 UV8.G4 UV8.G11 UV8.G13 UV8.G14 UV8.H3 UV8.H12 UV8.K3 UV8.K12 UV8.L1 UV8.L2 UV8.L4 UV8.L11 UV8.L13 UV8.L14 UV8.M1 UV8.M3 UV8.M12 UV8.M14 UV8.N5 UV8.N10 UV8.P1 UV8.P3 UV8.P11 UV8.P12 UV8.P14 UV8.R5 UV8.R10 UV8.T1 UV8.T3 UV8.T12 UV8.T14 UV9.B1 UV9.B3 UV9.B12 UV9.B14 UV9.C5 UV9.C10 UV9.D1 UV9.D3 UV9.D11 UV9.D12 UV9.D14 UV9.E5 UV9.E10 UV9.F1 UV9.F3 UV9.F12 UV9.F14 UV9.G1 UV9.G2 UV9.G4 UV9.G11 UV9.G13 UV9.G14 UV9.H3 UV9.H12 UV9.K3 UV9.K12 UV9.L1 UV9.L2 UV9.L4 UV9.L11 UV9.L13 UV9.L14 UV9.M1 UV9.M3 UV9.M12 UV9.M14 UV9.N5 UV9.N10 UV9.P1 UV9.P3 UV9.P11 UV9.P12 UV9.P14 UV9.R5 UV9.R10 UV9.T1 UV9.T3 UV9.T12 UV9.T14
+1.35VS_VGAP: PC907.1 PC908.1 PJP901.1 PJP902.1 PL901.2 PR906.2
+1.35VS_VGAP_B+: PC900.1 PC901.1 PC902.1 PC903.1 PJP900.1 PL900.1 PQ900.5
+1V_MPHY: CH183.1 CH184.1 CH185.1 PJP70.2 UH2.U21 UH2.U23 UH2.U25 UH2.U26 UH2.V26 UH2.V28
+1V_MPHY_MPHYPLL: CH180.1 CH181.1 CH182.1 RH124.2 UH2.A43 UH2.B43 UH2.C44 UH2.C45
+1V_PCH: PJP1302.2 UH2.AC17 UH2.AD15 UH2.AL22 UH2.N17 UH2.R17 UH2.R19 UH2.U20 UH2.V17
+1V_PCH_AZPLL: CH203.1 LH2.2 UH2.AN19
+1V_PCH_CLK5: CH177.1 CH178.1 CH179.1 RH122.2 UH2.K2 UH2.K3
+1V_PCH_PRIM: PJP1303.2 RH196.1 UH2.AA23 UH2.AA26 UH2.AA28 UH2.AC23 UH2.AC26 UH2.AC28 UH2.AE23 UH2.AE26 UH2.AJ20 UH2.AJ21 UH2.AJ23 UH2.AJ25 UH2.Y23 UH2.Y25
+1V_PCH_USBPLL: CH201.1 CH202.1 RH123.2 UH2.AJ5 UH2.AL5
+1V_VCCDSW: CH176.1 RH196.2 UH2.BA29
+1VALW: CZ88.1 CZ96.1 LH2.1 PJ601.2 PJP70.1 PJP1302.1 PJP1303.1 RE116.2 RH71.1 RH122.1 RH123.1 RH124.1 UZ9.1 UZ9.2 UZ9.7 UZ15.1 UZ15.2 UZ15.7
+1VALWP: PC606.1 PC607.1 PC608.1 PC609.1 PC610.1 PJ601.1 PL601.2 PR602.1
+2.5V_MEM: CD3.1 CD4.1 CD9.1 CD10.1 CD27.1 CD28.1 CD30.1 CD31.1 JDIMM1.257 JDIMM1.259 JDIMM2.257 JDIMM2.259 PR1805.2
+2.5VSP_ON: PC1800.1 PR1801.2 PU1800.2
+3.3V_GFX_AON: CV114.1 CV115.1 CV116.1 CV202.1 CV213.1 CV214.1 CV568.1 CV573.1 CV574.1 CV575.1 PR1001.1 RV34.2 RV39.1 RV41.2 RV42.2 RV55.2 RV57.2 RV60.1 RV146.2 RV147.2 RV148.2 RV149.2 RV150.2 RV191.2 RV192.2 RV526.2 RV532.2 RV533.2 RZ11.1 UV1.AG12 UV1.AH12 UV1.J8 UV1.K8 UV11.5 UV18.5
+3.3V_GFX_RUN: CV117.1 CV118.1 CV119.1 CV120.1 CV569.1 CV570.1 CV571.1 CV572.1 CV602.1 PR804.1 PR1007.2 RV157.2 RV158.2 RV159.2 RZ69.2 UV1.L8 UV1.M8
+3.3VDX_SSD: CD36.1 CD38.1 CD39.1 CD40.1 CD41.1 JNGFF2.2 JNGFF2.4 JNGFF2.12 JNGFF2.14 JNGFF2.16 JNGFF2.18 JNGFF2.70 JNGFF2.72 JNGFF2.74 PJP36.2 RD7.1 RD8.2
+3V_DVDD: CA8.1 CA9.1 CA25.1 CA26.1 CA28.1 HDA1.1 HDA1.9 RA5.2 RA23.1 RA24.1 RA70.2
+3V_PCH_AZIO: CH200.1 LH1.2 UH2.BA15
+3V_PCH_DSW: CH82.1 RH17.2 RH81.2 RH125.2 RH137.2 RH181.2 UH2.BA24 UH2.W15
+3V_PCH_SPI: RH493.2 UH2.BE41 UH2.BE42 UH2.BE43
+3V_ROM: RH74.1 RH121.1 UH8.8
+3VALW: CC298.1 CH186.1 CH187.1 CH189.1 CH190.1 CH191.1 CH192.1 CL39.1 CV212.1 CZ12.1 CZ105.1 JAPS.1 JAPS.3 JAPS.7 JIO1.28 LH1.1 PC506.1 PC613.1 PC713.1 PC813.1 PJP401.2 PR101.1 PR112.2 PR202.1 PR208.1 PR312.1 PR320.2 PR504.1 PR606.1 PR707.1 PR800.2 PR809.1 PR1800.1 PU500.13 PU600.15 PU700.15 PU800.15 QH5.2 QH5.5 RA17.2 RE12.1 RE25.1 RE28.2 RE29.2 RE30.2 RE34.1 RE38.1 RE39.2 RE113.2 RH21.1 RH22.1 RH23.1 RH25.1 RH62.1 RH63.1 RH64.1 RH65.1 RH66.1 RH67.2 RH68.2 RH82.1 RH91.1 RH92.1 RH110.2 RH121.2 RH126.2 RH128.2 RH130.1 RH131.2 RH132.2 RH134.2 RH135.2 RH137.1 RH193.2 RH493.1 RI9.1 RI10.1 RI30.1 RL41.2 RN2.1 RP8.5 RP8.6 RP8.7 RP8.8 RPE2.5 RPE2.6 RPE2.7 RPE2.8 RPE3.5 RPE3.6 RPE3.7 RPE3.8 RPE4.1 RPE4.2 RPE4.3 RPE4.4 RPE5.1 RPE5.2 RPE5.3 RPE5.4 RPE6.1 RPE6.2 RPE6.3 RPE6.4 RPE7.1 RPE7.2 RPE7.3 RPE7.4 RT1.1 RZ12.1 RZ32.2 RZ33.1 RZ96.2 UC16.5 UE4.5 UH2.AD41 UH2.AJ41 UH2.AL41 UH2.AN5 UH2.BA20 UH2.BA31 UH2.BA45 UH2.BB45 UH2.BC42 UH2.BC44 UH2.BC45 UH2.BD3 UH2.BD40 UH2.BE3 UH2.BE4 UL2.5 UV14.5 UZ1.6 UZ1.7 UZ8.5 UZ21.5
+3VALW_EC: CE62.1 CE63.2 CE64.2 CE65.1 CE66.1 CE67.1 CE68.1 CE69.1 CE79.1 CE81.1 CE89.1 RE12.2 RE13.1 RE15.1 RE43.2 RE44.2 RE45.2 RE46.2 RE53.2 RE60.2 RE63.1 RE64.1 RE65.1 RE118.1 RE119.2 RE125.1 UE1.5 UE1.19 UE1.22 UE1.43 UE1.65 UE1.82 UE1.103 UE1.115
+3VALWP: PC401.1 PC413.1 PJP401.1 PL402.1 PR401.1 PR410.1
+3VLP: PJP1304.1 PR400.1 RE20.2
+3VS: CA4.1 CD16.1 CD17.1 CD34.1 CD35.1 CE85.1 CH188.1 CT81.1 CZ9.1 CZ43.1 CZ106.1 JDIMM1.255 JDIMM2.255 JDIMM2.260 JIO1.29 JIO1.30 JLPDE1.1 JLPDE1.2 PJP15.2 PJP36.1 PR110.1 PR500.2 PR501.2 PR900.1 PR1112.1 Q12.2 Q13.2 QE3.2 QE19.2 QE19.5 QH4.2 QH4.5 QT2.2 QT2.5 QV85.3 QZ9.3 RA2.1 RA5.1 RE81.1 RE83.1 RE108.1 RE120.2 RE121.1 RE122.1 RH10.1 RH14.1 RH15.1 RH26.1 RH27.1 RH69.2 RH79.2 RH80.2 RH85.2 RH86.1 RH87.2 RH90.2 RH93.1 RH111.2 RH119.1 RH120.1 RH129.2 RH141.2 RH142.2 RH159.1 RH160.1 RH179.2 RH180.1 RH494.1 RH500.2 RL33.1 RM15.2 RM22.1 RP2.1 RP2.2 RP2.3 RP2.4 RP3.1 RP3.2 RP3.3 RP3.4 RP22.1 RP22.2 RP22.3 RP22.4 RP23.1 RP23.2 RP23.3 RP23.4 RT3.1 RT4.1 RT5.1 RZ38.2 UA1.1 UE6.5 UH2.AD13 UH7.5 UH14.5 UT1.1 UZ17.1 UZ17.2 UZ23.5
+3VS_CAM: CV582.1 CV583.1 CV584.1 CZ44.1 JCAM1.12 RZ37.2
+3VS_DTH: CM1.1 CM40.1 LM1.1 RM5.2 RM6.1 RM7.2 RM10.1 RM14.1 RM15.1 RM16.1 RM20.1 RM23.1 UM2.8
+3VS_TP: CE2.1 DE4.5 JTP.8 QE13.2 RE7.2 RE9.2 RE24.1 RE55.1 RE87.1 RE93.2 RE123.1
+3VS_WLAN: CN1.1 CN2.1 CN6.1 CN7.1 CN8.1 CN9.1 JNGFF1.2 JNGFF1.4 JNGFF1.64 JNGFF1.66 RM22.2 RN2.2
+5V_AVDD: CA17.1 CA18.1 HDA1.26 RA8.1
+5V_CHGUSB_1: CI17.1 CI18.1 CI19.1 JUSB1.1 US2.1
+5V_CHGUSB_2: CI11.1 CI12.1 CI13.1 JUSB2.1 US1.12
+5V_PVDD: CA11.1 CA12.1 CA13.1 CA14.1 HDA1.41 HDA1.46 RA7.2 RA8.2 RA10.2
+5VALW: CI23.1 CI24.1 CZ11.1 CZ86.1 CZ97.1 CZ104.1 CZ107.1 JIO1.1 JIO1.2 JIO1.3 JIO1.4 JIO1.5 JLED.4 JPW.1 JUART.1 PC905.1 PC1801.1 PC1804.1 PJP402.2 PR104.2 PU900.7 PU1800.3 PU1800.4 RH504.1 RH505.1 RH506.1 RV534.1 RW3.2 RW4.2 US1.1 US2.5 UZ1.1 UZ1.2 UZ1.4 UZ9.3 UZ15.3 UZ16.4 UZ17.4 UZ22.4
+5VALWP: PC402.2 PC414.1 PC415.1 PC423.1 PJP402.1 PL403.2 PR402.2 PU400.14
+5VS: CE5.1 CZ8.1 F1.2 PR1016.2 PR1028.2 PR1030.1 PR1101.1 PR1400.1 PR1402.1 PR1403.1 PR1414.1 PR1416.1 PR1418.1 PR1428.1 PR1430.1 PR1432.1 PR1500.1 PR1502.1 PR1504.1 PR1512.1 PR1514.1 PR1516.1 PR1531.1 PR1533.1 QE4.3 RA7.1 RA10.1 RA74.1 RA75.1 RE1.2 RE82.1 RE84.1 RE100.1 RE101.1 RE104.1 RE105.1 RZ13.2 RZ26.1 RZ34.1 UV17.1
+5VS_HDD: CS12.1 CS13.1 CS14.1 CS15.1 JHDD1.1 JHDD1.2 JHDD1.3 RZ34.2
+5VS_KBL: CE4.1 CE6.1 F1.1 JBL1.1
+5VS_TS: JEDP1.19 RZ26.2
+19VB_1VALWP: PC601.1 PC602.1 PC603.1 PC604.1 PJ600.2 PL600.2 PU600.2 PU600.3 PU600.4 PU600.5
+19VB_+0.95VSP: PC702.1 PC703.1 PC704.1 PC705.1 PJ700.2 PL700.2 PU700.2 PU700.3 PU700.4 PU700.5
+19VB_+1.05VSP: PC801.1 PC802.1 PC804.1 PC805.1 PJ800.2 PL800.2 PU800.2 PU800.3 PU800.4 PU800.5
+VCC_CORE: PC1200.1 PC1201.1 PC1202.1 PC1203.1 PC1204.1 PC1205.1 PC1207.1 PC1208.1 PC1220.1 PC1221.1 PC1222.1 PC1223.1 PC1224.1 PC1225.1 PC1226.1 PC1229.1 PC1230.1 PC1231.1 PC1232.1 PC1233.1 PC1239.1 PC1240.1 PC1241.1 PC1242.1 PC1243.1 PC1244.1 PC1245.1 PC1246.1 PC1247.1 PC1248.1 PC1261.1 PC1263.1 PC1264.1 PC1265.1 PC1269.1 PC1271.1 PC1274.1 PC1276.1 PC1397.1 PL1402.2 PL1403.2 PL1404.2 PR1408.1 PR1422.1 PR1436.1 RH197.1 UH1.AA13 UH1.AA31 UH1.AA32 UH1.AA33 UH1.AA34 UH1.AA35 UH1.AA36 UH1.AA37 UH1.AA38 UH1.AB29 UH1.AB30 UH1.AB31 UH1.AB32 UH1.AB35 UH1.AB36 UH1.AB37 UH1.AB38 UH1.AC13 UH1.AC14 UH1.AC29 UH1.AC30 UH1.AC31 UH1.AC32 UH1.AC33 UH1.AC34 UH1.AC35 UH1.AC36 UH1.AD13 UH1.AD14 UH1.AD31 UH1.AD32 UH1.AD33 UH1.AD34 UH1.AD35 UH1.AD36 UH1.AD37 UH1.AD38 UH1.AE13 UH1.AE14 UH1.AE30 UH1.AE31 UH1.AE32 UH1.AE35 UH1.AE36 UH1.AE37 UH1.AE38 UH1.AF35 UH1.AF36 UH1.AF37 UH1.AF38 UH1.K13 UH1.K14 UH1.L13 UH1.L14 UH1.N13 UH1.N14 UH1.N30 UH1.N31 UH1.N32 UH1.N35 UH1.N36 UH1.N37 UH1.N38 UH1.P13 UH1.P14 UH1.P29 UH1.P30 UH1.P31 UH1.P32 UH1.P33 UH1.P34 UH1.P35 UH1.P36 UH1.R13 UH1.R31 UH1.R32 UH1.R33 UH1.R34 UH1.R35 UH1.R36 UH1.R37 UH1.R38 UH1.T29 UH1.T30 UH1.T31 UH1.T32 UH1.T35 UH1.T36 UH1.T37 UH1.T38 UH1.U29 UH1.U30 UH1.U31 UH1.U32 UH1.U33 UH1.U34 UH1.U35 UH1.U36 UH1.V13 UH1.V14 UH1.V31 UH1.V32 UH1.V33 UH1.V34 UH1.V35 UH1.V36 UH1.V37 UH1.V38 UH1.W13 UH1.W14 UH1.W29 UH1.W30 UH1.W31 UH1.W32 UH1.W35 UH1.W36 UH1.W37 UH1.W38 UH1.Y29 UH1.Y30 UH1.Y31 UH1.Y32 UH1.Y33 UH1.Y34 UH1.Y35 UH1.Y36
+VCCGT: PC1300.1 PC1301.1 PC1303.1 PC1304.1 PC1305.1 PC1306.1 PC1307.1 PC1309.1 PC1310.1 PC1311.1 PC1312.1 PC1314.1 PC1320.1 PC1321.1 PC1322.1 PC1323.1 PC1324.1 PC1325.1 PC1326.1 PC1327.1 PC1328.1 PC1329.1 PC1330.1 PC1331.1 PC1332.1 PC1333.1 PC1334.1 PC1335.1 PC1338.1 PC1339.1 PC1340.1 PC1341.1 PC1342.1 PC1348.1 PC1349.1 PC1350.1 PC1351.1 PC1352.1 PC1353.1 PC1354.1 PC1359.1 PC1360.1 PC1361.1 PC1362.1 PC1363.1 PC1366.1 PC1367.1 PC1368.1 PC1369.1 PC1370.1 PC1372.1 PC1373.1 PC1374.1 PC1375.1 PC1376.1 PC1377.1 PC1378.1 PC1379.1 PL1502.2 PL1503.2 PR1507.1 PR1520.1 RH203.1 UH1.AJ29 UH1.AJ30 UH1.AJ31 UH1.AJ32 UH1.AJ33 UH1.AJ34 UH1.AJ35 UH1.AJ36 UH1.AK31 UH1.AK32 UH1.AK33 UH1.AK34 UH1.AK35 UH1.AK36 UH1.AK37 UH1.AK38 UH1.AL13 UH1.AL29 UH1.AL30 UH1.AL31 UH1.AL32 UH1.AL35 UH1.AL36 UH1.AL37 UH1.AL38 UH1.AM13 UH1.AM14 UH1.AM29 UH1.AM30 UH1.AM31 UH1.AM32 UH1.AM33 UH1.AM34 UH1.AM35 UH1.AM36 UH1.AN13 UH1.AN14 UH1.AN31 UH1.AN32 UH1.AN33 UH1.AN34 UH1.AN35 UH1.AN36 UH1.AN37 UH1.AN38 UH1.AP13 UH1.AP14 UH1.AP29 UH1.AP30 UH1.AP31 UH1.AP32 UH1.AP35 UH1.AP36 UH1.AP37 UH1.AP38 UH1.AR29 UH1.AR30 UH1.AR31 UH1.AR32 UH1.AR33 UH1.AR34 UH1.AR35 UH1.AR36 UH1.AT14 UH1.AT31 UH1.AT32 UH1.AT33 UH1.AT34 UH1.AT35 UH1.AT36 UH1.AT37 UH1.AT38 UH1.AU14 UH1.AU29 UH1.AU30 UH1.AU31 UH1.AU32 UH1.AU35 UH1.AU36 UH1.AU37 UH1.AU38 UH1.AV29 UH1.AV30 UH1.AV31 UH1.AV32 UH1.AV33 UH1.AV34 UH1.AV35 UH1.AV36 UH1.AW14 UH1.AW31 UH1.AW32 UH1.AW33 UH1.AW34 UH1.AW35 UH1.AW36 UH1.AW37 UH1.AW38 UH1.AY29 UH1.AY30 UH1.AY31 UH1.AY32 UH1.AY35 UH1.AY36 UH1.AY37 UH1.AY38 UH1.BA13 UH1.BA14 UH1.BA29 UH1.BA30 UH1.BA31 UH1.BA32 UH1.BA33 UH1.BA34 UH1.BA35 UH1.BA36 UH1.BB13 UH1.BB14 UH1.BB31 UH1.BB32 UH1.BB33 UH1.BB34 UH1.BB35 UH1.BB36 UH1.BB37 UH1.BB38 UH1.BC29 UH1.BC30 UH1.BC31 UH1.BC32 UH1.BC35 UH1.BC36 UH1.BC37 UH1.BC38 UH1.BD13 UH1.BD14 UH1.BD29 UH1.BD30 UH1.BD31 UH1.BD32 UH1.BD33 UH1.BD34 UH1.BD35 UH1.BD36 UH1.BE31 UH1.BE32 UH1.BE33 UH1.BE34 UH1.BE35 UH1.BE36 UH1.BE37 UH1.BE38 UH1.BF13 UH1.BF14 UH1.BF29 UH1.BF30 UH1.BF31 UH1.BF32 UH1.BF35 UH1.BF36 UH1.BF37 UH1.BF38 UH1.BG29 UH1.BG30 UH1.BG31 UH1.BG32 UH1.BG33 UH1.BG34 UH1.BG35 UH1.BG36 UH1.BH33 UH1.BH34 UH1.BH35 UH1.BH36 UH1.BH37 UH1.BH38 UH1.BJ37 UH1.BJ38 UH1.BL36 UH1.BL37 UH1.BM36 UH1.BM37 UH1.BN36 UH1.BN37 UH1.BN38 UH1.BP37 UH1.BP38 UH1.BR37 UH1.BT37
+VCCIO: CH102.1 CH103.1 CH104.1 PJ701.2 RH24.1 RH30.2 RH515.2 UH1.AG12 UH1.G15 UH1.G17 UH1.G19 UH1.G21 UH1.H15 UH1.H16 UH1.H17 UH1.H19 UH1.H20 UH1.H21 UH1.H26 UH1.H27 UH1.J15 UH1.J16 UH1.J17 UH1.J19 UH1.J20 UH1.J21 UH1.J26 UH1.J27
+VCCIO_PG: PR712.2 RH103.1
+VCCSA: CH111.1 CH112.1 CH113.1 CH114.1 CH115.1 CH116.1 CH117.1 CH133.1 CH134.1 CH135.1 CH136.1 PC1380.1 PC1382.1 PC1383.1 PC1384.1 PC1385.1 PC1386.1 PC1388.1 PC1389.1 PC1390.1 PC1391.1 PC1393.1 PC1394.1 PC1395.1 PC1396.1 PL1505.4 RH201.2 UH1.J30 UH1.K29 UH1.K30 UH1.K31 UH1.K32 UH1.K33 UH1.K34 UH1.K35 UH1.L31 UH1.L32 UH1.L35 UH1.L36 UH1.L37 UH1.L38 UH1.M29 UH1.M30 UH1.M31 UH1.M32 UH1.M33 UH1.M34 UH1.M35 UH1.M36
+VCCST: CH110.1 CH204.1 PC1101.1 PR1103.1 PR1104.1 RH97.1 RH98.1 RH100.1 RH144.1 RH151.1 RH152.1 RH156.1 RH163.1 RH164.1 RZ66.2 UH1.H28 UH1.H30 UH1.J28
+VCCSTG: CH106.1 CZ47.1 RH56.1 RH165.1 RH496.1 RH497.1 RZ48.1 UH1.G30 UH1.H29
GND: CA3.2 CA4.2 CA7.2 CA8.2 CA9.2 CA10.1 CA11.2 CA12.2 CA13.2 CA14.2 CA15.1 CA25.2 CA26.2 CA27.2 CA28.2 CA30.2 CA31.2 CA32.2 CA33.2 CA34.1 CA35.1 CA36.2 CA37.2 CA38.2 CA39.2 CA44.1 CA45.2 CA52.2 CA53.2 CA54.2 CA55.2 CA56.2 CA57.2 CA60.2 CA61.2 CA62.2 CA67.2 CC4.1 CC5.1 CC27.2 CC298.2 CD1.2 CD2.2 CD3.2 CD4.2 CD5.2 CD6.2 CD7.2 CD8.2 CD9.2 CD10.2 CD11.2 CD12.2 CD13.2 CD14.2 CD15.2 CD16.2 CD17.2 CD19.2 CD20.2 CD21.2 CD22.2 CD23.2 CD24.2 CD25.2 CD26.2 CD27.2 CD28.2 CD29.2 CD30.2 CD31.2 CD32.2 CD33.2 CD34.2 CD35.2 CD36.2 CD38.2 CD39.2 CD40.2 CD41.2 CD69.2 CD70.2 CD71.2 CD72.2 CD73.2 CD74.2 CD75.2 CD76.2 CD77.2 CD78.2 CD79.2 CD80.2 CD81.2 CD82.2 CD83.2 CD84.2 CD85.2 CD86.2 CD87.2 CD88.2 CD89.2 CD90.2 CD93.2 CD94.2 CD95.2 CD96.2 CE1.2 CE2.2 CE4.2 CE5.2 CE6.2 CE8.2 CE9.2 CE10.2 CE12.2 CE62.2 CE63.1 CE64.1 CE65.2 CE66.2 CE67.2 CE68.2 CE69.2 CE71.2 CE72.2 CE73.2 CE74.2 CE76.2 CE77.2 CE78.1 CE79.2 CE80.2 CE82.2 CE84.1 CE85.2 CE86.2 CE89.2 CE91.2 CE99.2 CE100.2 CE101.2 CE102.2 CE103.2 CH45.2 CH46.2 CH47.2 CH48.2 CH50.1 CH51.1 CH52.2 CH53.2 CH70.2 CH80.2 CH82.2 CH102.2 CH103.2 CH104.2 CH106.2 CH110.2 CH111.2 CH112.2 CH113.2 CH114.2 CH115.2 CH116.2 CH117.2 CH118.2 CH119.2 CH120.2 CH121.2 CH122.2 CH123.2 CH124.2 CH125.2 CH126.2 CH127.2 CH128.2 CH129.2 CH130.2 CH131.2 CH132.2 CH133.2 CH134.2 CH135.2 CH136.2 CH173.2 CH176.2 CH177.2 CH178.2 CH179.2 CH180.2 CH181.2 CH182.2 CH183.2 CH184.2 CH185.2 CH186.2 CH187.2 CH188.2 CH189.2 CH190.2 CH191.2 CH192.2 CH197.2 CH200.2 CH201.2 CH202.2 CH203.2 CH204.2 CI11.2 CI12.2 CI13.2 CI17.2 CI18.2 CI19.2 CI23.2 CI24.2 CL15.2 CL19.2 CL20.2 CL21.2 CL22.2 CL24.2 CL32.2 CL33.2 CL34.2 CL35.2 CL36.2 CL37.2 CL39.2 CL41.2 CL42.2 CL43.2 CL44.2 CLRP1.2 CM1.2 CM2.2 CM3.2 CM4.2 CM5.2 CM8.2 CM9.2 CM10.2 CM11.2 CM12.2 CM13.2 CM22.2 CM23.2 CM24.2 CM25.2 CM26.2 CM27.2 CM28.2 CM29.2 CM30.2 CM31.2 CM32.2 CM33.2 CM34.2 CM35.2 CM36.2 CM37.2 CM38.2 CM39.2 CM40.2 CM41.2 CM43.2 CM44.2 CN1.2 CN2.2 CN6.2 CN7.2 CN8.2 CN9.2 CS12.2 CS13.2 CS14.2 CS15.2 CT79.2 CT80.2 CT81.2 CV50.2 CV51.2 CV52.2 CV53.2 CV70.1 CV71.1 CV72.2 CV73.2 CV74.2 CV75.2 CV76.2 CV77.2 CV78.2 CV79.1 CV80.1 CV83.2 CV84.2 CV85.2 CV86.2 CV87.2 CV88.2 CV89.2 CV90.2 CV91.2 CV92.2 CV93.1 CV94.1 CV95.1 CV96.2 CV97.2 CV98.2 CV99.2 CV100.2 CV101.2 CV102.2 CV103.2 CV104.2 CV105.2 CV106.2 CV107.2 CV108.2 CV109.2 CV110.2 CV111.1 CV112.2 CV113.2 CV114.2 CV115.2 CV116.2 CV117.2 CV118.2 CV119.2 CV120.2 CV121.2 CV122.2 CV123.2 CV151.2 CV152.2 CV153.2 CV154.2 CV155.2 CV156.2 CV158.2 CV159.2 CV160.1 CV161.2 CV162.2 CV163.2 CV164.2 CV165.2 CV166.2 CV167.2 CV168.1 CV169.2 CV170.2 CV171.2 CV172.2 CV173.2 CV174.2 CV175.2 CV177.2 CV178.2 CV179.1 CV180.2 CV181.2 CV182.2 CV183.2 CV184.2 CV185.2 CV186.2 CV187.1 CV188.2 CV189.2 CV190.2 CV191.2 CV192.2 CV193.2 CV194.2 CV202.2 CV203.2 CV204.2 CV205.2 CV206.2 CV207.2 CV208.2 CV209.2 CV210.2 CV211.2 CV212.2 CV213.2 CV214.2 CV215.2 CV373.1 CV374.2 CV375.2 CV376.2 CV377.2 CV378.2 CV379.2 CV380.2 CV381.1 CV382.2 CV383.2 CV384.2 CV385.2 CV386.2 CV387.2 CV388.2 CV389.1 CV390.2 CV391.2 CV392.2 CV393.2 CV394.2 CV395.2 CV396.2 CV397.1 CV398.2 CV399.2 CV400.2 CV401.2 CV402.2 CV403.2 CV404.2 CV568.2 CV569.2 CV570.2 CV571.2 CV572.2 CV573.2 CV574.2 CV575.2 CV576.2 CV577.2 CV579.2 CV582.2 CV583.2 CV584.2 CV597.2 CV598.2 CV599.1 CV600.1 CV601.1 CV602.2 CV603.2 CZ4.2 CZ6.2 CZ8.2 CZ9.2 CZ11.2 CZ12.2 CZ28.2 CZ41.2 CZ43.2 CZ44.2 CZ47.2 CZ49.2 CZ57.2 CZ86.2 CZ88.2 CZ95.2 CZ96.2 CZ97.2 CZ98.2 CZ99.2 CZ102.2 CZ104.2 CZ105.2 CZ106.2 CZ107.2 DA1.1 DA2.1 DA3.1 DA4.1 DA5.1 DA6.1 DE4.2 DE8.2 DI3.1 DI7.3 DI8.1 DI9.3 DI10.1 DV4.3 DV5.3 DV12.1 EC5205.2 EC5206.2 H1.1(TP-1) H2.1(TP-1) H3.1(TP-1) H4.1(TP-1) H5.1(TP-1) H6.1(TP-1) H10.1(TP-1) H11.1(TP-1) H12.1(TP-1) H13.1(TP-1) H17.1(TP-1) H19.1(TP-1) H20.1(TP-1) H23.1(TP-1) H56.1(TP-1) H57.1(TP-1) HDA1.49 HT1.2 JAPS.8 JAPS.10 JAPS.12 JAPS.14 JAPS.19 JAPS.20 JBAT10.7 JBAT10.9 JBAT10.10 JBAT10.11 JBAT10.12 JBAT10.13 JBL1.5 JBL1.6 JCAM1.1 JCAM1.2 JCAM1.5 JCAM1.8 JCAM1.15 JCAM1.16 JDEG1.10 JDEG1.11 JDEG1.12 JDIMM1.1 JDIMM1.2 JDIMM1.5 JDIMM1.6 JDIMM1.9 JDIMM1.10 JDIMM1.14 JDIMM1.15 JDIMM1.18 JDIMM1.19 JDIMM1.22 JDIMM1.23 JDIMM1.26 JDIMM1.27 JDIMM1.30 JDIMM1.31 JDIMM1.35 JDIMM1.36 JDIMM1.39 JDIMM1.40 JDIMM1.43 JDIMM1.44 JDIMM1.47 JDIMM1.48 JDIMM1.51 JDIMM1.52 JDIMM1.56 JDIMM1.57 JDIMM1.60 JDIMM1.61 JDIMM1.64 JDIMM1.65 JDIMM1.68 JDIMM1.69 JDIMM1.72 JDIMM1.73 JDIMM1.77 JDIMM1.78 JDIMM1.81 JDIMM1.82 JDIMM1.85 JDIMM1.86 JDIMM1.89 JDIMM1.90 JDIMM1.93 JDIMM1.94 JDIMM1.98 JDIMM1.99 JDIMM1.102 JDIMM1.103 JDIMM1.106 JDIMM1.107 JDIMM1.166 JDIMM1.167 JDIMM1.168 JDIMM1.171 JDIMM1.172 JDIMM1.175 JDIMM1.176 JDIMM1.180 JDIMM1.181 JDIMM1.184 JDIMM1.185 JDIMM1.188 JDIMM1.189 JDIMM1.192 JDIMM1.193 JDIMM1.196 JDIMM1.197 JDIMM1.201 JDIMM1.202 JDIMM1.205 JDIMM1.206 JDIMM1.209 JDIMM1.210 JDIMM1.213 JDIMM1.214 JDIMM1.217 JDIMM1.218 JDIMM1.222 JDIMM1.223 JDIMM1.226 JDIMM1.227 JDIMM1.230 JDIMM1.231 JDIMM1.234 JDIMM1.235 JDIMM1.238 JDIMM1.239 JDIMM1.243 JDIMM1.244 JDIMM1.247 JDIMM1.248 JDIMM1.251 JDIMM1.252 JDIMM1.256 JDIMM1.260 JDIMM1.261 JDIMM1.262 JDIMM2.1 JDIMM2.2 JDIMM2.5 JDIMM2.6 JDIMM2.9 JDIMM2.10 JDIMM2.14 JDIMM2.15 JDIMM2.18 JDIMM2.19 JDIMM2.22 JDIMM2.23 JDIMM2.26 JDIMM2.27 JDIMM2.30 JDIMM2.31 JDIMM2.35 JDIMM2.36 JDIMM2.39 JDIMM2.40 JDIMM2.43 JDIMM2.44 JDIMM2.47 JDIMM2.48 JDIMM2.51 JDIMM2.52 JDIMM2.56 JDIMM2.57 JDIMM2.60 JDIMM2.61 JDIMM2.64 JDIMM2.65 JDIMM2.68 JDIMM2.69 JDIMM2.72 JDIMM2.73 JDIMM2.77 JDIMM2.78 JDIMM2.81 JDIMM2.82 JDIMM2.85 JDIMM2.86 JDIMM2.89 JDIMM2.90 JDIMM2.93 JDIMM2.94 JDIMM2.98 JDIMM2.99 JDIMM2.102 JDIMM2.103 JDIMM2.106 JDIMM2.107 JDIMM2.166 JDIMM2.167 JDIMM2.168 JDIMM2.171 JDIMM2.172 JDIMM2.175 JDIMM2.176 JDIMM2.180 JDIMM2.181 JDIMM2.184 JDIMM2.185 JDIMM2.188 JDIMM2.189 JDIMM2.192 JDIMM2.193 JDIMM2.196 JDIMM2.197 JDIMM2.201 JDIMM2.202 JDIMM2.205 JDIMM2.206 JDIMM2.209 JDIMM2.210 JDIMM2.213 JDIMM2.214 JDIMM2.217 JDIMM2.218 JDIMM2.222 JDIMM2.223 JDIMM2.226 JDIMM2.227 JDIMM2.230 JDIMM2.231 JDIMM2.234 JDIMM2.235 JDIMM2.238 JDIMM2.239 JDIMM2.243 JDIMM2.244 JDIMM2.247 JDIMM2.248 JDIMM2.251 JDIMM2.252 JDIMM2.256 JDIMM2.261 JDIMM2.262 JEDP1.6 JEDP1.7 JEDP1.8 JEDP1.11 JEDP1.13 JEDP1.14 JEDP1.24 JEDP1.27 JEDP1.30 JEDP1.33 JEDP1.36 JEDP1.39 JEDP1.40 JEDP1.41 JEDP1.42 JEDP1.43 JEDP1.44 JFAN1.4 JFAN1.5 JFAN1.6 JFAN2.4 JFAN2.5 JFAN2.6 JHDD1.6 JHDD1.9 JHDD1.12 JHDD1.13 JHDD1.14 JHDMI1.2 JHDMI1.5 JHDMI1.8 JHDMI1.11 JHDMI1.17 JHDMI1.20 JHDMI1.21 JHDMI1.22 JHDMI1.23 JIO1.7 JIO1.10 JIO1.13 JIO1.14 JIO1.17 JIO1.18 JIO1.21 JIO1.22 JIO1.26 JIO1.31 JIO1.32 JKB1.1 JKB1.31 JKB1.32 JLAN.9 JLAN.10 JLED.1 JLED.5 JLED.6 JLPDE1.9 JLPDE1.11 JLPDE1.12 JNGFF1.1 JNGFF1.7 JNGFF1.10 JNGFF1.15 JNGFF1.25 JNGFF1.28 JNGFF1.31 JNGFF1.37 JNGFF1.43 JNGFF1.49 JNGFF1.55 JNGFF1.61 JNGFF1.67 JNGFF1.68 JNGFF1.69 JNGFF2.1 JNGFF2.3 JNGFF2.9 JNGFF2.15 JNGFF2.21 JNGFF2.27 JNGFF2.33 JNGFF2.39 JNGFF2.45 JNGFF2.51 JNGFF2.57 JNGFF2.71 JNGFF2.73 JNGFF2.75 JNGFF2.76 JNGFF2.77 JPW.4 JPW.5 JPW.6 JRTC.2 JRTC.3 JRTC.4 JSPK1.7 JSPK1.8 JTP.5 JTP.9 JTP.10 JUART.4 JUART.5 JUART.6 JUSB1.4 JUSB1.7 JUSB1.10 JUSB1.11 JUSB1.12 JUSB1.13 JUSB2.4 JUSB2.7 JUSB2.10 JUSB2.11 JUSB2.12 JUSB2.13 PC100.2 PC101.2 PC105.2 PC106.2 PC107.2 PC108.2 PC109.2 PC110.2 PC111.2 PC112.2 PC114.2 PC202.2 PC204.2 PC305.2 PC306.2 PC307.2 PC308.2 PC309.1 PC311.2 PC312.1 PC313.1 PC314.2 PC315.2 PC316.2 PC317.2 PC318.1 PC320.2 PC321.2 PC322.1 PC323.2 PC400.2 PC403.2 PC404.2 PC405.2 PC406.2 PC407.2 PC408.2 PC409.2 PC410.2 PC413.2 PC414.2 PC415.2 PC416.2 PC417.2 PC418.2 PC419.2 PC420.2 PC421.2 PC422.2 PC423.2 PC500.2 PC501.2 PC502.2 PC503.2 PC504.2 PC506.2 PC507.2 PC509.2 PC510.2 PC511.2 PC512.2 PC513.2 PC514.2 PC515.2 PC516.2 PC517.2 PC518.2 PC600.2 PC601.2 PC602.2 PC603.2 PC604.2 PC607.2 PC608.2 PC609.2 PC610.2 PC611.2 PC612.2 PC613.2 PC700.2 PC702.2 PC703.2 PC704.2 PC705.2 PC706.2 PC707.2 PC708.2 PC709.2 PC710.2 PC711.2 PC713.2 PC800.2 PC801.2 PC802.2 PC804.2 PC805.2 PC807.2 PC808.2 PC809.2 PC810.2 PC811.2 PC812.2 PC813.2 PC900.2 PC901.2 PC902.2 PC903.2 PC905.2 PC906.2 PC907.2 PC908.2 PC909.2 PC1000.2 PC1002.2 PC1003.2 PC1004.2 PC1005.2 PC1006.2 PC1007.2 PC1008.2 PC1009.2 PC1010.2 PC1011.2 PC1012.2 PC1013.2 PC1014.2 PC1015.2 PC1016.2 PC1017.2 PC1018.2 PC1019.2 PC1020.2 PC1021.2 PC1022.2 PC1023.2 PC1024.2 PC1025.2 PC1026.2 PC1027.2 PC1028.2 PC1029.2 PC1030.2 PC1031.2 PC1034.2 PC1035.2 PC1036.2 PC1037.2 PC1038.2 PC1039.2 PC1040.2 PC1041.2 PC1043.2 PC1044.2 PC1045.2 PC1046.2 PC1047.2 PC1048.2 PC1051.2 PC1052.2 PC1053.2 PC1054.2 PC1055.2 PC1056.2 PC1057.2 PC1058.2 PC1059.2 PC1060.2 PC1061.2 PC1062.2 PC1063.2 PC1064.2 PC1065.2 PC1066.2 PC1067.2 PC1068.2 PC1069.2 PC1070.2 PC1071.2 PC1072.2 PC1073.2 PC1074.2 PC1075.2 PC1077.2 PC1078.2 PC1079.2 PC1080.2 PC1081.2 PC1082.2 PC1083.2 PC1084.2 PC1085.2 PC1086.2 PC1087.2 PC1100.1 PC1101.2 PC1102.2 PC1103.2 PC1104.1 PC1105.1 PC1106.1 PC1107.1 PC1108.1 PC1111.2 PC1114.2 PC1116.2 PC1120.2 PC1121.2 PC1122.2 PC1123.2 PC1124.2 PC1130.2 PC1135.2 PC1136.2 PC1137.2 PC1138.2 PC1139.2 PC1200.2 PC1201.2 PC1202.2 PC1203.2 PC1204.2 PC1205.2 PC1207.2 PC1208.2 PC1220.2 PC1221.2 PC1222.2 PC1223.2 PC1224.2 PC1225.2 PC1226.2 PC1229.2 PC1230.2 PC1231.2 PC1232.2 PC1233.2 PC1239.2 PC1240.2 PC1241.2 PC1242.2 PC1243.2 PC1244.2 PC1245.2 PC1246.2 PC1247.2 PC1248.2 PC1261.2 PC1263.2 PC1264.2 PC1265.2 PC1269.2 PC1271.2 PC1274.2 PC1276.2 PC1300.2 PC1301.2 PC1303.2 PC1304.2 PC1305.2 PC1306.2 PC1307.2 PC1309.2 PC1310.2 PC1311.2 PC1312.2 PC1314.2 PC1320.2 PC1321.2 PC1322.2 PC1323.2 PC1324.2 PC1325.2 PC1326.2 PC1327.2 PC1328.2 PC1329.2 PC1330.2 PC1331.2 PC1332.2 PC1333.2 PC1334.2 PC1335.2 PC1338.2 PC1339.2 PC1340.2 PC1341.2 PC1342.2 PC1348.2 PC1349.2 PC1350.2 PC1351.2 PC1352.2 PC1353.2 PC1354.2 PC1359.2 PC1360.2 PC1361.2 PC1362.2 PC1363.2 PC1366.2 PC1367.2 PC1368.2 PC1369.2 PC1370.2 PC1372.2 PC1373.2 PC1374.2 PC1375.2 PC1376.2 PC1377.2 PC1378.2 PC1379.2 PC1380.2 PC1382.2 PC1383.2 PC1384.2 PC1385.2 PC1386.2 PC1388.2 PC1389.2 PC1390.2 PC1391.2 PC1393.2 PC1394.2 PC1395.2 PC1396.2 PC1397.2 PC1400.2 PC1401.1 PC1403.2 PC1404.2 PC1405.2 PC1406.2 PC1407.2 PC1408.2 PC1409.2 PC1410.2 PC1411.1 PC1413.2 PC1414.2 PC1415.2 PC1416.2 PC1417.2 PC1418.2 PC1420.1 PC1421.2 PC1422.2 PC1423.2 PC1424.2 PC1425.2 PC1500.2 PC1501.1 PC1503.2 PC1504.2 PC1505.2 PC1506.2 PC1507.2 PC1508.2 PC1509.1 PC1511.2 PC1512.2 PC1513.2 PC1514.2 PC1515.2 PC1516.2 PC1517.2 PC1518.2 PC1519.2 PC1520.1 PC1521.2 PC1523.2 PC1800.2 PC1801.2 PC1803.2 PC1804.2 PD100.2 PD101.1 PD102.1 PD401.1 PH1100.1 PH1104.2 PL102.2 PL103.2 PL104.2 PL105.2 PQ101.3 PQ103.1 PQ103.4 PQ200.1 PQ200.4 PQ201.3 PQ202.3 PQ203.1 PQ203.4 PQ305.1 PQ305.2 PQ305.3 PQ401.3 PQ401.4 PQ401.5 PQ402.1 PQ402.2 PQ402.3 PQ901.1 PQ901.2 PQ901.3 PQ1000.3 PQ1000.4 PQ1000.5 PQ1001.3 PQ1001.4 PQ1001.5 PQ1002.3 PQ1002.4 PQ1002.5 PQ1004.3 PQ1004.4 PQ1004.5 PQ1005.3 PQ1005.4 PQ1005.5 PQ1006.3 PQ1006.4 PQ1006.5 PR105.2 PR115.2 PR201.2 PR204.1 PR207.2 PR211.2 PR213.2 PR214.2 PR301.2 PR313.2 PR318.2 PR323.2 PR329.2 PR403.1 PR404.2 PR405.1 PR406.2 PR411.2 PR505.2 PR506.2 PR508.2 PR510.2 PR604.2 PR605.2 PR607.2 PR704.2 PR709.2 PR711.2 PR807.2 PR808.2 PR810.2 PR902.1 PR905.2 PR907.2 PR1006.2 PR1013.1 PR1014.1 PR1100.1 PR1105.1 PR1110.1 PR1113.2 PR1114.2 PR1115.2 PR1116.2 PR1123.2 PR1135.2 PR1143.2 PR1144.2 PR1804.2 PU300.22 PU300.29 PU400.21 PU500.4 PU500.9 PU500.15 PU600.7 PU600.8 PU600.18 PU600.21 PU700.7 PU700.8 PU700.18 PU700.21 PU800.7 PU800.8 PU800.18 PU800.21 PU900.11 PU1000.25 PU1001.6 PU1001.9 PU1100.49 PU1400.4 PU1400.10 PU1400.23 PU1400.28 PU1401.4 PU1401.10 PU1401.23 PU1401.28 PU1402.4 PU1402.10 PU1402.23 PU1402.28 PU1500.4 PU1500.10 PU1500.23 PU1500.28 PU1501.4 PU1501.10 PU1501.23 PU1501.28 PU1503.3 PU1503.7 PU1503.10 PU1503.13 PU1800.8 PU1800.9 QA1.3 QE5.3 QE20.1 QE20.4 QE21.1 QE21.4 QE23.1 QE23.4 QE24.1 QE24.4 QV2.3 QV3.1 QV20.3 QV21.3 QZ6.1 QZ6.4 QZ7.1 QZ7.4 QZ8.3 RA9.2 RA12.2 RA13.2 RA14.2 RA15.2 RA16.2 RA33.2 RA57.1 RA58.2 RA62.2 RA64.2 RA66.2 RA67.2 RD10.1 RE4.1 RE21.2 RE22.2 RE23.2 RE27.1 RE35.2 RE67.1 RE114.1 RH13.1 RH29.2 RH33.2 RH41.2 RH57.1 RH58.1 RH59.2 RH60.1 RH61.1 RH77.2 RH88.1 RH94.2 RH95.1 RH109.2 RH112.2 RH113.2 RH127.2 RH148.1 RH149.1 RH150.1 RH166.1 RH183.2 RH184.2 RH185.2 RH186.2 RH187.2 RH188.2 RH209.2 RH210.2 RH211.2 RH212.2 RH495.2 RH516.2 RI45.2 RI49.2 RI51.1 RL27.1 RL30.2 RL31.1 RM4.2 RM8.2 RM9.2 RM11.1 RM12.1 RM13.1 RM17.2 RM18.2 RM21.1 RM24.2 RM25.1 RM26.1 RN4.2 RV27.1 RV37.2 RV49.2 RV50.1 RV51.2 RV58.1 RV62.2 RV63.2 RV66.2 RV78.1 RV79.1 RV104.1 RV107.2 RV108.2 RV110.2 RV111.2 RV116.2 RV118.2 RV119.2 RV120.2 RV121.2 RV127.2 RV130.2 RV132.2 RV133.2 RV134.2 RV135.2 RV136.2 RV142.2 RV145.2 RV152.1 RV153.1 RV154.1 RV155.1 RV156.1 RV160.1 RV161.1 RV162.1 RV187.2 RV209.2 RV510.2 RV511.2 RV512.2 RV513.2 RV514.2 RV515.2 RV536.2 RV537.2 RV551.2 RV561.2 RV567.2 RV573.2 RV579.2 RZ40.2 RZ71.2 SW5.4 UA1.2 UA2.4 UA2.7 UA2.11 UA2.17 UA2.20 UA2.21 UA2.24 UA2.33 UC1.3 UC16.3 UE1.17 UE1.51 UE1.64 UE1.84 UE1.100 UE1.124 UE4.2 UE6.3 UH1.A3 UH1.A4 UH1.A6 UH1.A9 UH1.A10 UH1.A12 UH1.A14 UH1.A16 UH1.A18 UH1.A20 UH1.A22 UH1.A24 UH1.A26 UH1.A28 UH1.A30 UH1.A34 UH1.A36 UH1.A37 UH1.AA12 UH1.AA29 UH1.AA30 UH1.AB6 UH1.AB33 UH1.AB34 UH1.AC1 UH1.AC2 UH1.AC3 UH1.AC4 UH1.AC5 UH1.AC6 UH1.AC12 UH1.AC37 UH1.AC38 UH1.AD6 UH1.AD7 UH1.AD8 UH1.AD9 UH1.AD10 UH1.AD11 UH1.AD12 UH1.AD29 UH1.AD30 UH1.AE6 UH1.AE33 UH1.AE34 UH1.AF1 UH1.AF2 UH1.AF3 UH1.AF4 UH1.AF12 UH1.AF13 UH1.AF14 UH1.AG6 UH1.AG7 UH1.AG8 UH1.AG10 UH1.AG11 UH1.AG29 UH1.AG30 UH1.AH6 UH1.AH12 UH1.AH33 UH1.AH34 UH1.AJ1 UH1.AJ2 UH1.AJ3 UH1.AJ4 UH1.AJ5 UH1.AJ6 UH1.AJ37 UH1.AJ38 UH1.AK4 UH1.AK29 UH1.AK30 UH1.AL4 UH1.AL7 UH1.AL8 UH1.AL9 UH1.AL10 UH1.AL12 UH1.AL14 UH1.AL33 UH1.AL34 UH1.AM1 UH1.AM2 UH1.AM3 UH1.AM4 UH1.AM5 UH1.AM12 UH1.AM37 UH1.AM38 UH1.AN5 UH1.AN6 UH1.AN12 UH1.AN29 UH1.AN30 UH1.AP8 UH1.AP9 UH1.AP10 UH1.AP11 UH1.AP12 UH1.AP33 UH1.AP34 UH1.AR1 UH1.AR2 UH1.AR3 UH1.AR4 UH1.AR5 UH1.AR13 UH1.AR14 UH1.AR37 UH1.AR38 UH1.AT6 UH1.AT29 UH1.AT30 UH1.AU6 UH1.AU7 UH1.AU8 UH1.AU9 UH1.AU10 UH1.AU11 UH1.AU12 UH1.AU33 UH1.AU34 UH1.AV37 UH1.AV38 UH1.AW1 UH1.AW2 UH1.AW3 UH1.AW4 UH1.AW5 UH1.AW12 UH1.AW29 UH1.AW30 UH1.AY12 UH1.AY14 UH1.AY33 UH1.AY34 UH1.B3 UH1.B9 UH1.B37 UH1.BA6 UH1.BA7 UH1.BA8 UH1.BA9 UH1.BA10 UH1.BA11 UH1.BA12 UH1.BA37 UH1.BA38 UH1.BB1 UH1.BB2 UH1.BB3 UH1.BB4 UH1.BB5 UH1.BB6 UH1.BB12 UH1.BB29 UH1.BB30 UH1.BC6 UH1.BC12 UH1.BC13 UH1.BC14 UH1.BC33 UH1.BC34 UH1.BD6 UH1.BD7 UH1.BD8 UH1.BD9 UH1.BD10 UH1.BD11 UH1.BD12 UH1.BD37 UH1.BD38 UH1.BE1 UH1.BE2 UH1.BE3 UH1.BE4 UH1.BE5 UH1.BE6 UH1.BE29 UH1.BE30 UH1.BF6 UH1.BF12 UH1.BF33 UH1.BF34 UH1.BG6 UH1.BG12 UH1.BG13 UH1.BG14 UH1.BG37 UH1.BG38 UH1.BH1 UH1.BH2 UH1.BH3 UH1.BH4 UH1.BH5 UH1.BH6 UH1.BH7 UH1.BH8 UH1.BH9 UH1.BH10 UH1.BH11 UH1.BH12 UH1.BH14 UH1.BJ12 UH1.BJ15 UH1.BJ18 UH1.BJ22 UH1.BJ25 UH1.BJ29 UH1.BJ30 UH1.BJ31 UH1.BJ32 UH1.BK6 UH1.BK13 UH1.BK14 UH1.BK15 UH1.BK18 UH1.BK22 UH1.BK25 UH1.BK29 UH1.BL6 UH1.BL13 UH1.BL29 UH1.BL35 UH1.BL38 UH1.BM2 UH1.BM3 UH1.BM5 UH1.BM6 UH1.BM7 UH1.BM8 UH1.BM9 UH1.BM11 UH1.BM12 UH1.BM13 UH1.BM18 UH1.BM21 UH1.BM23 UH1.BM25 UH1.BM26 UH1.BM27 UH1.BM28 UH1.BM29 UH1.BM35 UH1.BM38 UH1.BN2 UH1.BN4 UH1.BN7 UH1.BN9 UH1.BN12 UH1.BN14 UH1.BN18 UH1.BN19 UH1.BN20 UH1.BN21 UH1.BN24 UH1.BN29 UH1.BN30 UH1.BN31 UH1.BN34 UH1.BP7 UH1.BP12 UH1.BP14 UH1.BP18 UH1.BP21 UH1.BP24 UH1.BP26 UH1.BP29 UH1.BP33 UH1.BP34 UH1.BR7 UH1.BR12 UH1.BR14 UH1.BR18 UH1.BR21 UH1.BR24 UH1.BR26 UH1.BR29 UH1.BR34 UH1.BR36 UH1.BR38 UH1.BT3 UH1.BT4 UH1.BT5 UH1.BT9 UH1.BT12 UH1.BT14 UH1.BT18 UH1.BT21 UH1.BT24 UH1.BT26 UH1.BT32 UH1.BT35 UH1.BT36 UH1.C2 UH1.C5 UH1.C8 UH1.C9 UH1.C11 UH1.C13 UH1.C15 UH1.C17 UH1.C19 UH1.C21 UH1.C23 UH1.C25 UH1.C27 UH1.C29 UH1.C31 UH1.C37 UH1.D3 UH1.D6 UH1.D9 UH1.D10 UH1.D12 UH1.D14 UH1.D16 UH1.D18 UH1.D20 UH1.D22 UH1.D24 UH1.D26 UH1.D28 UH1.D30 UH1.D33 UH1.D38 UH1.E4 UH1.E9 UH1.E34 UH1.E35 UH1.E38 UH1.F2 UH1.F3 UH1.F4 UH1.F5 UH1.F8 UH1.F9 UH1.F11 UH1.F13 UH1.F15 UH1.F17 UH1.F19 UH1.F21 UH1.F23 UH1.F25 UH1.F27 UH1.F29 UH1.F31 UH1.F36 UH1.G4 UH1.G5 UH1.G6 UH1.G8 UH1.G9 UH1.G10 UH1.G12 UH1.G14 UH1.G16 UH1.G18 UH1.G20 UH1.G22 UH1.G23 UH1.G24 UH1.G26 UH1.G28 UH1.H11 UH1.H12 UH1.H18 UH1.H22 UH1.H25 UH1.H32 UH1.H35 UH1.J4 UH1.J7 UH1.J10 UH1.J18 UH1.J22 UH1.J25 UH1.J32 UH1.J33 UH1.J36 UH1.K1 UH1.K2 UH1.K3 UH1.K4 UH1.K5 UH1.K7 UH1.K8 UH1.K9 UH1.K10 UH1.K11 UH1.K38 UH1.L29 UH1.L30 UH1.L33 UH1.L34 UH1.M6 UH1.M12 UH1.M13 UH1.M14 UH1.N1 UH1.N2 UH1.N3 UH1.N4 UH1.N5 UH1.N6 UH1.N7 UH1.N8 UH1.N9 UH1.N10 UH1.N11 UH1.N12 UH1.N33 UH1.N34 UH1.P6 UH1.P12 UH1.P37 UH1.P38 UH1.R12 UH1.R29 UH1.R30 UH1.T1 UH1.T2 UH1.T3 UH1.T4 UH1.T5 UH1.T7 UH1.T8 UH1.T9 UH1.T10 UH1.T11 UH1.T12 UH1.T13 UH1.T14 UH1.T33 UH1.T34 UH1.U6 UH1.U37 UH1.U38 UH1.V6 UH1.V12 UH1.V29 UH1.V30 UH1.W1 UH1.W2 UH1.W3 UH1.W4 UH1.W5 UH1.W12 UH1.W33 UH1.W34 UH1.Y7 UH1.Y8 UH1.Y9 UH1.Y10 UH1.Y11 UH1.Y13 UH1.Y14 UH1.Y37 UH1.Y38 UH2.A2 UH2.A3 UH2.A4 UH2.A18 UH2.A25 UH2.A32 UH2.A37 UH2.A42 UH2.A44 UH2.AA4 UH2.AA17 UH2.AA18 UH2.AA20 UH2.AA21 UH2.AA25 UH2.AA29 UH2.AA42 UH2.AB4 UH2.AB5 UH2.AB7 UH2.AB8 UH2.AB10 UH2.AB11 UH2.AB14 UH2.AB15 UH2.AB31 UH2.AB32 UH2.AB38 UH2.AC1 UH2.AC18 UH2.AC20 UH2.AC21 UH2.AC25 UH2.AC29 UH2.AC45 UH2.AD4 UH2.AD8 UH2.AD11 UH2.AD14 UH2.AD32 UH2.AD33 UH2.AD36 UH2.AE4 UH2.AE18 UH2.AE20 UH2.AE21 UH2.AE25 UH2.AE28 UH2.AE29 UH2.AE42 UH2.AF18 UH2.AF20 UH2.AF21 UH2.AF23 UH2.AF25 UH2.AF26 UH2.AF28 UH2.AF29 UH2.AG4 UH2.AG11 UH2.AG13 UH2.AG31 UH2.AG32 UH2.AG33 UH2.AG38 UH2.AH1 UH2.AH17 UH2.AH18 UH2.AH20 UH2.AH21 UH2.AH23 UH2.AH25 UH2.AH26 UH2.AH28 UH2.AH29 UH2.AH45 UH2.AJ10 UH2.AJ14 UH2.AJ15 UH2.AJ17 UH2.AJ18 UH2.AJ26 UH2.AJ28 UH2.AJ29 UH2.AJ31 UH2.AJ32 UH2.AJ36 UH2.AK4 UH2.AK42 UH2.AL4 UH2.AL10 UH2.AL11 UH2.AL13 UH2.AL17 UH2.AL19 UH2.AL24 UH2.AL29 UH2.AL32 UH2.AL33 UH2.AL38 UH2.AM15 UH2.AM17 UH2.AM19 UH2.AM22 UH2.AM24 UH2.AM27 UH2.AM29 UH2.AM45 UH2.AN4 UH2.AN7 UH2.AN8 UH2.AN10 UH2.AN11 UH2.AN22 UH2.AN27 UH2.AN31 UH2.AN39 UH2.AP4 UH2.AP11 UH2.AR5 UH2.AR7 UH2.AR9 UH2.AR33 UH2.AR34 UH2.AR42 UH2.AT9 UH2.AT10 UH2.AT15 UH2.AT36 UH2.AU1 UH2.AU7 UH2.AU35 UH2.AU36 UH2.AU39 UH2.AU45 UH2.AV6 UH2.AV17 UH2.AV24 UH2.AV27 UH2.AV31 UH2.AV33 UH2.AW9 UH2.AW13 UH2.AW19 UH2.AW29 UH2.AW37 UH2.AY38 UH2.AY45 UH2.B1 UH2.B2 UH2.B3 UH2.B6 UH2.B25 UH2.B37 UH2.B40 UH2.B44 UH2.B45 UH2.BA1 UH2.BB1 UH2.BB11 UH2.BB16 UH2.BB21 UH2.BB25 UH2.BB30 UH2.BB34 UH2.BC1 UH2.BC2 UH2.BD2 UH2.BD43 UH2.BD44 UH2.BD45 UH2.BE9 UH2.BE14 UH2.BE18 UH2.BE23 UH2.BE28 UH2.BE32 UH2.BE37 UH2.BE40 UH2.BE44 UH2.C1 UH2.C2 UH2.C4 UH2.C10 UH2.C28 UH2.C37 UH2.C42 UH2.D1 UH2.D10 UH2.D12 UH2.D15 UH2.D16 UH2.D17 UH2.D19 UH2.D21 UH2.D24 UH2.D25 UH2.D27 UH2.D29 UH2.D30 UH2.D31 UH2.D33 UH2.D35 UH2.D36 UH2.D45 UH2.E13 UH2.E15 UH2.E31 UH2.E33 UH2.F8 UH2.F44 UH2.G9 UH2.G42 UH2.H3 UH2.H17 UH2.H19 UH2.H22 UH2.H24 UH2.H27 UH2.H29 UH2.H35 UH2.J3 UH2.J5 UH2.J7 UH2.J10 UH2.J11 UH2.J39 UH2.K4 UH2.K10 UH2.K27 UH2.K33 UH2.K36 UH2.K42 UH2.K43 UH2.L4 UH2.L8 UH2.L12 UH2.L13 UH2.L15 UH2.L41 UH2.M35 UH2.M42 UH2.N4 UH2.N5 UH2.N10 UH2.N15 UH2.N19 UH2.N22 UH2.N24 UH2.N35 UH2.N36 UH2.N41 UH2.P17 UH2.P19 UH2.P22 UH2.P45 UH2.R5 UH2.R10 UH2.R14 UH2.R22 UH2.R29 UH2.R33 UH2.R38 UH2.T1 UH2.T2 UH2.T4 UH2.T42 UH2.U4 UH2.U8 UH2.U10 UH2.U11 UH2.U14 UH2.U15 UH2.U17 UH2.U18 UH2.U28 UH2.U29 UH2.U31 UH2.U32 UH2.U33 UH2.U38 UH2.V3 UH2.V18 UH2.V20 UH2.V21 UH2.V23 UH2.V25 UH2.V29 UH2.V45 UH2.W4 UH2.W8 UH2.W14 UH2.W31 UH2.W32 UH2.W33 UH2.W38 UH2.Y17 UH2.Y18 UH2.Y20 UH2.Y21 UH2.Y26 UH2.Y28 UH2.Y29 UH7.3 UH8.4 UH14.3 UL1.33 UL2.2 UM1.B3 UM1.B6 UM1.D4 UM1.D5 UM1.E4 UM1.E5 UM1.G3 UM1.G6 UM2.4 US1.14 US1.17 US2.2 UT1.6 UV1.A2 UV1.A33 UV1.AA13 UV1.AA15 UV1.AA17 UV1.AA18 UV1.AA20 UV1.AA22 UV1.AB2 UV1.AB5 UV1.AB7 UV1.AB12 UV1.AB14 UV1.AB16 UV1.AB19 UV1.AB21 UV1.AB23 UV1.AB28 UV1.AB30 UV1.AB32 UV1.AC13 UV1.AC15 UV1.AC17 UV1.AC18 UV1.AC20 UV1.AC22 UV1.AE2 UV1.AE5 UV1.AE7 UV1.AE28 UV1.AE30 UV1.AE32 UV1.AE33 UV1.AG11 UV1.AH2 UV1.AH5 UV1.AH7 UV1.AH10 UV1.AH11 UV1.AH13 UV1.AH16 UV1.AH19 UV1.AH22 UV1.AH24 UV1.AH28 UV1.AH29 UV1.AH30 UV1.AH32 UV1.AH33 UV1.AJ7 UV1.AK7 UV1.AK10 UV1.AL2 UV1.AL5 UV1.AL12 UV1.AL14 UV1.AL15 UV1.AL17 UV1.AL18 UV1.AL20 UV1.AL21 UV1.AL23 UV1.AL24 UV1.AL26 UV1.AL28 UV1.AL30 UV1.AL32 UV1.AL33 UV1.AM13 UV1.AM16 UV1.AM19 UV1.AM22 UV1.AM25 UV1.AN1 UV1.AN4 UV1.AN7 UV1.AN10 UV1.AN13 UV1.AN16 UV1.AN19 UV1.AN22 UV1.AN25 UV1.AN30 UV1.AN34 UV1.AP2 UV1.AP33 UV1.B1 UV1.B4 UV1.B7 UV1.B10 UV1.B22 UV1.B25 UV1.B28 UV1.B31 UV1.B34 UV1.C7 UV1.C10 UV1.C13 UV1.C16 UV1.C19 UV1.C22 UV1.C25 UV1.C28 UV1.D2 UV1.D31 UV1.D33 UV1.E5 UV1.E7 UV1.E10 UV1.E22 UV1.E25 UV1.F7 UV1.F28 UV1.G2 UV1.G3 UV1.G5 UV1.G7 UV1.G10 UV1.G13 UV1.G16 UV1.G19 UV1.G22 UV1.G25 UV1.G28 UV1.G30 UV1.G32 UV1.G33 UV1.K2 UV1.K5 UV1.K7 UV1.K28 UV1.K30 UV1.K32 UV1.K33 UV1.M13 UV1.M15 UV1.M17 UV1.M18 UV1.M20 UV1.M22 UV1.N2 UV1.N5 UV1.N7 UV1.N12 UV1.N14 UV1.N16 UV1.N19 UV1.N21 UV1.N23 UV1.N28 UV1.N30 UV1.N32 UV1.N33 UV1.P13 UV1.P15 UV1.P17 UV1.P18 UV1.P20 UV1.P22 UV1.R12 UV1.R14 UV1.R16 UV1.R19 UV1.R21 UV1.R23 UV1.T2 UV1.T5 UV1.T7 UV1.T13 UV1.T15 UV1.T17 UV1.T18 UV1.T20 UV1.T22 UV1.T28 UV1.T32 UV1.U12 UV1.U14 UV1.U16 UV1.U19 UV1.U21 UV1.U23 UV1.V12 UV1.V14 UV1.V16 UV1.V19 UV1.V21 UV1.V23 UV1.W13 UV1.W15 UV1.W17 UV1.W18 UV1.W20 UV1.W22 UV1.W28 UV1.W32 UV1.Y12 UV1.Y14 UV1.Y16 UV1.Y19 UV1.Y21 UV1.Y23 UV6.A1 UV6.A3 UV6.A12 UV6.A14 UV6.B5 UV6.B10 UV6.C1 UV6.C3 UV6.C4 UV6.C11 UV6.C12 UV6.C14 UV6.D10 UV6.E1 UV6.E3 UV6.E12 UV6.E14 UV6.F5 UV6.F10 UV6.G5 UV6.G10 UV6.H1 UV6.H2 UV6.H13 UV6.H14 UV6.K1 UV6.K2 UV6.K13 UV6.K14 UV6.L5 UV6.L10 UV6.M5 UV6.M10 UV6.N1 UV6.N3 UV6.N12 UV6.N14 UV6.P10 UV6.R1 UV6.R3 UV6.R4 UV6.R11 UV6.R12 UV6.R14 UV6.T5 UV6.T10 UV6.U1 UV6.U3 UV6.U12 UV6.U14 UV7.A1 UV7.A3 UV7.A12 UV7.A14 UV7.B5 UV7.B10 UV7.C1 UV7.C3 UV7.C4 UV7.C11 UV7.C12 UV7.C14 UV7.D10 UV7.E1 UV7.E3 UV7.E12 UV7.E14 UV7.F5 UV7.F10 UV7.G5 UV7.G10 UV7.H1 UV7.H2 UV7.H13 UV7.H14 UV7.K1 UV7.K2 UV7.K13 UV7.K14 UV7.L5 UV7.L10 UV7.M5 UV7.M10 UV7.N1 UV7.N3 UV7.N12 UV7.N14 UV7.P10 UV7.R1 UV7.R3 UV7.R4 UV7.R11 UV7.R12 UV7.R14 UV7.T5 UV7.T10 UV7.U1 UV7.U3 UV7.U12 UV7.U14 UV8.A1 UV8.A3 UV8.A12 UV8.A14 UV8.B5 UV8.B10 UV8.C1 UV8.C3 UV8.C4 UV8.C11 UV8.C12 UV8.C14 UV8.D10 UV8.E1 UV8.E3 UV8.E12 UV8.E14 UV8.F5 UV8.F10 UV8.G5 UV8.G10 UV8.H1 UV8.H2 UV8.H13 UV8.H14 UV8.K1 UV8.K2 UV8.K13 UV8.K14 UV8.L5 UV8.L10 UV8.M5 UV8.M10 UV8.N1 UV8.N3 UV8.N12 UV8.N14 UV8.P10 UV8.R1 UV8.R3 UV8.R4 UV8.R11 UV8.R12 UV8.R14 UV8.T5 UV8.T10 UV8.U1 UV8.U3 UV8.U12 UV8.U14 UV9.A1 UV9.A3 UV9.A12 UV9.A14 UV9.B5 UV9.B10 UV9.C1 UV9.C3 UV9.C4 UV9.C11 UV9.C12 UV9.C14 UV9.D10 UV9.E1 UV9.E3 UV9.E12 UV9.E14 UV9.F5 UV9.F10 UV9.G5 UV9.G10 UV9.H1 UV9.H2 UV9.H13 UV9.H14 UV9.K1 UV9.K2 UV9.K13 UV9.K14 UV9.L5 UV9.L10 UV9.M5 UV9.M10 UV9.N1 UV9.N3 UV9.N12 UV9.N14 UV9.P10 UV9.R1 UV9.R3 UV9.R4 UV9.R11 UV9.R12 UV9.R14 UV9.T5 UV9.T10 UV9.U1 UV9.U3 UV9.U12 UV9.U14 UV11.3 UV14.3 UV17.2 UV18.3 UZ1.11 UZ1.15 UZ8.2 UZ9.5 UZ15.5 UZ16.5 UZ16.9 UZ17.5 UZ17.9 UZ21.3 UZ22.5 UZ22.9 UZ23.3 YH2.2 YH2.4 YL2.2 YL2.4 YM1.2 YM1.4 YV1.2 YV1.4
V1N: PR1408.2 PR1411.1 PR1412.1 PR1413.1
V2N: PR1422.2 PR1425.1 PR1426.1 PR1427.1
V3N: PR1436.2 PR1439.1 PR1440.1 PR1441.1
VBATT: PC109.1 PC110.1 PC314.1 PC316.1 PC317.1 PD300.2 PL107.1 PL108.1 PR314.4
VCC_CORE_PT1: PT1400.1(TP-1) PU1400.22
VCC_CORE_PT2: PT1401.1(TP-1) PU1401.22
VCC_CORE_PT3: PT1402.1(TP-1) PU1402.22
VCC_GT_PT1: PT1500.1(TP-1) PU1500.22
VCC_GT_PT2: PT1501.1(TP-1) PU1501.22
VCC_SA_PT1: PT1503.1(TP-1) PU1503.9
VCC_SENSE: PC1134.2 PR1146.2 RH198.2
VCCGT_B+: PC1503.1 PC1504.1 PC1505.1 PC1506.1 PC1511.1 PC1512.1 PC1513.1 PC1514.1 PJP1500.2 PL1500.2 PL1501.2 PU1500.8 PU1500.9 PU1501.8 PU1501.9
VCCGT_SENSE: PC1109.1 PR1127.1 RH204.2
VCCIO_PG: PR712.1 PU700.9
VCCIO_SENSE: PR705.2 RH514.2
VCCSA_SENSE: PC1115.2 PR1129.2 RH202.2
VCCSENSE_VGA: PR1017.1 UV1.L4
VCCST: CZ28.1 RZ66.1 UZ15.6
VCCST_PWRGD_CPU: RH154.2 UH1.H13
VCCSTG: RZ48.2 UZ9.6
VIN: PC105.1 PC106.1 PC107.1 PC303.1 PC324.1 PD300.3 PL100.2 PL101.2 PQ301.5 PQ306.5 PR203.1 PR209.1 PR210.1 PR317.1
VSS_SENSE: PC1135.1 PU1100.18 RH28.2
VSSGT_SENSE: PC1114.1 PU1100.6 RH32.2
VSSIO_SENSE: PR710.2 RH513.2
VSSSA_SENSE: PC1116.1 PU1100.31 RH31.2
VSSSENSE_VGA: PR1012.1 UV1.L5
+AMP: CA52.1 CA53.1 CA54.1 CA55.1 CA56.1 CA57.1 RA75.2 RA76.2 UA2.12 UA2.13 UA2.14 UA2.27 UA2.28
+CHGRTC: DC2.3 PJP1304.2
+DC_IN: JADP10.5 JADP10.6 JADP10.7 PC100.1 PC101.1 PC102.1 PC103.1 PC104.1 PL100.1 PL101.1
+DCPRTC: CH70.1 UH2.BA26
+EDPVDD: CV576.1 CV577.1 CZ41.1 JEDP1.20 JEDP1.21 JEDP1.22 PJP35.2
+FB_PLLAVDD: CV151.1 CV152.1 CV153.1 CV154.1 CV155.1 CV156.1 LV13.2 UV1.H17 UV1.K27 UV1.U27
+FBA_VREFC0: CV158.1 RV125.2 RV126.2 RV127.1 UV6.J14 UV7.J14
+FBA_VREFD_L: CV159.1 RV128.2 RV129.2 RV130.1 UV6.A10 UV6.U10 UV7.A10 UV7.U10
+FBC_VREFC1: CV177.1 RV140.2 RV141.2 RV142.1 UV8.J14 UV9.J14
+FBC_VREFD_H: CV178.1 RV143.2 RV144.2 RV145.1 UV8.A10 UV8.U10 UV9.A10 UV9.U10
+GPU_CORE: PC1010.1 PC1011.1 PC1012.1 PC1013.1 PC1014.1 PC1015.1 PC1016.1 PC1017.1 PC1018.1 PC1019.1 PC1021.1 PC1022.1 PC1023.1 PC1024.1 PC1025.1 PC1026.1 PC1027.1 PC1028.1 PC1029.1 PC1034.1 PC1035.1 PC1036.1 PC1037.1 PC1038.1 PC1039.1 PC1040.1 PC1041.1 PC1051.1 PC1052.1 PC1053.1 PC1054.1 PC1055.1 PC1062.1 PC1063.1 PC1064.1 PC1065.1 PC1066.1 PC1067.1 PC1068.1 PC1069.1 PC1070.1 PC1071.1 PC1072.1 PC1073.1 PC1074.1 PC1075.1 PC1077.1 PC1079.1 PC1080.1 PC1081.1 PC1083.1 PC1084.1 PC1085.1 PC1086.1 PC1087.1 PL1002.2 PL1003.2 PL1004.2 PR1019.1 RZ10.1 UV1.AA12 UV1.AA14 UV1.AA16 UV1.AA19 UV1.AA21 UV1.AA23 UV1.AB13 UV1.AB15 UV1.AB17 UV1.AB18 UV1.AB20 UV1.AB22 UV1.AC12 UV1.AC14 UV1.AC16 UV1.AC19 UV1.AC21 UV1.AC23 UV1.M12 UV1.M14 UV1.M16 UV1.M19 UV1.M21 UV1.M23 UV1.N13 UV1.N15 UV1.N17 UV1.N18 UV1.N20 UV1.N22 UV1.P12 UV1.P14 UV1.P16 UV1.P19 UV1.P21 UV1.P23 UV1.R13 UV1.R15 UV1.R17 UV1.R18 UV1.R20 UV1.R22 UV1.T12 UV1.T14 UV1.T16 UV1.T19 UV1.T21 UV1.T23 UV1.U13 UV1.U15 UV1.U17 UV1.U18 UV1.U20 UV1.U22 UV1.V13 UV1.V15 UV1.V17 UV1.V18 UV1.V20 UV1.V22 UV1.W12 UV1.W14 UV1.W16 UV1.W19 UV1.W21 UV1.W23 UV1.Y13 UV1.Y15 UV1.Y17 UV1.Y18 UV1.Y20 UV1.Y22
+INV_PWR_SRC: CV579.1 JEDP1.1 JEDP1.2 JEDP1.3 QV11.1 QV11.2 QV11.5 QV11.6
+LAN_IO: CL15.1 CL19.1 CL21.1 CL43.1 CL44.1 RL42.1 UL1.11 UL1.23 UL1.32 UL2.1
+LAN_VDD: CL20.1 CL22.1 CL24.1 CL32.1 CL34.1 CL35.1 CL42.1 UL1.3 UL1.8 UL1.22 UL1.24 UL1.30
+PLLVDD: CV72.1 CV73.1 LV8.1 RV45.1 UV1.AD8
+RTCBATT: JRTC.1 RC11.2
+RTCVCC: CC27.1 CH80.1 CH173.1 DC2.1 RA18.2 RE16.1 RE31.1 RE52.2 RH83.1 RH84.1 RH143.2 UH2.BA22
+RTCVCC_VBAT: CE73.1 RE16.2 UE1.122
+SP_PLLVDD: CV50.1 CV51.1 CV52.1 CV53.1 LV7.2 RV45.2 UV1.AD7 UV1.AE8
+V_DAC: CL41.1 TL2.1 TL2.4 TL2.7 TL2.10
+V_DDR_REFA: CD96.1 JDIMM1.164 RH45.2 RH206.2 RH209.1
+V_DDR_REFA_R: CH101.1 RH45.1 UH1.BN13
+V_DDR_REFB: CD29.1 JDIMM2.164 RH46.2 RH207.2 RH210.1
+V_DDR_REFB_R: CH100.1 RH46.1 UH1.BR13
+VDISPLAY_VCC: CV597.1 CV598.1 JHDMI1.18 RM1.2 RM2.2 UV17.3
+VGA_B+: PC1002.1 PC1003.1 PC1004.1 PC1005.1 PC1006.1 PC1007.1 PC1043.1 PC1044.1 PC1045.1 PC1047.1 PC1048.1 PC1057.1 PC1058.1 PC1059.1 PC1060.1 PC1061.1 PL1000.1 PL1001.1 PQ1000.2 PQ1001.2 PQ1002.2 PQ1004.2 PQ1005.2 PQ1006.2 PR1010.1
-DC_IN: JADP10.1 JADP10.2 JADP10.3 PC102.2 PC103.2 PC104.2 PC108.1 PL102.1 PL103.1 PL104.1 PL105.1
AC_PRESENT: DV1.2 RH125.1 UH2.BB15
ACAV_IN: CE84.2 DV1.1 PR212.1 PR316.2 PR318.1 PU300.5 UE1.128
ACDET_CHG: PC323.1 PR317.2 PR323.1 PU300.6
ACDRV_CHG: PR308.2 PU300.4
ALL_GPWRGD: RV56.2 RV572.1 RV579.1 UV11.4
ALL_SYS_PWRGD: PQ403.2 RE62.1 RH105.2 RH106.1
ALW_PWRGD_3V_5V: PR408.1 PR603.1
ALWON: PR418.1 UE1.121
AUD_AGND: CA1.2 CA2.2 CA16.1 CA17.2 CA18.2 CA19.1 CA22.1 CA23.2 CA24.2 CA40.2 CA41.2 CA42.2 CA43.2 CA63.1 HDA1.25 HDA1.38 JHP1.5 JHP1.7 RA9.1 RA11.1 RA12.1 RA13.1 RA14.1 RA15.1 RA16.1 RA54.2 RA55.2 RA71.2 RA73.2
AUD_AZA_CPU_SCLK: RH147.1 UH1.G27
AUD_AZA_CPU_SCLK_R: RH147.2 UH2.AM2
AUD_AZA_CPU_SDI_R: RH145.2 UH2.AN2
AUD_AZA_CPU_SDO: RH146.1 UH1.G25
AUD_AZA_CPU_SDO_R: RH146.2 UH2.AM1
AUD_HP1_JACK_L: HDA1.32 RA44.1
AUD_HP1_JACK_L1: LA20.1 RA44.2 RA46.2 RA48.2
AUD_HP1_JACK_R: HDA1.33 RA49.1
AUD_HP1_JACK_R1: LA21.1 RA49.2 RA51.2 RA53.2
AUD_PC_BEEP: CA29.2 RA19.2
AUD_PC_BEEP_C: D1.1 RA30.1
AUD_PORTA_L_R_B: CA41.1 DA5.3 JHP1.1 LA20.2 RA55.1
AUD_PORTA_R_R_B: CA40.1 DA4.3 JHP1.2 LA21.2 RA54.1
AUD_SENSE: RA22.2 RA56.2
AUD_SENSE_A: CA24.1 HDA1.13 RA22.1 RA24.2
AUD_SPK_L+: HDA1.42 LA25.1
AUD_SPK_L+_C: CA37.1 DA2.3 JSPK1.3 LA25.2
AUD_SPK_L-: HDA1.43 LA26.1
AUD_SPK_L-_C: CA36.1 DA2.2 JSPK1.4 LA26.2
AUD_SPK_R+: HDA1.45 LA23.1
AUD_SPK_R+_C: CA39.1 DA3.3 JSPK1.1 LA23.2
AUD_SPK_R-: HDA1.44 LA24.1
AUD_SPK_R-_C: CA38.1 DA3.2 JSPK1.2 LA24.2
B+: CA66.1 CV578.1 PC113.1 PC1403.1 PJ600.1 PJ700.1 PJ800.1 PJP300.1 PJP400.1 PJP900.2 PJP1400.1 PJP1500.1 PJP1501.1 PL300.1 PL301.1 PL400.1 PL401.1 PL500.1 PL600.1 PL700.1 PL800.1 PL900.2 PL1000.2 PL1001.2 PL1400.1 PL1401.1 PL1500.1 PL1501.1 PL1504.1 PQ102.1 PQ102.2 PQ102.3 PQ303.5 PR106.1 PR302.4 QA2.4 QV11.4 RA80.1 RV535.1
B++: PC403.1 PC404.1 PC405.1 PC406.1 PC407.1 PC408.1 PC409.1 PC410.1 PJP400.2 PL400.2 PL401.2 PQ400.5 PQ401.2 PR416.1
B+_AMP: CA67.1 QA2.1 QA2.2 QA2.5 QA2.6 RA76.1
B+_CAM: JCAM1.14 PC114.1 PQ102.5
BAT1_LED#: QE20.5 RE39.1 UE1.1
BAT2_LED#: QE23.2 RE113.1 UE1.106
BATDRV_CHG: PR306.2 PU300.18
BATSRC_CHG: PR307.2 PU300.17
BATT++: JBAT10.1 JBAT10.2 JBAT10.3 PC111.1 PC112.1 PL107.2 PL108.2
BATT_PRS#: JBAT10.6 PR111.1
BBS_BIT0: RH130.2 UH2.AT29
BEEP: D1.2 UE1.45
BIA_PWM_PCH: DV2.2 RH20.2 UH2.W36
BOARD_ID: CE98.1 RE13.2 RE14.2 UE1.111
BOARD_ID_14_15: RH494.2 RH495.1 UH2.AL35
BREATH_LED: JPW.2 LED3.1 LED4.1 QE24.3
BREATH_LED#_EC: QE24.2 RE119.1 UE1.70
BST1_3V: PC411.2 PR412.1
BST1_5V: PC412.1 PR413.2
BST_1VALWP: PR601.1 PU600.1
BST_1VALWP_R: PC605.1 PR601.2
BST_3V: PR412.2 PU400.9
BST_5V: PR413.1 PU400.17
BST_+0.95VSP: PR701.1 PU700.1
BST_+0.95VSP_R: PC701.1 PR701.2
BST_+1.05VSP: PR803.1 PU800.1
BST_+1.05VSP_R: PC803.1 PR803.2
BST_+1.35VS_VGAP: PR901.1 PU900.10
BT_RADIO_DIS#: DN2.1 UH2.AV43
BT_RADIO_DIS#_R: DN2.2 JNGFF1.46
BTST_CHG: PR311.2 PU300.25
CAM_CBL_DET#: JCAM1.10 RH79.1 UH2.U43
CAP_LED: JKB1.4 RE2.2
CAPS_LED#: QE3.3 RE120.1 UE1.93
CFG0: RH183.1 UH1.BN25
CFG2: RH184.1 UH1.BN26
CFG4: RH185.1 UH1.BR20
CFG5: RH186.1 UH1.BM20
CFG6: RH187.1 UH1.BT20
CFG7: RH188.1 UH1.BP20
CFG_RCOMP: RH59.1 UH1.BT25
CHG_B+: PC305.1 PC306.1 PC307.1 PC308.1 PJP300.2 PL300.2 PL301.2 PQ304.5
CHG_SMBCLK: PR328.1 PU300.12
CHG_SMBDAT: PR327.1 PU300.11
CLK_PCI_LPC_MEC: CC4.2 RE10.2 RH168.2 UE1.57
CLK_PCI_LPDEBUG: CC5.2 JLPDE1.10 JNGFF1.22 RH16.2
CLK_PCIE_LAN: UH2.F2 UL1.15
CLK_PCIE_LAN#: UH2.D3 UL1.16
CLK_PCIE_SSD: JNGFF2.55 UH2.R7
CLK_PCIE_SSD#: JNGFF2.53 UH2.R8
CLK_PCIE_WLAN: JNGFF1.39 UH2.G4
CLK_PCIE_WLAN#: JNGFF1.41 UH2.E5
CLK_PEG_N16P: UH2.U3 UV1.AL13
CLK_PEG_N16P#: UH2.U2 UV1.AK13
CLK_REQ: QV3.4 RV57.1 UV1.AK12
CLK_SMB: JBAT10.4 PR108.1
CLK_TP_SIO: CE10.1 DE4.4 JTP.1 RE24.2 UE1.78
CLKDET#: RH126.1 UH2.BB22
CLKOUT_LPC0: RH168.1 UH2.BC17
CLKOUT_LPC1: RH16.1 UH2.AV19
CLKREQ_PCIE#0: RP2.6 UH2.BC24
CLKRUN#: RH85.1 UE1.63 UH2.AW22
CMP_STRAP0: RE28.1 UE1.118
CMP_VIN0: RE33.1 RE73.1 UE1.20
CMP_VOUT0: PR419.1 QV88.1 RE33.2 RE38.2 UE1.85
CMPIN: PR200.2 PR201.1 PU300.13
CMPOUT: PR205.2 PR206.1 PR207.1 PU300.14
CMSRC_CHG: PR309.2 PU300.3
CODEC_BITCLK_R: HDA1.6 RA31.2
CODEC_SDOUT_R: HDA1.5 RA29.2
CPU_24MHZ_N: UH1.D31 UH2.F1
CPU_24MHZ_P: UH1.E31 UH2.G1
CPU_TRIGGER: RH192.1 UH2.AK1
CPU_TRIGGER_R: RH192.2 UH1.J23
CPU_XDP_TCK: RH38.2 RH61.2 UH1.BR28
CPU_XDP_TDI: RH56.2 RH118.2 UH1.BL32
CPU_XDP_TDO: RH115.2 RH497.2 UH1.BT28
CPU_XDP_TMS: RH492.2 RH496.2 UH1.BP28
CPU_XDP_TRST#: RH60.2 UH1.BP30 UH2.AY5
CSON_1: PC319.2 PC320.1 PR314.3 PR324.2
CSOP_1: PC318.2 PC319.1 PR314.2 PR322.2
CSSN_1: PR302.3 PR305.1
CSSN_2: PC310.2 PC311.1 PR305.2 PU300.1
CSSP_1: PR302.2 PR304.1
CSSP_2: PC309.2 PC310.1 PR304.2 PU300.2
DAT_SMB: JBAT10.5 PR109.1
DAT_TP_SIO: CE9.1 DE4.6 JTP.2 RE55.2 UE1.79
DDC_CLK_HDMI: JHDMI1.15 RM1.1 UM1.E1
DDC_DAT_HDMI: JHDMI1.16 RM2.1 UM1.F1
DDI1_CPU_AUXN: CM46.2 UH1.E27
DDI1_CPU_AUXN_C: CM21.1 UM1.C8
DDI1_CPU_AUXP: CM45.2 UH1.D27
DDI1_CPU_AUXP_C: CM20.1 UM1.C7
DDI1_DDPB_CTRLCLK: RH141.1 UH2.BA5
DDI1_DDPB_CTRLDAT: RH142.1 UH2.BC4
DDI1_HTX_TBRX_N0: CM7.2 UH1.K37
DDI1_HTX_TBRX_N0_C: CM7.1 UM1.A7
DDI1_HTX_TBRX_N1: CM15.2 UH1.J34
DDI1_HTX_TBRX_N1_C: CM15.1 UM1.A5
DDI1_HTX_TBRX_N2: CM17.2 UH1.H36
DDI1_HTX_TBRX_N2_C: CM17.1 UM1.A3
DDI1_HTX_TBRX_N3: CM19.2 UH1.J38
DDI1_HTX_TBRX_N3_C: CM19.1 UM1.A1
DDI1_HTX_TBRX_P0: CM6.2 UH1.K36
DDI1_HTX_TBRX_P0_C: CM6.1 UM1.A8
DDI1_HTX_TBRX_P1: CM14.2 UH1.J35
DDI1_HTX_TBRX_P1_C: CM14.1 UM1.A6
DDI1_HTX_TBRX_P2: CM16.2 UH1.H37
DDI1_HTX_TBRX_P2_C: CM16.1 UM1.A4
DDI1_HTX_TBRX_P3: CM18.2 UH1.J37
DDI1_HTX_TBRX_P3_C: CM18.1 UM1.A2
DDI1_PCH_HPD: RM3.2 UH2.AW4
DDI1_PCH_HPD_R: RM3.1 UM1.B1
DDR4_DRAMRST#: JDIMM1.108 JDIMM2.108 RD31.1
DDR_A_ACT#: JDIMM1.114 UH1.AU3
DDR_A_ALERT#: JDIMM1.116 UH1.AU5
DDR_A_BG0: JDIMM1.115 UH1.AU1
DDR_A_BG1: JDIMM1.113 UH1.AU2
DDR_A_BS0: JDIMM1.150 UH1.AH5
DDR_A_BS1: JDIMM1.145 UH1.AH1
DDR_A_CAS#: JDIMM1.156 UH1.AD1
DDR_A_D0: JDIMM1.8 UH1.BR6
DDR_A_D1: JDIMM1.7 UH1.BT6
DDR_A_D2: JDIMM1.20 UH1.BP3
DDR_A_D3: JDIMM1.21 UH1.BN3
DDR_A_D4: JDIMM1.4 UH1.BN5
DDR_A_D5: JDIMM1.3 UH1.BP6
DDR_A_D6: JDIMM1.16 UH1.BP2
DDR_A_D7: JDIMM1.17 UH1.BR3
DDR_A_D8: JDIMM1.28 UH1.BK5
DDR_A_D9: JDIMM1.29 UH1.BL4
DDR_A_D10: JDIMM1.41 UH1.BL2
