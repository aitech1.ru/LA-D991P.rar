# Allegro board Dell Inspiron 15 Gaming 7566 Compal LA-D991P BCV00 Rev1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBC_D42: length 29.2
  IN3 w0.102: 180.98,96.89 178.03,96.89 v2(177.59,96.45)
  IN3 w0.145: 180.98,96.89 181.31,97.22 183.82,97.22 187.94,101.34 199.94,101.34 200.29,101.69 200.29,102.83 200.01,103.11 199.34,103.11 v2(198.66,103.79)
  BOTTOM w0.102: v2(177.59,96.45) 177.59,96.51 UV1.G26 ; UV9.T11 v2(198.66,103.79)
FBC_D43: length 30.5
  IN3 w0.102: v2(179.29,98.17) 179.73,97.73 180.48,97.73 180.74,97.99
  IN3 w0.145: 180.74,97.99 180.94,98.19 183.47,98.19 188.78,103.5 189.2,103.5 189.37,103.33 189.37,102.43 189.53,102.27 189.87,102.27 190.04,102.43 190.04,103.33 190.2,103.5 190.55,103.5 190.71,103.33 190.71,102.43 190.87,102.27 191.22,102.27 191.38,102.43 191.38,103.33 191.54,103.5 191.89,103.5 192.05,103.33 192.05,102.43 192.21,102.27 192.56,102.27 192.72,102.43 192.72,103.33 192.88,103.5 196.2,103.5 196.91,104.2 198.07,104.2 198.25,104.38 198.25,104.98 v2(198.66,105.39)
  BOTTOM w0.102: UV1.E27 178.89,97.77 v2(179.29,98.17) ; UV9.T13 v2(198.66,105.39)
FBC_D44: length 29.3
  IN3 w0.102: 184,100.95 182.63,99.58 179.51,99.58 v2(179.29,99.81)
  IN3 w0.145: 184,100.95 184,101.81 189.49,107.31 199.15,107.31 199.87,106.59 199.87,106.01 200.07,105.8 200.42,105.8 200.66,105.56 200.66,104.19 v2(201.06,103.79)
  BOTTOM w0.102: UV9.N11 v2(201.06,103.79) ; UV1.E29 v2(179.29,99.81)
FBC_D45: length 29.7
  IN3 w0.102: 183.52,100.9 182.4,99.79 180.03,99.79 179.56,100.26 178.84,100.26 v2(178.46,99.88) ; 200.65,106.95 200.66,106.94
  IN3 w0.145: 200.66,106.94 200.66,106.03 201.06,105.63 v2(201.06,105.39) ; 183.52,100.9 183.52,101.97 189.34,107.79 199.81,107.79 200.65,106.95
  BOTTOM w0.102: UV9.N13 v2(201.06,105.39) ; UV1.F29 178.04,99.46 v2(178.46,99.88)
FBC_D46: length 33.7
  IN3 w0.102: 182.2,101.06 182.2,100.4 182.04,100.24 180.69,100.24 180.5,100.43 180.5,100.9 180.34,101.06 179.64,101.06 v2(179.29,100.71)
  IN3 w0.145: 182.2,101.06 182.2,101.95 188.98,108.73 201.03,108.73 202.25,107.51 202.25,104.19 v2(201.86,103.79)
  BOTTOM w0.102: UV1.E30 v2(179.29,100.71) ; UV9.M11 v2(201.86,103.79)
FBC_D47: length 29.7
  IN3 w0.102: 183.08,101.13 183.08,100.85 182.25,100.02 180.47,100.02 180.09,100.4 v2(180.09,100.63)
  IN3 w0.145: v2(201.86,105.39) UV9.M13 201.46,107.53 200.72,108.27 189.15,108.27 183.08,102.2 183.08,101.13
  BOTTOM w0.102: v2(180.09,100.63) 179.69,100.23 UV1.D30 ; UV9.M13 v2(201.86,105.39)
FBC_D48: length 38.4
  BOTTOM w0.102: UV1.A32 182.96,102.78
  BOTTOM w0.13: UV9.A11 210.92,104.19 211.87,105.14 211.87,107.43 209.76,109.54 189.52,109.54 v1(188.88,108.91) 183.83,103.85 183.83,103.34 183.27,102.78 182.96,102.78
FBC_D49: length 43.5
  BOTTOM w0.102: UV1.C31 180.91,101.48 181.74,101.48 181.86,101.36 182.39,101.36 182.44,101.41 182.89,101.41
  BOTTOM w0.13: 182.89,101.41 182.99,101.41 183.09,101.51 183.62,101.51 190.54,108.43 v1(192.44,108.43) 192.81,108.43 192.94,108.3 192.94,107.13 193.06,107 193.44,107 193.57,107.13 193.57,108.3 193.7,108.43 194.08,108.43 194.21,108.3 194.21,106.98 194.34,106.85 194.72,106.85 194.85,106.98 194.85,108.3 194.98,108.43 195.33,108.43 195.46,108.3 195.46,107.1 195.59,106.97 195.97,106.97 196.1,107.1 196.1,108.3 196.35,108.55 209.18,108.55 210.76,106.97 210.76,106.29 UV9.A13
FBC_D50: length 43
  BOTTOM w0.102: UV1.C32 180.89,102.31 182.18,102.31 182.62,102.75 182.62,102.95 183.1,103.42 183.13,103.42
  BOTTOM w0.13: 183.13,103.42 183.3,103.58 183.3,104.03 v1(186.78,107.51) 189.29,110.02 210.15,110.02 212.35,107.82 212.35,104.95 211.05,103.65 210.68,103.65 210.55,103.77 209.88,103.77 UV9.B11
FBC_D51: length 37.8
  BOTTOM w0.102: 182.84,102.13 182.27,101.57 181.95,101.57 181.6,101.91 UV1.B32
  BOTTOM w0.13: UV9.B13 209.84,105.42 210.5,105.42 210.6,105.32 211.06,105.32 211.31,105.57 211.31,107.18 209.43,109.06 190.51,109.06 v1(186.06,104.61) 183.6,102.15 182.85,102.15 182.84,102.13
FBC_D52: length 44.3
  BOTTOM w0.102: 183.15,100.87 182.82,100.54 182.82,100.32 182.28,99.78 180.06,99.78 UV1.D29
  BOTTOM w0.13: UV9.E11 207.46,104.6 207.46,106.74 207.61,106.89 207.61,107.53 207.1,108.04 197.75,108.04 196.12,106.42 196.12,105.27 195.92,105.07 195.39,105.07 195.26,105.2 195.26,106.21 195.13,106.34 194.75,106.34 194.62,106.21 194.62,105.17 194.5,105.04 194.1,105.04 193.97,105.17 193.97,106.21 193.84,106.34 193.46,106.34 193.33,106.21 193.33,105.17 193.2,105.04 192.59,105.04 192.46,105.17 192.46,107.49 192.11,107.84 190.64,107.84 v1(188.55,105.76) 183.67,100.87 183.15,100.87
FBC_D53: length 43.3
  BOTTOM w0.102: UV1.A29 182.25,99.41 183.08,100.23 183.18,100.23
  BOTTOM w0.13: UV9.E13 206.72,106.14 206.11,106.14 205.85,106.39 205.85,106.77 205.07,107.56 197.93,107.56 196.76,106.39 196.76,104.84 196.3,104.38 v1(194.35,104.38) 191.8,104.38 191.67,104.51 191.67,107 191.54,107.13 191.17,107.13 191.04,107 191.04,106.24 190.91,106.11 190,106.11 189.87,105.99 189.87,105.61 190,105.48 190.91,105.48 191.04,105.35 191.04,104.51 190.91,104.38 189.25,104.38 189.03,104.16 188.84,104.16 188.4,104.6 188.22,104.6 187.95,104.33 187.95,104.15 188.39,103.71 188.39,103.53 188.13,103.26 187.94,103.26 187.5,103.7 187.32,103.7 187.05,103.43 187.05,103.25 187.49,102.81 187.49,102.62 187.22,102.36 187.04,102.36 186.6,102.8 186.42,102.8 186.15,102.53 186.15,102.34 186.59,101.91 186.59,101.72 186.32,101.45 186.14,101.45 185.7,101.89 185.52,101.89 185.25,101.63 185.25,101.44 185.69,101 185.69,100.82 185.1,100.23 183.18,100.23
FBC_D54: length 42.5
  BOTTOM w0.102: UV1.C29 180.86,99.04 181.37,99.04 181.64,98.77 182.71,98.77 182.89,98.96 183.14,98.96
  BOTTOM w0.13: 183.14,98.96 185.28,98.96 186.37,100.05 186.53,100.05 186.95,100.47 v1(188.27,100.47) 192.36,100.47 192.49,100.6 192.49,103.09 192.62,103.22 192.99,103.22 193.12,103.09 193.12,100.6 193.25,100.47 193.63,100.47 193.76,100.6 193.76,103.09 193.89,103.22 194.27,103.22 194.4,103.09 194.4,102.71 194.49,102.62 195.12,102.62 195.34,102.4 195.34,102.2 195.18,102.05 194.45,102.05 194.35,101.95 194.35,100.98 194.47,100.85 194.78,100.85 196.05,102.12 206.39,102.12 206.68,101.83 206.86,101.83 207.2,102.17 207.2,102.53 206.67,103.06 206.67,103.49 206.26,103.89 UV9.F11
FBC_D55: length 43
  BOTTOM w0.102: 183.15,99.6 183.04,99.6 182.5,99.05 181.74,99.05 181.38,99.41 UV1.B29
  BOTTOM w0.13: 183.15,99.6 183.15,99.59 185.27,99.59 186.18,100.51 186.2,100.51 189.42,103.72 189.84,103.72 189.97,103.59 189.97,102.42 189.84,102.29 188.71,102.29 188.58,102.17 188.58,101.78 188.71,101.66 189.84,101.66 189.97,101.53 189.97,101.08 190.1,100.96 190.48,100.96 190.61,101.08 190.61,103.59 190.74,103.72 191.11,103.72 191.24,103.59 v1(191.24,101.82) 191.24,101.16 191.37,101.03 191.75,101.03 191.88,101.16 191.88,103.59 192.01,103.72 196.05,103.72 197.22,102.56 205.32,102.56 205.8,103.04 205.8,105.34 UV9.F13
FBC_D56: length 35.4
  BOTTOM w0.102: UV1.B21 181.41,92.71 181.87,93.17 182.17,93.17 182.45,92.89 183.12,92.89 183.32,93.09 183.55,93.09
  BOTTOM w0.13: 183.55,93.09 v1(193.25,93.09) 194.1,93.94 210.06,93.94 211.62,95.49 211.62,97.23 UV9.A4
FBC_D57: length 32.3
  BOTTOM w0.102: 184.97,94.22 183.2,94.22 183,94.02 180.88,94.02 UV1.C23
  BOTTOM w0.13: UV9.A2 210.63,96.63 210.63,95.92 210.09,95.39 207.77,95.39 207.5,95.12 207.24,94.86 193.34,94.86 192.71,94.22 v1(191.22,94.22) 184.97,94.22
FBC_D58: length 37.5
  BOTTOM w0.102: 183.66,92.45 183.57,92.36 182.44,92.36 UV1.A21 ; UV9.B4 209.86,98.99 210.48,98.99 210.63,98.85
  BOTTOM w0.13: 210.63,98.85 210.83,98.85 212.1,97.57 212.1,94.53 211.04,93.46 194.6,93.46 193.71,92.57 v1(189.34,92.57) 183.78,92.57 183.66,92.45
FBC_D59: length 35.2
  BOTTOM w0.102: 185,93.73 183.46,93.73 182.95,93.22 182.44,93.22 182.26,93.4 181.78,93.4 181.53,93.14 180.93,93.14 UV1.C21
  BOTTOM w0.13: UV9.B2 209.85,97.38 210.55,97.38 211.14,96.79 211.14,95.72 210.34,94.93 207.96,94.93 207.43,94.4 193.8,94.4 193.13,93.73 v1(187.77,93.73) 185,93.73
FBC_D60: length 32.5
  BOTTOM w0.102: UV1.B24 180.9,95.59 180.9,96.28 180.7,96.48 180.26,96.48 180.1,96.64 180.1,97.11 180.27,97.27 182.35,97.27
  BOTTOM w0.13: UV9.E4 206.64,99.01 206.64,100.07 206.05,100.65 197.37,100.65 195.69,98.97 v1(189.67,98.97) 187.61,98.97 186.12,97.48 182.55,97.48 182.35,97.27
FBC_D61: length 32.7
  BOTTOM w0.102: UV1.C24 180.49,94.98 180.63,94.84 182.72,94.84 183,95.11 185.07,95.11
  BOTTOM w0.13: UV9.E2 206.64,96.57 206.64,95.65 206.23,95.24 205.75,95.24 205.68,95.32 v1(194.04,95.32) 192.93,95.32 192.72,95.11 192.34,95.11 192.21,95.24 192.21,95.49 192.09,95.62 191.7,95.62 191.58,95.49 191.58,95.16 191.45,95.04 191.07,95.04 190.94,95.16 190.94,95.49 190.81,95.62 190.43,95.62 190.3,95.49 190.3,95.16 190.18,95.04 189.79,95.04 189.66,95.16 189.66,95.52 189.54,95.65 189.15,95.65 189.03,95.52 189.03,95.14 188.9,95.01 188.52,95.01 188.39,95.14 188.39,95.49 188.26,95.62 187.88,95.62 187.75,95.49 187.75,95.14 187.62,95.01 187.24,95.01 187.11,95.14 187.11,95.47 186.99,95.6 186.6,95.6 186.48,95.47 186.48,95.24 186.35,95.11 185.07,95.11 185.07,95.11
FBC_D62: length 32.5
  BOTTOM w0.102: 182.45,96.61 182.29,96.45 181.8,96.45 181.34,96.91 UV1.B26
  BOTTOM w0.13: UV9.F4 205.84,99.01 205.84,99.64 205.26,100.22 197.72,100.22 195.25,97.74 194.57,97.74 194.45,97.87 194.45,98.27 194.35,98.36 193.97,98.36 193.84,98.23 193.84,97.87 193.71,97.74 193.34,97.74 193.21,97.87 193.21,98.23 193.08,98.36 192.7,98.36 192.57,98.23 v1(192.57,97.87) 192.44,97.74 192.06,97.74 191.93,97.87 191.93,98.23 191.8,98.36 191.42,98.36 191.29,98.23 191.29,97.87 191.16,97.74 190.79,97.74 190.66,97.87 190.66,98.23 190.53,98.36 190.15,98.36 190.02,98.23 190.02,97.87 189.89,97.74 189.51,97.74 189.38,97.87 189.38,98.23 189.25,98.36 188.87,98.36 188.74,98.23 188.74,97.87 188.61,97.74 187.24,97.74 186.5,97.01 182.84,97.01 182.45,96.61
FBC_D63: length 36
  BOTTOM w0.102: 181.91,96.12 182.5,96.12 182.51,96.12 183.63,96.12
  BOTTOM w0.107: 181.91,96.12 181.72,96.12 181.35,96.48 181.05,96.48 180.63,96.91 UV1.C26
  BOTTOM w0.13: UV9.F2 205.89,96.62 205.89,96.11 205.6,95.82 197.12,95.82 195.97,96.97 195.34,96.97 195.16,96.79 195.16,96.23 195.06,96.13 194.6,96.13 194.5,96.23 194.5,96.85 194.38,96.97 194,96.97 193.87,96.84 193.87,96.25 193.74,96.12 193.36,96.12 193.23,96.25 193.23,96.84 193.1,96.97 192.72,96.97 192.59,96.84 192.59,96.25 192.46,96.12 192.08,96.12 191.96,96.25 191.96,96.84 191.83,96.97 191.45,96.97 191.32,96.84 191.32,96.25 191.19,96.12 190.81,96.12 190.68,96.25 190.68,96.84 190.55,96.97 190.17,96.97 190.04,96.84 190.04,96.25 189.91,96.12 189.53,96.12 189.41,96.25 189.41,96.84 189.28,96.97 188.9,96.97 188.77,96.84 188.77,96.25 188.64,96.12 188.26,96.12 188.13,96.25 188.13,96.84 188,96.97 187.33,96.97 v1(186.89,96.52) 184.03,96.52 183.63,96.12
FBC_DBI0#: length 27.3
  IN3 w0.102: v2(179.29,83.99) 179.87,84.57 183.08,84.57 183.24,84.72
  IN3 w0.145: v2(199.46,87.08) 199.46,87.32 199.06,87.72 199.06,88.25 198.69,88.62 191.98,88.62 191.82,88.46 191.82,88.13 191.7,88 191.28,88 191.15,88.13 191.15,88.46 190.99,88.62 190.64,88.62 190.48,88.46 190.48,88.03 190.35,87.9 189.94,87.9 189.81,88.03 189.81,88.46 189.65,88.62 189.3,88.62 189.14,88.46 189.14,88.1 189.01,87.98 188.6,87.98 188.47,88.1 188.47,88.46 188.31,88.62 187.88,88.62 184.63,85.38 183.89,85.38 183.24,84.72
  BOTTOM w0.102: UV1.E11 178.89,84.39 v2(179.29,83.99) ; UV8.D2 v2(199.46,87.08)
FBC_DBI1#: length 23.1
  IN3 w0.145: v2(179.25,78.09) 179.38,78.22 182.38,78.22 182.73,77.87 183.17,77.87 183.49,78.19 192.47,78.19 193.66,77 198.85,77 199.07,77.22 199.07,77.85 v2(199.46,78.25)
  BOTTOM w0.102: UV8.D13 199.48,78.26 199.48,78.25 v2(199.46,78.25) ; v2(179.25,78.09) 178.87,77.71 UV1.E3
FBC_DBI2#: length 30.4
  TOP w0.13: v2(183.7,76.94) v1(183.13,77.51)
  IN1 w0.147: v2(208.26,78.28) 207.61,78.28 206.36,77.03 204.7,77.03 203.84,76.16 192.69,76.16 192.03,76.83 187.67,76.83 186.52,77.97 184.02,77.97 183.77,77.71 183.77,77.01 v2(183.7,76.94)
  BOTTOM w0.102: v2(183.7,76.94) 183.7,77.02 183.69,77.03 183.69,77.04 183.38,77.36 182.73,77.36 182.55,77.53 182.26,77.53 UV1.A3 ; UV8.P13 v2(208.26,78.28)
FBC_DBI3#: length 37.2
  BOTTOM w0.102: 185.02,83.87 184.69,83.54 181.85,83.54 181.44,83.12 180.91,83.12 UV1.C9
  BOTTOM w0.13: 185.02,83.87 188.58,83.87 v1(189.87,85.16) 192.29,87.58 193.17,87.58 196.17,90.58 207.32,90.58 209.66,88.24 209.66,87.8 209.84,87.62 209.84,87.25 209.65,87.06 209.36,87.06 209.05,86.75 209.05,86.44 208.93,86.31 208.23,86.31 UV8.P2
FBC_DBI4#: length 25.4
  IN3 w0.102: v2(177.87,93.43) 178.02,93.59 181.58,93.59 182.03,94.05 183.15,94.05 183.32,93.88
  IN3 w0.145: v2(199.46,97.39) 199.06,96.99 199.06,96.42 196.79,94.15 186.22,94.15 185.85,93.78 184.92,93.78 184.92,93.77 184.55,93.77 184.55,93.78 183.42,93.78 183.32,93.88
  BOTTOM w0.102: UV1.F23 178.04,93.61 v2(177.87,93.43) ; UV9.P2 v2(199.46,97.39)
FBC_DBI5#: length 29.9
  IN3 w0.102: v2(177.61,98.17) 178.81,99.36 180.29,99.36 180.43,99.23 182.76,99.23 184.48,100.96
  IN3 w0.145: v2(200.26,105.39) 200.06,105.39 199.67,105.78 199.28,105.78 199.07,106 199.07,106.5 198.83,106.74 191.41,106.74 191.25,106.57 191.25,106.04 191.13,105.91 190.71,105.91 190.58,106.04 190.58,106.44 190.45,106.57 189.82,106.57 189.69,106.44 189.69,106.16 189.57,106.04 189.01,106.04 184.48,101.51 184.48,100.96
  BOTTOM w0.102: v2(177.61,98.17) 178.04,97.74 UV1.F27 ; UV9.P13 v2(200.26,105.39)
FBC_DBI6#: length 35.7
  IN3 w0.145: v2(208.26,105.43) 207.11,106.58 206.48,106.58 203.18,109.87 188.45,109.87 184.54,105.96 183.6,105.96 182.18,104.54 182.18,103.62 180.89,102.33 v2(180.89,100.63)
  BOTTOM w0.102: v2(180.89,100.63) 180.49,100.23 UV1.C30
  BOTTOM w0.13: v2(208.26,105.43) 207.9,105.79 UV9.D13
FBC_DBI7#: length 33.3
  IN1 w0.147: v2(185.12,95.68) 185.12,95.86 190.32,101.06 206.93,101.06 208.65,99.34 208.65,96.99 v2(208.26,96.59)
  BOTTOM w0.107: UV9.D2 v2(208.26,96.59)
  BOTTOM w0.13: v2(185.12,95.68) 185.12,95.65 185.08,95.7 182.58,95.7 UV1.A24
FBC_EDC0: length 26.5
  IN3 w0.145: v2(199.46,86.28) 199.06,86.68 199.06,87.25 198.83,87.48 197.35,87.48 197.19,87.64 197.19,87.85 197.06,87.98 196.64,87.98 196.52,87.85 196.52,87.54 196.39,87.42 195.97,87.42 195.85,87.54 195.85,87.87 195.72,88 195.29,88 195.16,87.87 195.16,87.44 195.03,87.32 194.7,87.32 194.57,87.44 194.57,87.9 194.45,88.03 194.11,88.03 193.98,87.9 193.98,87.49 193.85,87.37 193.44,87.37 193.31,87.49 193.31,87.9 193.18,88.03 192.77,88.03 192.64,87.9 192.64,87.62 192.35,87.33 187.45,87.33 184.36,84.24 180.34,84.24 v2(180.07,83.97)
  BOTTOM w0.102: UV1.D10 179.69,83.59 v2(180.07,83.97) ; UV8.C2 v2(199.46,86.28)
FBC_EDC1: length 21.8
  IN1 w0.102: v2(198.66,78.28) 198.66,78.22 198.31,77.87 196.74,77.87 196.61,77.99 196.61,78.07
  IN1 w0.147: 196.61,78.07 196.45,78.23 194.95,78.23 194.7,78.48 193.02,78.48 192.72,78.78 187.92,78.78 186.47,80.23 183.85,80.23 183.47,80.61 v2(183.47,80.66)
  BOTTOM w0.102: UV8.C13 198.66,78.28 v2(198.66,78.28) ; v2(183.47,80.66) 183.42,80.61 181.07,80.61 180.86,80.41 180.86,79.92 180.76,79.82 180.1,79.82 UV1.D5
FBC_EDC2: length 30.8
  BOTTOM w0.102: 182.75,77.03 182.63,77.03 182.36,77.29 181.15,77.29 180.73,77.71 UV1.C3
  BOTTOM w0.13: UV8.R13 208.34,77.56 208.34,77.23 208.29,77.18 208.29,76.29 207.5,75.5 192.71,75.5 192.02,76.19 v1(189.6,76.19) 183.59,76.19 182.75,77.03
FBC_EDC3: length 32.9
  BOTTOM w0.102: UV1.B9 181.4,82.71 181.92,83.23 185.26,83.23
  BOTTOM w0.13: UV8.R2 208.66,86.92 209.03,87.29 209.03,87.59 208.68,87.94 208.68,88.09 206.83,89.94 196.44,89.94 193.17,86.68 192.29,86.68 188.84,83.23 v1(186.34,83.23) 185.26,83.23
FBC_EDC4: length 25.7
  IN3 w0.102: v2(178.5,94.03) 178.5,94.03 178.51,94.03 178.53,94.05 179.41,94.05 179.76,94.4 180.42,94.4 180.52,94.3 183.62,94.3 183.69,94.22 184.74,94.22
  IN3 w0.145: 184.74,94.22 184.74,94.23 185.64,94.23 186.12,94.71 190.28,94.71 192.59,97.01 192.59,97.45 192.71,97.58 193.13,97.58 193.26,97.45 193.26,96.71 193.38,96.59 193.8,96.59 193.93,96.71 193.93,97.45 194.05,97.58 194.45,97.58 194.57,97.45 194.57,97.01 194.87,96.71 197.07,96.71 197.34,96.99 198.26,96.99 v2(198.66,97.39)
  BOTTOM w0.102: UV1.E23 178.51,94.03 178.51,94.03 178.5,94.03 v2(178.5,94.03) ; UV9.R2 v2(198.66,97.39)
FBC_EDC5: length 29.4
  IN3 w0.102: 185,101.18 185,100.96 183.06,99.02 180.7,99.02 180.27,98.6 179.67,98.6 v2(179.29,98.98)
  IN3 w0.145: 185,101.18 189.16,105.35 191.81,105.35 191.93,105.48 191.93,106.01 192.06,106.14 192.63,106.14 192.76,106.01 192.76,105.5 192.89,105.37 193.3,105.37 193.43,105.5 193.43,106.04 193.56,106.16 193.97,106.16 194.1,106.04 194.1,105.54 194.26,105.37 194.49,105.37 194.65,105.54 194.65,106.04 194.78,106.16 195.12,106.16 195.25,106.04 195.25,105.54 195.41,105.37 195.76,105.37 195.92,105.54 195.92,106.01 196.05,106.14 196.84,106.14 196.96,106.01 196.96,105.78 197.16,105.58 197.41,105.58 197.62,105.79 198.83,105.79 199.22,105.39 v2(199.46,105.39)
  BOTTOM w0.102: v2(179.29,98.98) 178.89,98.58 UV1.E28 ; UV9.R13 v2(199.46,105.39)
FBC_EDC6: length 35
  IN3 w0.145: v2(209.06,105.39) 208.67,105 207.88,105 206.77,106.11 206.11,106.11 202.91,109.31 188.78,109.31 181.68,102.22 181.68,100.7 181.71,100.68 v2(181.71,100.63)
  BOTTOM w0.102: v2(181.71,100.63) 181.71,100.63 UV1.B30
  BOTTOM w0.107: UV9.C13 v2(209.06,105.39)
FBC_EDC7: length 30.9
  IN1 w0.147: v2(184.46,94.63) 184.72,94.89 184.72,94.96 184.93,95.17 186.99,95.17 192.24,100.42 197.6,100.42 197.8,100.62 205.02,100.62 205.63,100.02 205.63,99.69 206.51,98.8 206.86,98.8 v2(208.26,97.39)
  BOTTOM w0.107: UV9.C2 v2(208.26,97.39) ; UV1.A23 182.86,94.41
  BOTTOM w0.13: 182.86,94.41 183.08,94.63 v2(184.46,94.63)
FBC_MA0_MA10_H: length 29.3
  IN1 w0.102: v2(180.09,88.98) 180.29,89.18 182.72,89.18 184.62,91.09 184.62,91.24 184.64,91.26
  IN1 w0.147: 184.64,91.26 184.64,91.36 185.66,92.38 187.77,92.38 192.28,96.89 197.24,96.89 197.34,96.99 201.23,96.99 201.46,97.22 201.46,97.58 201.68,97.8 202.02,97.8 202.03,97.81 202.04,97.81 202.27,98.03 202.27,98.35 202.27,98.36 202.27,98.45 202.42,98.59 202.83,98.59 203.23,98.19 v2(203.46,98.19)
  BOTTOM w0.102: UV1.D16 179.69,88.58 v2(180.09,88.98) ; UV9.K4 v2(203.46,98.19)
FBC_MA0_MA10_L: length 26.2
  IN1 w0.102: 185.42,87.46 185.07,87.46 v2(184.77,87.76)
  IN1 w0.147: 185.42,87.46 187.19,87.46 187.97,86.68 202.19,86.68 202.26,86.61 202.26,86.01 202.39,85.88 203.32,85.88 203.46,85.74 v2(203.46,85.48)
  BOTTOM w0.102: UV1.D15 180.08,87.32 183.67,87.32 183.72,87.37 183.99,87.37 184.04,87.32 184.33,87.32 v2(184.77,87.76) ; UV8.H4 v2(203.46,85.48)
FBC_MA1_MA9_H: length 25.4
  IN1 w0.147: v2(202.66,98.99) 202.56,98.9 202.35,98.9 202.04,98.59 201.63,98.59 201.47,98.43 201.47,98.02 201.26,97.81 201.23,97.81 201.22,97.8 196.9,97.8 196.89,97.81 196.56,97.81 196.48,97.73 192.48,97.73 187.58,92.83 185.45,92.83 184.28,91.66 184.28,91.35 v2(184.23,91.3)
  BOTTOM w0.102: UV1.A18 182.24,90.06 183.03,90.06 184.23,91.25 v2(184.23,91.3)
  BOTTOM w0.107: UV9.K5 v2(202.66,98.99)
FBC_MA1_MA9_L: length 23.3
  IN1 w0.147: v2(184.34,86.56) 184.8,86.1 186.63,86.1 188.45,84.28 203.07,84.28 v2(203.47,84.67)
  BOTTOM w0.102: v2(184.34,86.56) 183.87,87.04 v1(183.86,87.04) 183.8,87.09 182.27,87.09 UV1.A14 ; UV8.H5 203.07,84.28 v2(203.47,84.67)
FBC_MA2_BA0_H: length 36.5
  IN1 w0.102: 180.54,94 180.54,93.88 180.21,93.55 179.94,93.55 179.69,93.3 179.69,92.49 179.69,91.22 179.54,91.07 178.06,91.07 v2(177.61,90.63)
  IN1 w0.147: 180.54,94 180.54,94.5 181.23,95.19 181.23,96.09 190.93,105.78 196.76,105.78 197.54,105 202.85,105 203.06,104.79 203.06,104.41 203.45,104.02 v2(203.45,103.81)
  BOTTOM w0.102: UV9.K11 v2(203.45,103.81) ; UV1.F18 v2(177.61,90.63)
FBC_MA2_BA0_L: length 30.3
  IN1 w0.102: v2(177.7,86.45) 178.15,86 179.48,86 179.97,85.52
  IN1 w0.147: v2(203.46,79.08) 203.06,78.68 198.03,78.68 198.03,78.68 198,78.68 197.99,78.68 197.69,78.68 197.69,78.68 197.23,78.68 197.23,78.68 196.89,78.68 196.13,79.44 188.17,79.44 185.66,81.95 183.67,81.95 180.1,85.52 179.97,85.52
  BOTTOM w0.102: UV1.F14 178.04,86.8 v2(177.7,86.45) ; UV8.H11 v2(203.46,79.08)
FBC_MA3_BA3_H: length 32.3
  IN1 w0.102: 181,94.1 181,93.91 180.49,93.4 180.49,91.32 180.23,91.06 179.89,91.06 179.46,90.63 v2(179.29,90.63)
  IN1 w0.147: v2(202.65,103.8) 202.63,103.83 202.45,103.83 202.09,104.18 189.97,104.18 182.11,96.33 182.11,95.44 181,94.33 181,94.1
  BOTTOM w0.102: UV9.K10 v2(202.65,103.8) ; v2(179.29,90.63) 178.89,90.23 UV1.E18
FBC_MA3_BA3_L: length 28
  IN1 w0.102: v2(179.35,86.48) 179.5,86.48 180.01,85.97 180.27,85.97
  IN1 w0.147: v2(202.66,79.88) 202.66,80.7 202.27,81.09 187.8,81.09 186.04,82.86 184.04,82.86 181.41,85.49 181.41,85.79 181.07,86.12 180.62,86.12 180.47,85.97 180.27,85.97
  BOTTOM w0.102: UV1.E14 179.31,86.48 v2(179.35,86.48)
  BOTTOM w0.107: UV8.H10 v2(202.66,79.88)
FBC_MA4_BA2_H: length 31.8
  IN1 w0.102: v2(181.69,91.53) 181.69,91.6 182.32,92.23 182.32,93.67
  IN1 w0.147: v2(204.26,104.59) UV9.H11 204.66,103.37 203.4,102.1 189.81,102.1 183.52,95.81 183.52,94.92 182.32,93.72 182.32,93.67
  BOTTOM w0.102: UV9.H11 v2(204.26,104.59)
  BOTTOM w0.107: UV1.A20 182.07,91.91 v2(181.69,91.53)
FBC_MA4_BA2_L: length 25.1
  IN1 w0.147: v2(204.26,79.88) 204.25,79.88 203.64,80.48 203.64,80.73 202.83,81.54 187.99,81.54 186.22,83.31 184.23,83.31 182.63,84.91 182.63,84.95 v2(182.6,84.98)
  BOTTOM w0.102: UV8.K11 v2(204.26,79.88) ; UV1.A12 182.26,85.21 182.47,85 182.58,85 v2(182.6,84.98)
FBC_MA5_BA1_H: length 29.8
  IN1 w0.102: 181.94,93.93 181.89,93.88 181.89,93.69 181.69,93.49 v2(181.69,92.31)
  IN1 w0.147: 181.94,93.93 181.94,93.99 183.02,95.06 183.02,95.96 189.62,102.56 203.02,102.56 v2(204.26,103.79)
  BOTTOM w0.102: UV9.H10 v2(204.26,103.79)
  BOTTOM w0.107: UV1.B20 v2(181.69,92.31)
FBC_MA5_BA1_L: length 26.3
  IN1 w0.147: v2(204.26,80.68) 204.26,81.61 203.88,82 188.18,82 186.41,83.76 184.6,83.76 184.42,83.94 184.41,83.94 183.33,85.02 183.33,85.03 182.83,85.53 v2(182.83,85.54)
  BOTTOM w0.102: v2(182.83,85.54) 182.22,85.54 182.2,85.56 181.64,85.56 UV1.B12
  BOTTOM w0.107: UV8.K10 v2(204.26,80.68)
FBC_MA6_MA11_H: length 34.5
  IN1 w0.102: v2(176.79,90.63) 177.21,90.21 181.41,90.21 183.21,92.01 183.21,92.14
  IN1 w0.147: 183.21,92.14 183.21,92.53 184.88,94.19 187.02,94.19 192.68,99.85 197.69,99.85 198.03,100.19 203.86,100.19 v2(205.06,98.99)
  BOTTOM w0.102: v2(176.79,90.63) 177.19,90.23 UV1.G18 ; UV9.H5 v2(205.06,98.99)
FBC_MA6_MA11_L: length 32
  IN1 w0.102: v2(176.79,88.13) 177.99,86.93 180.39,86.93
  IN1 w0.147: 180.39,86.93 182.7,86.93 184.43,85.2 186.25,85.2 188.08,83.38 197.16,83.38 197.63,82.9 204.08,82.9 v2(205.06,83.88)
  BOTTOM w0.102: UV8.K5 v2(205.06,83.88) ; UV1.G15 177.19,87.73 v2(176.79,88.13)
FBC_MA7_MA8_H: length 27.8
  IN1 w0.147: v2(204.26,98.19) 203.86,97.79 202.46,97.79 202.25,97.58 202.25,97.12 202.12,96.99 201.69,96.99 201.46,96.76 201.46,96.43 201.2,96.16 200.96,96.16 200.95,96.15 192.18,96.15 187.71,91.68 v2(187.4,91.68)
  BOTTOM w0.102: UV9.H4 v2(204.26,98.19) ; UV1.B18 181.47,90.21 181.88,90.62 182.22,90.62 182.48,90.36 182.8,90.36 183.83,91.39 183.83,91.56 184.21,91.94 v1(186.37,91.94) 187.15,91.94 v2(187.4,91.68)
FBC_MA7_MA8_L: length 26.6
  IN1 w0.147: v2(183.76,86.55) 183.76,86.51 184.62,85.65 186.44,85.65 188.26,83.83 197.34,83.83 197.82,83.35 203.77,83.35 205.06,84.64 v2(205.06,84.68)
  BOTTOM w0.102: UV1.B14 181.64,86.56 182.24,86.56 182.53,86.85 183.46,86.85 v2(183.76,86.55) ; UV8.K4 v2(205.06,84.68)
FBC_MA12_RFU_H: length 32.7
  IN1 w0.102: v2(178.46,88.98) 178.92,89.44 182.23,89.44 183.85,91.05 183.85,91.87 184.07,92.09
  IN1 w0.147: v2(204.26,98.99) 203.86,98.59 203.31,98.59 203.07,98.83 203.07,99.15 202.81,99.41 201.69,99.41 201.46,99.18 201.46,98.84 201.21,98.59 197.29,98.59 197.17,98.72 192.83,98.72 187.39,93.29 185.26,93.29 184.07,92.09
  BOTTOM w0.102: UV9.J5 v2(204.26,98.99) ; UV1.F17 v2(178.46,88.98)
FBC_MA12_RFU_L: length 28
  IN1 w0.102: 184.8,86.7 184.49,87 183.54,87 183.2,87.35 v2(178.48,87.35)
  IN1 w0.147: 184.8,86.7 184.94,86.55 186.82,86.55 187.94,85.43 196.3,85.43 196.65,85.08 203.63,85.08 204.03,84.68 v2(204.26,84.68)
  BOTTOM w0.102: v2(178.48,87.35) 178.48,87.35 178.84,87.71 UV1.E15 ; UV8.J5 v2(204.26,84.68)
FBC_RAS#_H: length 28.2
  IN1 w0.147: v2(185.32,91.39) 185.64,91.08 187.74,91.08 188.88,92.22 189.97,92.22 191.57,93.82 191.57,94.9 192.37,95.7 201.71,95.7 202.27,96.26 202.27,96.79 202.66,97.18 v2(202.66,97.39)
  BOTTOM w0.102: UV1.D17 180.08,89.79 183.16,89.79 184.19,90.82 184.75,90.82 v2(185.32,91.39) ; UV9.L3 v2(202.66,97.39)
FBC_RAS#_L: length 25.6
  IN1 w0.102: v2(179.33,88.13) 179.73,87.72 183.4,87.72 183.8,87.32 184.62,87.32 184.85,87.09
  IN1 w0.147: 184.85,87.09 184.93,87.01 187,87.01 188.13,85.88 201.46,85.88 v2(201.86,86.28)
  BOTTOM w0.102: v2(179.33,88.13) 179.33,87.3 179.69,86.94 UV1.D14 ; UV8.G3 v2(201.86,86.28)
FBC_RST#_H: length 27.8
  TOP w0.13: v2(184.36,90.24) 182.51,90.24 RV110.1
  IN1 w0.102: 185.73,90.78 184.83,90.78 184.36,90.31 v2(184.36,90.24)
  IN1 w0.147: v2(203.46,97.39) 203.06,96.99 203.06,96.42 201.89,95.25 194.16,95.25 189.53,90.62 185.88,90.62 185.73,90.78
  BOTTOM w0.102: UV9.J2 v2(203.46,97.39) ; UV1.A17 183.27,89.41 184.1,90.24 v2(184.36,90.24)
FBC_RST#_L: length 24.8
  TOP w0.13: v2(183.84,88.21) 183.84,88.07 182.99,87.22 RV111.1
  IN1 w0.102: 185.17,87.91 184.87,88.21 183.85,88.21 v2(183.84,88.21)
  IN1 w0.147: 185.17,87.91 187.38,87.91 187.81,87.48 190.24,87.48 190.67,87.91 193.11,87.91 193.54,87.48 203.06,87.48 v2(203.46,87.08)
  BOTTOM w0.102: v2(183.84,88.21) 183.89,88.16 183.29,87.56 182.24,87.56 UV1.A15 ; UV8.J2 v2(203.46,87.08)
FBC_WCK0: length 25.2
  IN3 w0.102: v2(178.46,81.43) 178.6,81.43 178.72,81.54 178.72,81.79 178.99,82.06 179.73,82.06 180.01,81.78 180.34,81.78 180.35,81.79 180.38,81.79
  IN3 w0.13: v2(199.46,84.68) 199.62,84.68 199.81,84.5 199.81,83.47 199.54,83.2 198.13,81.79 180.38,81.79
  BOTTOM w0.102: UV8.D4 v2(199.46,84.68)
  BOTTOM w0.114: v2(178.46,81.43) 178.04,81.85 UV1.F8
FBC_WCK0_N: length 25.2
  IN3 w0.102: 180.38,81.56 180.35,81.56 180.34,81.57 179.93,81.57 179.65,81.85 179.07,81.85 178.92,81.7 178.92,81.58 179.07,81.43 v2(179.29,81.43)
  IN3 w0.13: 180.38,81.56 198.23,81.56 199.64,82.97 200.04,83.37 200.04,84.46 v2(200.26,84.68)
  BOTTOM w0.102: UV8.D5 v2(200.26,84.68)
  BOTTOM w0.114: UV1.E8 178.89,81.83 v2(179.29,81.43)
FBC_WCK1: length 29.9
  BOTTOM w0.114: UV8.P4 208.29,84.65 208.29,83.15 207.63,82.49 196.88,82.49 195.35,80.97 191.43,80.97 190.26,79.79 v4(189.16,79.79) 186.09,79.79 186.06,79.77 185.46,79.77 185.43,79.79 182.48,79.79 UV1.A5
FBC_WCK1_N: length 29.9
  BOTTOM w0.114: UV1.A6 182.3,80 v4(185.76,80) 188.84,80 188.86,80.03 189.46,80.03 189.49,80 190.17,80 191.34,81.17 195.27,81.17 196.79,82.7 207.55,82.7 208.08,83.24 208.08,83.82 208.01,83.89 207.58,83.89 207.4,84.06 207.4,84.43 207.52,84.55 207.78,84.55 207.86,84.47 UV8.P5
FBC_WCK2: length 25.6
  IN3 w0.13: v2(199.46,98.99) 199.4,99.05 199.4,99.35 199.58,99.53 199.86,99.53 200.03,99.7 200.03,99.92 199.35,100.6 188.27,100.6 184.13,96.46 181.69,96.46 181.3,96.08 179.91,96.08 179.73,95.9 179.46,95.9 179.32,95.75 v2(179.32,95.63)
  BOTTOM w0.102: UV9.P4 v2(199.46,98.99)
  BOTTOM w0.114: UV1.D24 179.69,95.26 v2(179.32,95.63)
FBC_WCK2_N: length 25.6
  IN3 w0.13: v2(179.31,96.47) 179.31,96.28 179.46,96.13 179.64,96.13 179.81,96.31 181.21,96.31 181.59,96.69 184.04,96.69 188.18,100.83 199.45,100.83 200.26,100.02 v2(200.26,98.99)
  BOTTOM w0.102: UV9.P5 v2(200.26,98.99)
  BOTTOM w0.114: UV1.D25 179.69,96.08 v2(179.31,96.47)
FBC_WCK3: length 30.2
  BOTTOM w0.102: UV1.B27 181.45,97.55 181.61,97.55 181.71,97.65 181.71,97.98 181.85,98.12 184.47,98.12 184.47,98.12 184.5,98.12
  BOTTOM w0.114: 184.5,98.12 185.86,98.12 v4(186.59,98.85) 187.38,99.63 194.02,99.63 194.04,99.61 194.78,99.61 196.46,101.29 206.3,101.29 207.5,100.08 207.5,98.95 UV9.D4
FBC_WCK3_N: length 30.2
  BOTTOM w0.102: 184.5,98.33 184.47,98.33 184.47,98.32 181.77,98.32 181.63,98.19 180.97,98.19 UV1.C27
  BOTTOM w0.114: 184.5,98.33 185.78,98.33 186.22,98.77 186.22,98.81 186.64,99.23 186.68,99.23 187.29,99.84 v4(194.35,99.84) 194.72,99.84 196.37,101.49 206.38,101.49 207.71,100.16 207.71,99.54 UV9.D5
FBC_WE#_H: length 34.3
  IN1 w0.102: v2(180.89,90.63) 181.35,90.63 182.81,92.09 182.81,92.22
  IN1 w0.147: 182.81,92.22 182.81,92.93 183.39,93.51 183.39,94.02 183.97,94.6 183.97,95.63 189.99,101.65 204.44,101.65 205.6,102.81 205.6,104.05 v2(205.06,104.59)
  BOTTOM w0.102: UV1.C18 180.49,90.23 v2(180.89,90.63) ; UV9.G12 v2(205.06,104.59)
FBC_WE#_L: length 30.7
  IN1 w0.147: v2(205.06,79.09) 205.07,79.09 205.5,79.52 205.5,81.02 204.07,82.45 197.44,82.45 196.97,82.92 187.89,82.92 186.42,84.39 184.6,84.39 183.68,85.31 183.68,85.35 v2(183.46,85.56)
  BOTTOM w0.102: v2(183.46,85.56) 183.46,86.14 183.06,86.54 182.7,86.54 182.51,86.35 182.33,86.35 182.33,86.35 181.52,86.35 181.31,86.56 180.84,86.56 UV1.C14 ; v2(205.06,79.09) 205.46,78.69 UV8.L12
FBVDD_EN: length 98.1
  TOP w0.102: v2(204.35,72.89) 204.35,73.01 206.51,75.17 QZ6.5 ; DV13.1 158.4,74.67 RV209.1 157.34,75.73 157.34,78.2 157.92,78.78 157.92,79.4 v2(157.49,79.83)
  IN1 w0.114: v2(142.63,108.83) 145.55,108.83 149.36,105.02 149.36,95.36 154.19,90.53 154.19,83.14 v2(157.49,79.83)
  IN3 w0.127: v2(204.35,72.89) 204.23,72.89 202.8,74.31 186.95,74.31 186.47,74.79 180.8,74.79 180.74,74.84 178.69,74.84 177.41,76.12 174.63,76.12 173.9,76.85 171.49,76.85 169.29,79.05 165.45,79.05 165.11,79.39 157.93,79.39 v2(157.49,79.83)
  BOTTOM w0.102: v2(142.63,108.83) 142.2,108.83 PR903.1
FCCM_GT: length 74.8
  IN3 w0.254: v2(64.2,109.21) 63.61,109.79 63.61,123.18 64.45,124.02 85.05,124.02 88.5,127.47 88.5,130.23 90.37,132.1 91.35,132.1 v2(91.96,132.71)
  BOTTOM w0.203: PU1100.11 68.2,91.37 67.75,91.81
  BOTTOM w0.254: 67.75,91.81 67.75,92.29 65.8,94.25 65.8,99.92 66.87,101 66.87,101.34 68.21,102.67 68.21,106.21 66.45,107.97 65.44,107.97 v2(64.2,109.21) 64.45,109.46 PR1515.1 ; PR1503.1 v2(91.96,132.71)
FCCM_SA: length 107.9
  IN3 w0.254: v2(130.67,130.24) 130.46,130.44 130.03,130.44 129.12,131.36 123.49,131.36 122.98,130.85 110.71,130.85 109.98,131.59 105.38,131.59 104.42,130.62 101.26,130.62 101.08,130.8 95.8,130.8 95.51,130.51 95.51,129.27 94.87,128.63 93.23,128.63 92.36,127.77 92.36,126.76 92.36,126.76 92.36,126.34 90.14,124.12 89.46,124.12 86.31,120.97 71.73,120.97 71.05,120.3 71.05,114.53 68.69,112.17 68.69,108.09 69.5,107.28 69.5,104.82 71,103.32 71,99.1 72.07,98.03 74.13,98.03 77.63,94.53 77.63,92.59 75.63,90.58 v2(75.63,88.18)
  BOTTOM w0.203: v2(75.63,88.18) 75.61,88.17 PU1100.34
  BOTTOM w0.254: v2(130.67,130.24) 130.74,130.17 PR1530.1
FCCM_VCORE: length 101.9
  TOP w0.254: v2(111.92,132.81) 111.24,133.49 v3(106.08,133.49) 103.01,133.49 v2(102.14,132.63)
  IN1 w0.254: v2(111.92,132.81) 112.51,133.39 113.67,133.39 114.87,132.2 122.64,132.2 122.9,132.45 v2(122.9,132.73)
  IN3 w0.254: v2(102.14,132.63) 102.09,132.68 102.09,132.86 101.53,133.42 95.55,133.42 93.21,131.08 90.79,131.08 89.52,129.81 89.52,127.05 85.47,123 70.88,123 69.02,121.14 69.02,115.37 65.92,112.28 65.92,96.87 69.86,92.93 73.9,92.93 v2(74.3,93.34)
  BOTTOM w0.203: v2(74.3,93.34) 74.3,93.21 73.94,92.85 PU1100.24
  BOTTOM w0.254: PR1417.1 111.9,132.78 v2(111.92,132.81) ; v2(102.14,132.63) 102.24,132.53 PR1431.1 ; v2(122.9,132.73) 122.9,132.62 122.47,132.2 122.46,132.2 122.31,132.05 PR1404.1
GC6_EVENT#_D: length 19.5
  BOTTOM w0.102: DV9.2 164.02,73.36 RV42.1 ; DV9.2 v1(165.16,74.5) ; DV9.2 164.39,75.33 165.11,76.05 165.11,81.95 165.35,82.19 171.44,82.19 171.76,81.87 171.76,81.53 171.86,81.42 172.58,81.42 UV1.M7
GPIO0: length 2.2
  TOP w0.102: UM1.C4 264.47,34.64 v2(264.08,35.03)
  BOTTOM w0.102: v1(264.63,35.45) 264.5,35.45 v2(264.08,35.03)
  BOTTOM w0.254: RM13.2 264.47,34.64 v2(264.08,35.03)
GPIO2: length 4.5
  TOP w0.102: v2(265.69,33.39) 266.09,33.79 UM1.E3
  BOTTOM w0.102: RM12.2 v1(263.43,31.87) 264.17,31.87 v2(265.69,33.39)
GPIO4: length 7.6
  TOP w0.102: UM1.E7 266.09,37.06 265.69,37.46 265.69,38.02 264.3,39.41 RM11.2 263.81,40.4 263.81,41.52 263.56,41.77 RM20.2 263.75,42.46 264.21,42 v1(264.53,42)
GPU_EN: length 29.6
  TOP w0.254: PR1029.1 199.17,58.03 v2(199.15,58)
  IN2 w0.254: v2(175.76,58.05) 176.93,59.22 182.08,59.22 183.5,57.8 198.94,57.8 v2(199.15,58)
  BOTTOM w0.254: PU1000.3 v2(175.76,58.05) 175.78,58.08 175.78,58.31 176.03,58.56 PC1020.1 ; PC1020.1 PR1008.1 ; PC1020.1 PR1007.1
GPU_EVENT#: length 83.9
  IN1 w0.114: v2(146.26,71.59) 146.34,71.52 146.34,67.91 140.81,62.39 140.81,46.45 146.01,41.25 146.01,40.52 150.77,35.76 150.77,32.88 152.62,31.03 153.25,31.03 154.14,30.14 160.06,30.14 160.33,29.86 162.01,29.86 162.2,29.67 162.78,29.67 162.84,29.61 162.84,29.23 163.08,28.99 163.59,28.99 165.23,27.35 166.45,27.35 v2(166.81,26.99)
  BOTTOM w0.089: UH2.AR24 166.89,26.91 v2(166.81,26.99)
  BOTTOM w0.102: DV9.1 161.84,74.77 155.18,74.77 154.22,73.81 154.22,73.21 v1(153.5,72.49) 151.41,72.49 151.16,72.25 151.16,71.8 150.98,71.62 149.09,71.62 148.52,71.06 146.8,71.06 v2(146.26,71.59)
GPU_FB: length 4.8
  BOTTOM w0.254: PU1000.11 178.43,54.16 178.81,53.77 178.81,53.23
  BOTTOM w0.406: 178.81,53.23 v1(179.09,52.95) 179.35,52.7 PC1032.2 180.86,52.7 PR1017.2 PR1019.2
GPU_FBRTN: length 4.1
  BOTTOM w0.254: PR1012.2 179.73,54.47 179.49,54.23 v1(179.12,54.23) 178.92,54.23 178.49,54.66 PU1000.10
  BOTTOM w0.406: PR1012.2 180.02,53.63 PC1032.1 180.83,53.61 PR1013.2
GPU_GC6_FB_EN: length 103.2
  TOP w0.102: v2(141.36,65.57) 143.9,68.11 143.9,70.6 145.42,72.13 149.49,72.13 151.19,73.83 151.19,73.84 151.38,74.03 151.39,74.03 152.03,74.67 156.22,74.67 156.35,74.54 157.9,74.54 158.33,74.11 160.4,74.11 DV13.3 161.88,75.59 RV37.1 162.18,76.32 162.56,75.94 162.56,75.33 163.14,74.76 164.68,74.76 165.36,75.43 168.03,75.43 v1(168.26,75.66) 168.72,76.11 168.72,76.63 169.63,77.54 169.63,79.35 v2(170.03,79.75)
  IN1 w0.114: v2(141.36,65.57) 139.76,63.97 139.76,46.13 145.04,40.85 145.04,39.98 145.54,39.48 145.54,38 147.1,36.44 148.73,36.44 149.81,35.36 149.81,33.81 149.18,33.19 149.18,32.39 149.57,32.01 149.57,30.2 150.66,29.11 152.6,29.11 154.11,27.61 156.65,27.61 157.62,26.63 158.33,26.63 158.48,26.79 162.63,26.79 163.18,27.33 163.69,27.33 163.94,27.08 163.94,26.01 164.21,25.75 164.35,25.75 v2(164.4,25.69)
  BOTTOM w0.102: UH2.AW27 166.23,24.7 165.77,25.16 164.78,25.16 164.4,25.54 v2(164.4,25.69) ; UV1.P6 171.08,80.16 170.66,79.75 v2(170.03,79.75)
GPU_JTAG_TCK: length 7.2
  BOTTOM w0.102: T98.1 150.33,83.94 151.04,83.23 155.27,83.23 155.37,83.12 156.01,83.12 156.29,83.41 UV1.AM10
GPU_JTAG_TDI: length 9.4
  BOTTOM w0.102: UV1.AM11 156.69,84 156.69,82.54 156.47,82.31 154.54,82.31 153.95,82.9 150.42,82.9 150.17,82.64 T99.1
GPU_JTAG_TDO: length 2.9
  BOTTOM w0.102: T100.1 152.77,85.46 153.27,84.95 154.43,84.95 UV1.AP12
GPU_JTAG_TMS: length 4.5
  BOTTOM w0.102: UV1.AP11 154.22,84.41 154.05,84.57 151.57,84.57 150.71,85.44 T101.1
GPU_JTAG_TRST#: length 3.5
  BOTTOM w0.102: RV63.1 152.39,83.9 v1(153.15,83.9) 154.98,83.9 UV1.AN11
GPU_LEVEL: length 7.7
  TOP w0.102: v2(172.58,77.28) 173.01,77.71 173.11,77.71 v1(173.16,77.76) 173.56,77.76 173.82,77.5 173.82,76.21 173.94,76.09 174.7,76.09 174.91,75.88 174.91,75.48 174.66,75.22 174.29,75.22 173.73,74.67 DV11.2 173.67,73.69 RV60.2
  BOTTOM w0.102: UV1.N3 172.15,77.71 v2(172.58,77.28)
GPU_PEX_RST_HOLD#: length 25.7
  TOP w0.102: v2(170.06,75.35) 169.5,74.79 166.02,74.79 164.39,73.17 v1(163.69,73.17) 163.36,73.17 163.2,73.02 158.91,73.02 157.54,71.64 155.89,71.64 154.14,73.4 UV18.2 153.6,73.4 153.58,73.37 151.77,73.37 150.74,72.34 v2(150.74,72.09)
  BOTTOM w0.102: v2(150.74,72.09) 150.37,72.46 RV41.1 ; UV1.P1 171.29,76.06 170.58,75.35 v2(170.06,75.35)
GPU_PGOOD: length 4.8
  BOTTOM w0.102: v1(176.65,48.54) 176.41,48.78 176.41,50.02 175.9,50.52 PR1026.1
  BOTTOM w0.254: PR1026.1 175.93,50.64 175.93,52.07 175.76,52.24 PU1000.16
GPU_PSI: length 34.8
  IN1 w0.114: v2(172.6,78.1) 172.4,78.1 171.89,77.59 171.89,75.53 172.4,75.02 172.4,73.25 173.19,72.46 173.19,71.91 173.71,71.39 173.71,69.74 174.06,69.38 174.06,66.84 180.61,60.3 182.15,60.3 v2(182.92,59.53)
  BOTTOM w0.102: PR1001.2 177.84,58.97 178.27,59.4 178.27,60.24 178.64,60.61 180.91,60.61 182.05,59.48 v1(182.23,59.48) 182.86,59.48 v2(182.92,59.53) ; v2(172.6,78.1) 172.99,78.48 UV1.M4
  BOTTOM w0.254: PU1000.4 176.26,57.7 176.97,58.41 177.39,58.41 177.81,58.83 PR1001.2
GPU_PVCC: length 1.3
  IN1 w0.254: v2(172.53,54.47) v2(173.11,54.47)
  BOTTOM w0.254: 171.9,54.59 PC1046.1 172.35,54.6 172.48,54.47 v2(172.53,54.47)
GPU_PWR_LEVEL: length 101.9
  TOP w0.102: UE1.21 219.29,22.14 219.04,22.39 217.93,22.39 217.62,22.09 215.3,22.09 215,21.78 215,21.12 213.6,19.73 213.17,19.73 212.76,20.13 212.76,21.61 212.4,21.97 212.4,23.74 213.55,24.88 v2(213.55,26.3) ; DV11.1 176.5,73.24 178.27,73.24 178.78,73.75 v3(180.63,73.75) v2(181.42,72.96)
  IN2 w0.127: v2(206.61,43.22) 206.31,43.53 206.31,54.14 207.48,55.31 207.48,72.53 206,74.01 189.32,74.01 189.16,73.85 182.31,73.85 v2(181.42,72.96)
  BOTTOM w0.102: v2(206.61,43.22) 206.61,42.65 209.14,40.12 210.86,40.12 212.32,38.65 212.32,37.77 211.82,37.27 211.82,32.9 213.75,30.97 213.75,26.51 v2(213.55,26.3)
GPU_REFADJ: length 4.6
  BOTTOM w0.102: v1(180.73,59.08) 180.62,58.97 PR1005.2
  BOTTOM w0.254: PR1005.2 179.71,58.96 179.16,58.41 178.7,58.41 177.69,57.39 177.34,57.39 177.26,57.32 PU1000.6
GPU_REFIN: length 11.2
  TOP w0.102: PR1006.1 180.81,58.94 v1(180.39,59.36)
  TOP w0.254: PR1006.1 PR1004.1 v2(180.81,56.89) 180.45,56.53 180.45,55.33 180.28,55.16 179.52,55.16 179.16,55.53 178.58,55.53 177.94,54.88 PR1021.1
  BOTTOM w0.254: v2(180.81,56.89) 180.63,56.89 180.02,56.28 PC1008.1 179.69,56.58 178.9,56.58 178.48,56.16 177.99,56.16 PU1000.7
GPU_THM_SMBCLK: length 252.9
  TOP w0.102: UE1.12 221.11,25.74 221.22,25.84 221.59,25.84 221.7,25.74 221.7,25.59 v2(221.5,25.39) ; v2(53.1,49.14) 54.21,48.03 54.35,48.03 55.08,48.76 65.16,48.76 v2(65.41,49.01)
  IN1 w0.114: v2(150.92,24.76) 150.62,25.06 148.84,25.06 145.42,28.48 145.42,29.73 143.71,31.45 143.71,33.06 143.33,33.44 143.33,40.28 137.7,45.9 137.7,52.19 v2(138.06,52.54) 138.14,52.54 138.25,52.66 138.25,64.9 143.01,69.66 143.01,73.48 143.11,73.59 v2(143.11,73.9)
  IN3 w0.127: v2(150.92,24.76) 151.19,24.49 151.19,23.95 154.01,21.14 154.84,21.14 156.25,19.73 158.36,19.73 158.51,19.57 160.18,19.57 160.76,18.99 166.33,18.99 167.16,18.15 169.89,18.15 170.7,17.34 170.7,16.78 173.21,14.26 178.28,14.26 179.26,15.24 179.26,16.19 182.03,18.96 186.37,18.96 188.45,21.05 190.23,21.05 191.09,21.91 198.44,21.91 199.36,22.83 206.11,22.83 207.2,23.92 214.15,23.92 215.98,22.09 219.16,22.09 220.21,21.03 224.1,21.03 224.49,20.64 224.49,20.46 v2(224.34,20.31)
  BOTTOM w0.102: v2(65.41,49.01) 65.67,48.76 66.56,48.76 66.81,49.01 66.81,50.48 67.99,51.65 136.44,51.65 137.08,52.29 137.8,52.29 v2(138.06,52.54) ; v2(224.34,20.31) 224.52,20.49 224.52,23.38 224.42,23.49 223.83,23.49 RE46.1 222.72,24.6 222.08,24.6 221.52,25.16 221.52,25.37 v2(221.5,25.39) ; v2(53.1,49.14) 53.1,49.57 RT7.2 52.4,49.28 QT2.3 ; v2(143.11,73.9) 143.19,73.82 143.4,73.82 143.63,74.06 144.1,74.06 144.36,73.8 144.36,73.24 144.94,72.66 146.31,72.66 147.3,71.67 147.81,71.67 148.28,72.14 148.28,72.88 147.49,73.67 QV1.6 ; QH5.6 152.17,25.57 151.82,25.21 151.37,25.21 v2(150.92,24.76)
GPU_THM_SMBDAT: length 252.1
  TOP w0.102: v2(222.16,25.38) 221.92,25.61 221.92,25.84 221.69,26.07 221.3,26.07 221.23,26.14 UE1.11 ; v2(65.41,48.38) 65.26,48.53 55.18,48.53 54.32,47.67 54.32,46.51 v2(54.37,46.46)
  IN1 w0.114: v2(151.51,24.77) 151.51,24.96 151.17,25.3 148.94,25.3 145.67,28.58 145.67,29.83 143.95,31.55 143.95,33.16 143.57,33.54 143.57,40.38 138.11,45.83 138.11,51.91 v2(138.14,51.93) 138.49,52.29 138.49,64.8 143.25,69.56 143.25,73.38 143.32,73.45 v2(143.57,73.45)
  IN3 w0.127: v2(151.51,24.77) 151.44,24.7 151.44,24.06 154.12,21.39 154.95,21.39 156.36,19.98 158.46,19.98 158.62,19.83 160.28,19.83 160.87,19.24 166.43,19.24 167.27,18.41 169.99,18.41 170.95,17.44 170.95,16.88 173.32,14.52 178.17,14.52 179,15.35 179,16.3 181.92,19.22 186.26,19.22 188.35,21.3 190.13,21.3 190.99,22.16 198.33,22.16 199.25,23.08 206.01,23.08 207.1,24.17 214.26,24.17 216.09,22.34 219.26,22.34 220.32,21.28 224.21,21.28 224.75,20.75 224.75,20.51 v2(224.95,20.31)
  BOTTOM w0.102: v2(224.95,20.31) 224.75,20.51 224.75,23.48 225.18,23.91 225.18,24.5 224.93,24.76 223.58,24.76 RE45.1 222.27,25.26 v2(222.16,25.38) ; v2(138.14,51.93) 138.01,52.06 137.17,52.06 136.53,51.43 68.08,51.43 67.07,50.41 67.07,48.94 66.65,48.53 65.57,48.53 v2(65.41,48.38) ; v2(54.37,46.46) 54.37,46.33 54,45.96 RT6.2 53.81,46.85 QT2.6 ; v2(151.51,24.77) 151.51,24.52 150.87,23.88 QH5.3 ; QV1.3 148.83,72.37 147.91,71.44 147.21,71.44 146.22,72.43 144.85,72.43 144.13,73.15 144.13,73.71 144.01,73.83 143.72,73.83 143.57,73.68 v2(143.57,73.45)
GPU_TON: length 2.6
  TOP w0.102: v1(178.8,55.11) v2(179.16,54.75)
  TOP w0.254: v2(179.16,54.75) 179.36,54.55 PR1011.2
  BOTTOM w0.254: PU1000.9 178.75,55.16 179.17,54.75 v2(179.16,54.75)
GPU_VID: length 3.3
  BOTTOM w0.254: PR1000.2 178.72,58.97 178.13,58.38 178.02,58.38 v1(177.69,58.05) 177.42,57.78 177.05,57.78 176.76,57.49 PU1000.5
GPU_VREF: length 4
  TOP w0.102: v2(179.26,56.1) 178.9,56.45 v1(178.9,56.56)
  TOP w0.254: PR1002.1 179.61,55.69 179.26,56.05 v2(179.26,56.1)
  BOTTOM w0.254: PC1000.1 179.97,55.41 179.94,55.41 v2(179.26,56.1) 178.82,55.66 PU1000.8
GVDD: length 19.6
  TOP w0.127: v2(269.73,22.93) v1(268.79,21.99)
  TOP w0.508: v2(266.46,24.63) 266.46,23.94 267.46,22.94 269.07,22.94
  IN2 w0.508: v2(261.73,24.55) 262.52,25.34 265.74,25.34 v2(266.46,24.63)
  BOTTOM w0.254: UA2.2 262.28,21.73 261.74,22.27 261.66,22.27 260.97,22.95 ; UA2.1 261.78,21.65 261.63,21.81 261.4,21.81 260.97,22.24 260.97,22.95 ; 260.97,22.95 CD93.1
  BOTTOM w0.381: RA61.1 269.45,23.21 v2(269.73,22.93) 269.15,22.34 RA60.1
  BOTTOM w0.508: v2(266.46,24.63) 266.33,24.5 RA63.1 ; v2(261.73,24.55) 261.88,24.4 RA65.1 261.33,23.94 260.94,23.56 CD93.1
H_CATERR#: length 5.5
  TOP w0.102: v2(90.56,95.49) v1(90.05,94.99) RH144.2
  BOTTOM w0.102: UH1.BM30 90.24,95.15 90.56,95.47 v2(90.56,95.49)
H_CPUPWRGD: length 191.2
  TOP w0.102: v2(79.18,95.72) v3(79.18,94.99)
  IN3 w0.127: v2(191.14,38.43) 191.14,38.43 191.14,38.42 191.65,38.93 191.65,46.73 185.33,53.05 185.33,56.51 182.18,59.65 180.66,59.65 172.91,67.4 172.91,68.75 172.73,68.93 172.73,69.54 172.37,69.89 172.37,71.95 171.93,72.39 171.35,72.39 167.64,76.09 159.52,76.09 158.94,76.67 156.68,76.67 155.05,78.3 154.47,78.3 152.64,80.13 152.64,85.7 130.91,107.43 87.31,107.43 78.57,98.7 78.57,96.21 79.05,95.72 v2(79.18,95.72)
  BOTTOM w0.076: 87.05,95.83 87.13,95.91 UH1.BT31 ; UH2.AM3 177.85,28.35 178.09,28.58 181.02,28.58 181.57,29.13 181.57,29.78
  BOTTOM w0.102: 87.05,95.83 86.49,95.27 84.06,95.27 83.25,96.08 82.81,96.08 82.18,96.71 80.35,96.71 79.35,95.72 v2(79.18,95.72) ; v2(191.14,38.43) 191.14,38.43 190.75,38.04 190.5,38.04 190.22,37.76 188.22,37.76 186.83,36.36 186.83,34.71 186.53,34.42 185.2,34.42 184.19,33.4 184.19,32.81 183.38,32 183.38,31.59 181.87,30.09 181.57,29.78
H_DRAMRST#: length 93.4
  IN2 w0.127: v2(143.49,21.48) 142.35,21.48 141.59,20.72 139.1,20.72 137.93,19.55 96.9,19.55 96.28,18.93 v2(96.28,18.71)
  IN3 w0.127: v2(143.49,21.48) 144.49,22.47 144.49,23.21 148.37,27.09 151.71,27.09 154.14,24.66 154.14,23.09 154.89,22.34 155.46,22.34 156.74,21.06 158.64,21.06 158.98,20.72 160.13,20.72 160.47,21.06 161.4,21.06 162.03,21.69 162.88,21.69 163.48,22.29 170.5,22.29 171.15,21.64 171.86,21.64 172.17,21.33 172.17,20.97 172.5,20.64 v2(172.83,20.64)
  BOTTOM w0.076: v2(172.83,20.64) 173.01,20.82 173.01,22.01 172.88,22.14 172.88,22.83 UH2.BC14
  BOTTOM w0.114: RD35.2 RD31.2 96.05,16.58 CD69.1 95.39,16.63 95.23,16.78 95.23,17.67 v2(96.28,18.71)
H_PM_DOWN: length 192
  IN2 w0.127: v2(83.73,96.71) 83.73,100.27 89.63,106.17 101.27,106.17 102.07,105.37 104.33,105.37 105.04,106.09 131.68,106.09 140.34,97.42 140.34,84.67 146.52,78.5 146.52,76.38 147.3,75.59 147.3,70.78 147.03,70.5 147.03,63.13 140.9,57.01 140.9,47.21 143.04,45.08 147.51,45.08 150.15,47.72 169.91,47.72 170.72,48.53 178.01,48.53 181.78,44.76 181.78,42.24 186.22,37.81 186.22,35.31 183.23,32.33 183.23,32.01 182.74,31.51 182.13,31.51 v2(181.7,31.94)
  BOTTOM w0.076: UH2.AH2 178.66,29.91 179.92,29.91 180.45,30.44 180.45,30.77 181.62,31.94 v2(181.7,31.94)
  BOTTOM w0.102: v1(84.16,96.28) v2(83.73,96.71) 82.76,96.71 RH155.1
H_PM_DOWN_R: length 6.5
  BOTTOM w0.076: 87.11,96.19 88.07,96.19 88.11,96.23 88.59,96.23 UH1.BP31
  BOTTOM w0.102: RH155.2 v1(85.2,97.37) 86.39,96.19 87.11,96.19
H_PM_SYNC_R: length 170.6
  IN2 w0.127: v2(184.95,36.24) 184.95,37.64 180.77,41.82 180.77,44.34 177.59,47.51 171.14,47.51 170.33,46.7 150.57,46.7 147.93,44.06 142.61,44.06 139.89,46.79 139.89,57.43 144.21,61.75 144.21,71.12 144.87,71.79 144.87,76.18 141.64,79.42 140.85,79.42 137.49,82.78 137.49,94.73 137.81,95.05 137.81,96.88 133.65,101.05 132.12,101.05 128.68,104.49 122.42,104.49 121.45,103.52 116.11,103.52 115.25,104.38 110.63,104.38 109.46,103.22 109.46,103.2 109.08,102.82 101,102.82 100.25,103.57 90.33,103.57 89.21,102.46 89.21,99.46 89.85,98.82 v2(89.85,97.88)
  BOTTOM w0.076: UH1.BM34 90.18,97.6 89.9,97.88 v2(89.85,97.88)
  BOTTOM w0.102: RH189.2 184.52,35.8 v2(184.95,36.24)
H_PROCHOT#: length 355
  TOP w0.102: PR215.2 PR216.2 48.46,44.87 48.87,45.28 48.87,47.11 v2(48.04,47.95) PR217.2 ; v3(69.1,81.73) v2(69.1,82.41) 68.74,82.41 68.46,82.69 PR1109.1
  IN1 w0.114: v2(55.05,26.6) 56.79,26.6 58.53,24.86 58.53,23.36 58.3,23.13 58.3,21.71 60.18,19.83 61.75,19.83 66.1,15.48 71.58,15.48 72.42,16.32 95.79,16.32 96.03,16.07 96.03,15.7 96.29,15.44 102.84,15.44 104.21,16.8 109.9,16.8 111.39,15.32 114.9,15.32 116.08,16.5 126.18,16.5 130.95,11.74 143.08,11.74 143.77,12.44 147.46,12.44 149.01,13.99 151.09,13.99 152.39,12.69 158.02,12.69 159.27,13.94 167.63,13.94 170.22,11.34 171.36,11.34 172.02,10.68 172.02,9.13 172.48,8.68 178.37,8.68 179.5,9.81 180.88,9.81 182.5,11.43 183.57,11.43 184.52,12.37 185.61,12.37 186.63,13.39 188.58,13.39 189.39,12.58 195.63,12.58 197.28,14.23 198.98,14.23 200.83,16.08 204.61,16.08 205.18,15.52 211.21,15.52 212.03,14.7 214.98,14.7 216.06,15.77 216.48,16.2 217.03,16.2 219.49,16.2 220.1,15.59 221.02,15.59 222.11,16.68 227.37,16.68 228.35,17.66 229.05,17.66 229.75,18.35 v2(230.59,18.35)
  IN2 w0.127: v2(69.1,82.41) 70.63,83.95 73.3,83.95 76.63,87.28 76.63,90.45 80.27,94.1 v2(81.16,94.1)
  IN3 w0.127: v2(61.55,71.69) 61.88,71.69 62.53,72.34 62.53,77.37 62.94,78.57 65.99,81.61 68.3,81.61 v2(69.1,82.41) ; v2(55.05,26.6) 55.07,26.6 55.59,27.12 55.59,29.01 55.05,29.54 53.91,29.54 50.35,33.1 43.82,33.1 42.53,34.39 42.53,37.44 44.37,39.28 47.06,39.28 47.48,39.7 47.48,47.39 v2(48.04,47.95)
  BOTTOM w0.102: RH158.1 84.24,94.76 83.17,94.76 RH165.2 83.02,94.4 82.71,94.1 v2(81.16,94.1) ; CE86.1 237.15,25.77 UE6.4 237.64,26.01 238.26,25.39 238.26,24.72 238.58,24.4 239.2,24.4 239.91,23.69 239.91,22.57 239.53,22.19 239.53,20.59 239.89,20.23 239.89,18.53 239.53,18.17 238.65,18.17 237.99,17.52 236.99,17.52 235.49,16.02 232.93,16.02 v2(230.59,18.35) ; v2(61.55,71.69) 61.55,64.34 62.84,63.05 62.84,59.52 63.32,59.04 63.32,55.34 58.35,50.37 52.32,50.37 51.37,49.42 49.51,49.42 v2(48.04,47.95) 48.02,47.92 45.47,47.92 43.38,45.84 40.3,45.84 39.17,45.52 38.36,45.08 36.96,43.68 34.48,43.68 34.18,43.38 32.37,43.38 31.51,42.52 PR326.2
H_PROCHOT#_R: length 3.2
  BOTTOM w0.076: UH1.BR30 87.9,94.82 87.12,94.82 86.98,94.68 v1(86.22,94.68) 85.76,94.68 85.68,94.61 RH158.2
H_PROCHOT_EC: length 7
  TOP w0.102: v2(237.2,26.56) 237.09,26.45 237.09,25.39 236.93,25.23 236.93,25.23 236.77,25.06 236.77,25.06 236.65,24.94 UE1.83
  BOTTOM w0.102: RE27.2 237.09,26.66 v2(237.2,26.56) 237.51,26.56 237.93,26.98 238.5,26.98 238.82,26.66 UE6.2 239.77,26.66 239.87,26.56 239.91,26.56 v1(240.19,26.28)
H_THERMTRIP#: length 8.6
  BOTTOM w0.076: 181.25,32.02 181.24,32.01 181.24,31.81 180.25,30.82 180.25,30.49 179.85,30.09 178.84,30.09 178.55,30.37 178.26,30.37 UH2.AJ3
  BOTTOM w0.102: RH191.1 183.4,34.48 v1(182.69,33.77) 182.69,33.11 181.89,32.31 181.54,32.31 181.25,32.02
H_THERMTRIP#_R: length 130.5
  TOP w0.102: v2(122.84,96.17) 122.84,96.05 122.5,95.71 RH163.2
  IN2 w0.127: v2(182.66,35.73) 181.69,36.7 181.69,38.43 180,40.11 180,44.02 177.43,46.6 171.31,46.6 170.62,45.91 161.1,45.91 161,45.81 150.76,45.81 148.23,43.28 142.31,43.28 139.07,46.52 139.07,57.7 143.09,61.71 143.09,72.89 139.35,76.62 139.35,77.29 135.77,80.87 135.77,92.39 134.63,93.53 134.63,98.54 133.08,100.09 132.32,100.09 130.6,101.81 127.87,101.81 127.28,101.23 126.12,101.23 123.45,98.57 123.45,96.78 v2(122.84,96.17)
  BOTTOM w0.076: v2(122.84,96.17) 122.84,96.13 123.16,95.81 UH1.J31
  BOTTOM w0.102: RH191.2 182.74,35.8 v2(182.66,35.73) 182.27,35.73 v1(182.16,35.84)
H_VCCST_PWRGD: length 3.9
  TOP w0.102: RH164.2 RH154.1 132.18,76.97 UC16.4 133.1,77.73 v1(133.51,78.15)
HDA_BITCLK: length 10.7
  BOTTOM w0.089: UH2.BA9 175.09,23.44 175.15,23.37 175.15,22.28 175.66,21.77 175.66,21.39
  BOTTOM w0.102: RP15.7 180.47,18.61 CH50.2 180.3,18.84 179.87,19.27 178.9,19.27 178.58,18.95 v1(178.28,18.95) 178.12,18.95 176.64,20.44 176.62,20.44 175.66,21.39
HDA_BITCLK_AUDIO: length 113.2
  IN3 w0.127: v2(188.38,12.32) 188.88,12.83 188.88,13.53 189.68,14.33 199.17,14.33 200.65,15.81 207.91,15.81 209.24,14.48 215.54,14.48 216.54,15.48 219.34,15.48 219.97,14.85 221.37,14.85 221.71,15.19 231.11,15.19 232.12,16.2 235.09,16.2 237.14,18.24 238.06,18.24 240.08,20.26 245.07,20.26 246.01,21.2 252.82,21.2 256.03,17.99 256.03,16.84 256.85,16.02 264.98,16.02 265.4,16.02 266.18,16.79 266.18,20.78 267.87,22.47 270.15,22.47 270.46,22.79 271.55,22.79 272.06,23.3 v2(272.06,23.67)
  BOTTOM w0.102: RA31.1 276.08,23.92 CA32.1 274.61,23.92 RA35.2 274.53,23.31 274.08,22.85 273.83,22.85 273.17,23.51 272.23,23.51 v2(272.06,23.67) ; v2(188.38,12.32) 188.14,12.56 186.93,12.56 186.36,13.13 184.63,13.13 v1(184.46,13.3) 184.16,13.6 181.93,13.6 180.47,15.06 RP15.2
HDA_CODEC_SDIN0: length 3
  TOP w0.102: HDA1.8 277.43,24.15 277.39,24.12 v1(277.06,24.12) 276.28,24.12 275.9,23.74 RA32.2
HDA_SDIN0: length 8.5
  BOTTOM w0.102: UH2.BE7 175.89,21.62 176.59,20.92 180.17,20.92 RH96.2 v1(182.05,18.1)
HDA_SDIN0_AUDIO: length 112.2
  TOP w0.102: v2(273.9,23.36) 273.92,23.33 274.1,23.33 RA32.1
  IN3 w0.127: v2(273.9,23.36) 273.1,24.15 271.91,24.15 271.18,23.42 268.1,23.42 265.67,20.99 265.67,17 265.19,16.53 260.08,16.53 257.54,19.07 255.67,19.07 252.95,21.78 245.81,21.78 244.79,20.77 239.69,20.77 238.1,19.18 238.1,19 237.85,18.75 236.93,18.75 234.95,16.77 231.95,16.77 230.9,15.71 220.99,15.71 220.69,15.41 220.28,15.41 219.49,16.2 216.51,16.2 215.32,15.01 209.65,15.01 208.21,16.45 200.57,16.45 198.97,14.85 189.43,14.85 188.38,13.8 v2(188.38,12.93)
  BOTTOM w0.102: v2(188.38,12.93) 188.38,13.07 186.78,14.67 184.57,14.67 184.46,14.57 182.6,14.57 181.98,15.2 181.98,17.44 182.97,18.43 RH96.1
