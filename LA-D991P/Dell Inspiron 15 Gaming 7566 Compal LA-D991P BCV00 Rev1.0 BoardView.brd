# Allegro board Dell Inspiron 15 Gaming 7566 Compal LA-D991P BCV00 Rev1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N129707905: length 1.7
  BOTTOM w0.254: PU1400.26 121.95,128.43 121.45,128.93
  BOTTOM w0.305: PR1403.2 121.09,128.93 121.45,128.93
N129708017: length 4.7
  BOTTOM w0.102: v1(127.16,133.37) 127.16,131.77 126.93,131.54 126.68,131.54 126.5,131.36 PR1405.2
  BOTTOM w0.305: PU1400.7 126.16,129.9
  BOTTOM w0.508: PR1405.2 126.16,130.53 126.16,129.9
N129708019: length 2.4
  BOTTOM w0.102: PC1402.1 v1(125.23,133.39)
  BOTTOM w0.508: PC1402.1 PR1405.1
N129708021: length 1.9
  BOTTOM w0.305: 125.41,129.96 125.16,129.72 PU1400.5
  BOTTOM w0.508: PC1402.2 125.41,130.69 125.41,129.96
N129708031: length 2.8
  BOTTOM w0.254: PR1401.2 121.42,131 121.95,130.48 122.15,130.48 v1(122.44,130.19) 122.73,129.9 122.73,129.9 123.16,129.47 PU1400.1
N129708035: length 2.5
  BOTTOM w0.254: PR1404.2 122.31,130.93 123.66,129.57 PU1400.2
N129708047: length 3.7
  TOP w0.102: v2(121.55,128.01) v1(122.23,128.01)
  TOP w0.508: PR1400.2 121.04,128.51 v2(121.55,128.01)
  BOTTOM w0.305: PU1400.24 121.83,127.43 121.82,127.43 121.4,127.43 121.4,127.43 120.99,127.43 PC1400.1
  BOTTOM w0.508: PC1400.1 120.98,127.5 121.49,128.01 v2(121.55,128.01)
N129708951: length 2.9
  BOTTOM w0.305: PU1400.3 124.16,129.84 124.04,129.96
  BOTTOM w0.508: PR1402.2 PC1401.2 124.09,130.42 124.04,130.37 124.04,129.96
N129713259: length 4.2
  BOTTOM w0.102: PR1418.2 110.36,129.28 110.36,130.86 v1(110.08,131.14)
  BOTTOM w0.254: PU1401.26 111.6,128.43 111.21,128.82
  BOTTOM w0.305: 111.21,128.82 PR1418.2
N129713349: length 1.7
  BOTTOM w0.305: PU1401.7 116,129.9
  BOTTOM w0.508: PR1419.2 116,130.78 116,129.9
N129713351: length 2.7
  BOTTOM w0.102: PC1412.1 114.06,133.02 v1(114.06,133.39)
  BOTTOM w0.508: PC1412.1 PR1419.1
N129713353: length 2
  BOTTOM w0.305: PU1401.5 115,129.72 115.25,129.96
  BOTTOM w0.508: 115.25,129.96 115.25,130.43 PC1412.2
N129713363: length 5
  BOTTOM w0.102: PR1415.2 110.78,131.1 110.08,131.8 v1(110.08,132.49)
  BOTTOM w0.254: PR1415.2 111.01,130.93 112.27,129.67 112.77,129.67 113,129.44 PU1401.1
N129713367: length 2.9
  BOTTOM w0.254: PU1401.2 113.5,129.55 113.19,129.87 112.85,130.2 v1(112.53,130.2) 112.34,130.2 111.9,130.65 PR1417.2
N129713379: length 3.5
  TOP w0.127: v2(110.82,128.13) v1(110.82,127.46)
  TOP w0.508: v2(110.82,128.13) 110.88,128.2 PR1414.2
  BOTTOM w0.305: PC1410.1 110.83,127.43 111.24,127.43 111.24,127.43 111.66,127.43 111.67,127.43 PU1401.24
  BOTTOM w0.508: PC1410.1 v2(110.82,128.13)
N129714262: length 2.9
  BOTTOM w0.305: 113.8,130.04 114,129.84 PU1401.3
  BOTTOM w0.508: PR1416.2 PC1411.2 113.67,130.17 113.8,130.04
N129715037: length 2.6
  BOTTOM w0.102: v1(99.98,128.92) 100.21,128.69 PR1432.2
  BOTTOM w0.254: 101.31,128.69 101.69,128.3 PU1402.26
  BOTTOM w0.305: 101.31,128.69 PR1432.2
N129715137: length 4.8
  BOTTOM w0.102: v1(107.1,133.26) 107.1,131.63 106.96,131.49 106.69,131.49 106.44,131.23 PR1433.2
  BOTTOM w0.305: PU1402.7 106.1,129.78
  BOTTOM w0.508: 106.1,129.78 106.1,130.4 PR1433.2
N129715139: length 2.5
  BOTTOM w0.102: PC1419.1 v1(105.17,133.37)
  BOTTOM w0.508: PC1419.1 PR1433.1
N129715141: length 1.9
  BOTTOM w0.305: 105.34,129.83 105.1,129.59 PU1402.5
  BOTTOM w0.508: PC1419.2 105.34,130.56 105.34,129.83
N129715151: length 3.8
  BOTTOM w0.102: PR1429.2 v1(100.26,130.98)
  BOTTOM w0.254: PR1429.2 101.36,130.88 102.73,129.5 102.91,129.5 103.1,129.31 PU1402.1
N129715155: length 2.6
  BOTTOM w0.254: PU1402.2 103.6,129.46 102.97,130.09 v1(102.72,130.09) 102.24,130.56 PR1431.2
N129715167: length 3.4
  TOP w0.102: v2(100.91,127.93) v1(100.91,127.38)
  TOP w0.508: PR1428.2 100.97,127.99 v2(100.91,127.93)
  BOTTOM w0.305: PU1402.24 101.76,127.3 101.76,127.31 101.34,127.31 101.33,127.3 100.93,127.3 PC1418.1
  BOTTOM w0.508: PC1418.1 v2(100.91,127.93)
N129715635: length 2.9
  BOTTOM w0.305: 103.97,129.83 104.1,129.71 PU1402.3
  BOTTOM w0.508: PR1430.2 PC1420.2 104.02,130.29 103.97,130.24 103.97,129.83
N129716454: length 3.6
  BOTTOM w0.102: v1(90.12,130.51) 90.26,130.37 90.26,129.49 90.29,129.45 90.29,129.15 PR1504.2
  BOTTOM w0.254: PU1500.26 91.56,128.3
  BOTTOM w0.305: PR1504.2 90.81,128.69 91.2,128.3 91.56,128.3
N129716544: length 1.8
  BOTTOM w0.305: PU1500.7 95.81,129.78
  BOTTOM w0.508: 95.81,129.78 95.81,130.4 PR1505.2
N129716546: length 2.8
  BOTTOM w0.102: PR1505.1 v1(97.69,132.13)
  BOTTOM w0.508: PC1502.1 PR1505.1
N129716548: length 1.9
  BOTTOM w0.305: PU1500.5 94.81,129.59 95.06,129.83
  BOTTOM w0.508: 95.06,129.83 95.06,130.56 PC1502.2
N129716558: length 4.3
  BOTTOM w0.102: PR1501.2 90.48,130.98 90.12,131.35 v1(90.12,131.8)
  BOTTOM w0.254: PU1500.1 92.81,129.31 92.59,129.53 92.35,129.53 91.07,130.81 PR1501.2
N129716562: length 2.6
  BOTTOM w0.254: PR1503.2 91.96,130.57 v1(92.45,130.08) 92.66,130.08 93.31,129.42 PU1500.2
N129716574: length 3.6
  TOP w0.102: v2(90.51,128.03) v1(90.51,127.35)
  TOP w0.508: v2(90.51,128.03) 90.69,128.21 PR1500.2
  BOTTOM w0.305: PC1500.1 90.64,127.3 91.05,127.3 91.05,127.31 91.47,127.31 91.47,127.3 PU1500.24
  BOTTOM w0.508: PC1500.1 90.62,127.92 v2(90.51,128.03)
N129717674: length 2.9
  BOTTOM w0.305: PU1500.3 93.81,129.71 93.69,129.83
  BOTTOM w0.508: 93.69,129.83 93.69,130.24 93.74,130.29 PC1501.2 PR1502.2
N129718561: length 2.8
  BOTTOM w0.102: PR1516.2 v1(69.61,107.89)
  BOTTOM w0.254: PU1501.26 70.86,108.13 PR1516.2
N129718659: length 4.8
  BOTTOM w0.102: PR1517.2 68.03,113.66 67.83,113.86 67.83,114.11 67.62,114.32 v1(65.9,114.32)
  BOTTOM w0.305: PU1501.7 69.31,113.32
  BOTTOM w0.508: 69.31,113.32 68.97,113.66 PR1517.2
N129718661: length 2.4
  BOTTOM w0.102: PC1510.1 v1(65.97,112.39)
  BOTTOM w0.508: PR1517.1 PC1510.1
N129718663: length 1.8
  BOTTOM w0.305: 69.28,112.56 69.52,112.32 PU1501.5
  BOTTOM w0.508: 69.28,112.56 68.7,112.56 PC1510.2
N129718673: length 4
  BOTTOM w0.102: 68.29,108.58 PR1513.2 68.29,107.43 v1(68.33,107.38)
  BOTTOM w0.254: PU1501.1 69.74,110.32 68.84,109.43 68.84,109.03 68.39,108.58 68.29,108.58
N129718677: length 4.6
  BOTTOM w0.102: PR1515.2 68.29,109.2 68.09,109.01 v1(66.43,109.01)
  BOTTOM w0.254: PR1515.2 68.32,109.46 69.68,110.82 PU1501.2
N129718689: length 5.2
  BOTTOM w0.102: PC1508.1 72.96,107.89 73.42,107.43 v1(74.69,107.43)
  BOTTOM w0.254: PU1501.24 71.86,108.99 71.76,108.89 71.76,108.7
  BOTTOM w0.508: 71.76,108.7 71.51,108.45 PR1512.2 PC1508.1
N129719256: length 2.7
  BOTTOM w0.305: PU1501.3 69.05,111.32 68.97,111.24
  BOTTOM w0.508: PR1514.2 PC1509.2 68.97,111.24
N129830333: length 2.5
  BOTTOM w0.203: PR407.2 54.49,19.04 54.25,19.28 53.49,19.28 53.14,19.63 PU400.6
N129937820: length 4
  TOP w0.102: v2(133.61,116.32) v1(134.38,115.56)
  TOP w0.254: v2(133.61,116.32) 132.8,116.32 PR1529.1
  BOTTOM w0.254: v2(133.61,116.32) 133.87,116.32 134.12,116.07 PL1505.3
N129937845: length 3.6
  TOP w0.102: v2(133.61,116.96) v1(134.3,116.96)
  TOP w0.254: v2(133.61,116.96) 133.04,116.96 PR1528.1
  BOTTOM w0.254: v2(133.61,116.96) 133.87,116.96 134.12,117.21 PL1505.2
N130402506: length 3
  TOP w0.102: v3(246.94,29.92) 246.39,30.47 246.39,32.67
N130402546: length 7.5
  TOP w0.102: JFAN1.3 54.01,32.08 DE7.1 53.98,31.32 54.37,30.94 54.37,30.19 RE82.2 54.85,29.45 55.69,28.62 55.69,28.13 55.74,28.08 v3(55.74,27.9)
N130402633: length 5.6
  TOP w0.254: JFAN2.3 244.5,36.93 RE84.2 244.48,38.02 DE9.1 244.55,38.51 243.56,39.5 v3(243.56,39.87)
N130433988: length 3.1
  BOTTOM w0.102: v1(171.9,57.83) 171.9,59.95 172.34,60.38 PC1001.1
N130434002: length 1.4
  TOP w0.102: PC1030.1 v1(164.16,53.09)
N130435744: length 1.2
  BOTTOM w0.102: PC1033.1 v1(173.11,48.76)
N130435872: length 1.3
  TOP w0.102: 143.24,58.31 v1(143.24,59.65)
N130438051: length 1.6
  TOP w0.102: PC1082.1 v1(192.99,72.08)
N130584913: length 1.5
  TOP w0.102: v2(170.24,27.19) 169.81,27.63 T92.1
  BOTTOM w0.102: UH2.AR17 170.52,26.91 v2(170.24,27.19)
N130791078: length 17.1
  TOP w0.102: RV571.2 157.16,74.31 156.19,74.31 156.07,74.44 152.26,74.44 v1(151.52,73.7) 151.29,73.47 151.15,73.47 150.32,72.63 150.32,72.38 v2(150.03,72.09)
  BOTTOM w0.102: v2(150.03,72.09) 149.76,72.36 149.76,72.71 149.65,72.82 149.36,72.82 QV1.2 149.38,73.02 149.78,73.41 149.78,73.92 149.42,74.27 149.41,74.27 149.4,74.28 147.02,74.28 RV572.2 146.72,73.4 147.1,73.02 QV1.5
N130949507: length 3.5
  BOTTOM w0.076: 169.66,20.54 169.95,20.84 169.95,20.86 170.47,21.37 170.47,21.56 170.49,21.59 170.49,22.34 170.6,22.45 170.6,22.69 170.49,22.79 170.49,22.95 UH2.BC18
  BOTTOM w0.102: 169.66,20.54 169.61,20.49 T1.1
N130955932: length 2.6
  TOP w0.102: RA72.1 283.56,18.28 283.03,17.74 v1(283.03,16.94)
  TOP w0.381: CA21.2 RA72.1
N130956130: length 2
  BOTTOM w0.102: CD92.2 RA73.1 v1(257.92,24.7)
N130959682: length 4
  BOTTOM w0.305: RE60.1 245.7,34.03 v3(246.58,34.03) 246.91,34.03 247.29,34.41 JDEG1.1
N130960109: length 1.1
  BOTTOM w0.102: T3.1 252.1,30.56 RE111.2
N130982801: length 5.7
  BOTTOM w0.102: v1(279.89,40.71) RL43.2
  BOTTOM w0.203: 283.01,43.38 283.32,43.69 UL1.26
  BOTTOM w0.254: 283.01,43.38 282.03,42.41 282.03,41.78 280.96,40.71 RL43.2
N131144481: length 5.5
  TOP w0.102: UM1.F2 266.89,32.75 267.29,32.35 267.29,31.99 267.55,31.74 270.19,31.74 v1(270.29,31.84) 270.57,32.12 RM19.1
N131307421: length 5.1
  TOP w0.102: v1(65.24,19.37) 65.73,19.87 CV578.2 ; CV578.2 65.42,21 QV11.3 ; CV578.2 65.97,20.93 RV535.2 RV570.1
N131307439: length 2.3
  TOP w0.102: QV2.1 66.89,23.86 RV570.2 v1(67.98,22.72)
N131311358: length 3.3
  BOTTOM w0.102: RC11.1 155.39,16.83 v1(155.69,17.12)
  BOTTOM w0.508: RC11.1 154.24,16.83 153.44,17.63 DC2.2
N131431549: length 3.8
  BOTTOM w0.102: RH504.2 14.25,18.44 QE20.3 ; RH504.2 QE20.2 ; RH504.2 v1(12.61,19.09)
N131431604: length 3.6
  BOTTOM w0.102: RH505.2 v1(16.52,22.01)
  BOTTOM w0.254: QE23.6 16.15,21.36 RH505.2 QE23.5
N131431963: length 2.2
  BOTTOM w0.102: v1(284.62,57.98) RW3.1 285.76,57.95 LED3.2
N131431980: length 2.3
  TOP w0.102: v1(208.16,31.56) LED4.2 207.23,32.64 RW4.1
N131432059: length 3.6
  BOTTOM w0.102: QE24.5 286.9,59.86 287.11,60.06 287.11,60.37 286.96,60.51 QE24.6 285.87,60.51 RH506.2 285.71,61.46 v1(286.04,61.79)
N131436195: length 5.6
  TOP w0.254: Q12.1 59.01,31.54 59.9,31.54 60.18,31.82 v3(60.18,33.57)
  TOP w1.016: Q12.1 58.25,32.3 56.75,32.3
N131438652: length 8.9
  TOP w0.102: RV56.1 148.7,81.68 148.7,80.56 148.85,80.41 150.07,80.41 150.37,80.1 150.37,79.42 v1(148.39,77.43) 147.95,77.43 147.56,77.04 147.56,76.15 QV3.5
N131522020: length 9.6
  BOTTOM w0.102: v1(208.98,55.95) PR113.2
  BOTTOM w0.114: PR113.2 209.46,56.48 210.25,56.48 PR115.1 212,58.23 212,59.98 212.56,60.54 212.56,61.18 212.4,61.34 212.1,61.34 211.82,61.62 PQ103.5
N132541936:
  vias: v1(255.23,23.31)
N132541970: length 2.9
  BOTTOM w0.102: v1(256.75,23.64) RA79.2 256.75,25.53 QA1.1
N132753431:
  vias: v2(136.13,128.11) v2(136.41,127.42) v2(136.59,128.82) v2(136.94,128.08) v2(137.58,128.79) v2(137.88,128.08) v3(134.76,127.93)
N132753897: length 3.2
  BOTTOM w0.102: PR1532.1 130.83,127.37 131.63,128.17 v1(131.63,128.29)
  BOTTOM w0.254: PU1503.12 131.82,126.49 131.28,127.03 131.03,127.03 PR1532.1
N132753926: length 1.4
  TOP w0.102: v2(131.33,126.23) v1(131.86,126.23)
  TOP w0.508: PR1533.2 130.82,126.74 v2(131.33,126.23)
N132753938: length 1.4
  BOTTOM w0.102: v1(134.73,131.56) 135.26,131.03 PR1527.1
N132754030: length 3.7
  BOTTOM w0.102: v1(130.9,129.61) 131.25,129.25 PR1530.2
  BOTTOM w0.254: PU1503.1 132.46,127.24 132.04,127.66 132.04,128.45 131.84,128.66 PR1530.2
N132754050: length 1.9
  TOP w0.127: v1(132.72,127.75) 132.95,127.75 133.11,127.9 v2(133.11,128.51)
  TOP w0.508: PR1531.2 132.85,128.77 v2(133.11,128.51)
N133033957: length 3.1
  TOP w0.102: v1(22.17,35.05) 22.49,35.37 PQ306.4
  TOP w0.508: PR325.1 22.84,36.67 PQ306.4
N133034293: length 3.1
  TOP w0.102: v1(16.9,33.37) 16.9,33.67 17.69,34.46 PR303.1
  TOP w0.508: PR303.1 17.69,35.45 17.92,35.68 v2(17.92,36.06)
N201821498: length 3.1
  TOP w0.203: v2(281.42,20.58) 281.51,20.68 HDA1.19
  BOTTOM w0.102: v2(281.42,20.58) 280.98,20.58 v1(280.71,20.31)
  BOTTOM w0.203: CA23.1 281.63,20.79 281.42,20.58 v2(281.42,20.58)
N201821507: length 2.4
  TOP w0.203: 285.48,27.12 285.51,27.09 v1(285.51,26.71) 285.24,26.44 285.16,26.44 284.87,26.15 HDA1.34
  TOP w0.254: 285.48,27.12 285.48,27.52 CA15.2
N201821575: length 3.8
  TOP w0.102: CA16.2 v1(287.06,24.68)
  TOP w0.203: CA16.2 285.23,23.64 285.11,23.76 HDA1.28
N201821604: length 2.6
  TOP w0.203: HDA1.7 277.66,24.55 277.58,24.48 277.24,24.48 277.22,24.5 276.9,24.5 276.88,24.48 276.32,24.48 CA27.1
N201821615: length 3.1
  TOP w0.203: HDA1.35 284.79,26.55 285.07,26.83 285.07,27.22 v2(284.87,27.42)
  BOTTOM w0.102: v2(284.87,27.42) 284.55,27.42 v1(284.19,27.05)
  BOTTOM w0.203: v2(284.87,27.42) 285.52,27.42 CA20.2
N201821733: length 2.5
  TOP w0.203: HDA1.37 283.51,28.07 283.6,28.16 v2(284.11,28.16)
  BOTTOM w0.203: CA20.1 285.54,28.36 v1(284.67,28.36) 284.31,28.36 v2(284.11,28.16)
N201821740: length 4.1
  TOP w0.203: RA11.2 287.11,21.58 287.11,22.37 CA19.2 286.9,22.7 286.42,23.18 286.35,23.18 286.29,23.23 v1(285.84,23.23) 285.79,23.28 285.07,23.28 285,23.36 HDA1.27
N1290221070: length 1
  TOP w0.102: RA36.1 270.52,23.76 CA34.2
N1290221251: length 0.7
  TOP w0.102: RA37.1 CA35.2
N1323149380: length 5.2
  BOTTOM w0.102: T91.1 153.58,38.6 153.65,38.67 155.41,38.67 157.18,36.91 157.41,36.91 157.58,36.74 UH2.R44
N1323150428: length 5.3
  BOTTOM w0.102: UH2.U42 158.58,35.83 157.95,36.46 157.3,36.46 155.48,38.28 154.74,38.28 154.72,38.27 T94.1
N13231504269: length 1.3
  TOP w0.089: T182.1 162.92,31.03 v2(162.47,30.57)
  BOTTOM w0.089: v2(162.47,30.57) 162.11,30.93 UH2.AG35
N13248890811: length 4.1
  BOTTOM w0.089: UH2.AL42 158.43,28.76 158.22,28.97 157.9,28.97 157.8,29.07 156.63,29.07
  BOTTOM w0.102: T120.1 155.71,29.99 156.63,29.07

## Copper pours and planes (outline as drawn)
1.2V_DTH on TOP (solid shape): 258.58,28.34 258.58,27.91 258.58,27.58 258.17,27.17 258.17,26.22 258.15,26.2 257.59,26.2 257.59,27.49 257.54,27.54 257.54,28.41 257.64,28.51 258.4,28.51
1.2V_VCCPLL_OC on TOP (solid shape): 72.43,47.84 72.43,46.73 72.3,46.6 70.48,46.6 70.32,46.76 70.32,47.86 70.38,47.92 72.35,47.92
3VS on TOP (solid shape): 212.66,16.12 213.19,16.12 213.88,15.43 213.88,13.71 213.8,13.63 213.62,13.63 213.57,13.64 213.51,13.65 212.74,13.65 212.44,13.95 212.44,14.18 212.3,14.32 211.21,14.32 211.08,14.45 211.08,16.16 211.27,16.35 212.43,16.35
5VS on TOP (solid shape): 213.88,12.18 213.88,11.7 213.7,11.52 213.7,10.38 213.42,10.1 211.52,10.1 211.45,10.16 211.45,11.71 211.49,11.75 212.48,11.75 212.89,12.16 212.91,12.16 212.99,12.23 213.83,12.23
+0.6VS on TOP (solid shape): 138.88,21.67 138.88,18.93 138.77,18.81 136.92,18.81 136.85,18.88 136.85,21.39 137.4,21.94 138.62,21.94
+0.6VS on TOP (solid shape): 106.39,16.01 106.39,16.01 106.47,15.61 106.87,15.54 106.88,15.55 106.94,15.55 106.94,15.48 107.13,15.29 107.32,15.29 107.34,15.31 108.49,15.31 108.87,14.93 108.87,14.24 108.52,13.88 106.23,13.88 104.94,15.18 104.94,16.04 105.04,16.14 106.26,16.14
+0.6VS on TOP (solid shape): 137.63,31.8 137.63,31.79 137.9,31.54 138.25,31.66 138.32,31.69 138.39,31.66 138.44,31.61 138.44,29.57 138.44,29.49 138.19,29.23 138.19,27.39 138.41,27.16 138.41,25.26 137.91,24.76 137.45,24.76 137.27,24.93 137.27,25.74 137.35,25.81 137.35,26.24 136.79,26.79 136.79,27.81 136.78,27.82 136.78,28.97 136.28,29.47 136.27,29.52 136.26,29.55 136.26,29.96 136.27,29.98 136.27,30.3 136.26,30.32 136.26,30.68 136.27,30.69 136.27,31.01 136.26,31.03 136.26,31.38 136.28,31.51 136.26,31.65 136.26,31.77 136.36,31.87 137.56,31.87
+0.6VS on BOTTOM (solid shape): 137.04,33.47 137.04,31.87 137.17,31.74 137.42,31.74 137.75,31.41 137.75,30.7 137.6,30.55 137.12,30.55 136.76,30.9 136.76,33.52 136.79,33.54 136.97,33.54
+0.6VS on BOTTOM (solid shape): 137.73,21.73 137.73,21.61 137.1,20.98 137.1,20.95 137.04,20.89 137.04,19.19 136.76,19.19 136.74,19.22 136.74,20.49 136.76,20.51 136.76,21.12 136.78,21.14 136.78,21.52 137.12,21.86 137.6,21.86
+0.6VS on BOTTOM (solid shape): 106.11,16.42 106.11,16.19 106.12,16.18 106.12,16.09 106.2,16.09 106.23,16.08 106.27,16.04 106.31,15.99 106.33,15.96 106.33,15.71 106.23,15.61 106.05,15.61 105.98,15.53 105.95,15.53 105.61,15.19 104.91,15.19 104.91,15.66 104.9,15.68 104.9,15.75 104.85,15.75 104.85,15.98 104.9,15.98 104.9,16.41 105.06,16.58 105.95,16.58
+0.6VSP on BOTTOM (solid shape): 104.76,16.12 104.3,16.12 104.23,16.04 104.23,15.69 104.28,15.64 104.76,15.64 104.78,15.61 104.78,15.2 104.49,15.2 104.49,15.19 104.4,15.1 104.38,15.1 103.58,14.3 102.51,14.3 101.72,13.52 101.72,13.11 101.73,13.08 101.73,12.67 101.66,12.6 101.07,12.6 101,12.67 101,15.94 101.1,16.04 103.57,16.04 103.89,16.37 104.75,16.37 104.76,16.37
+0.95VSP on TOP (solid shape): 77.01,72.61 77.01,70.94 77.01,70.91 77,69.98 77.23,69.08 77.35,68.83 77.48,68.58 77.48,65.22 77.44,65.18 77.44,61.93 76.72,61.2 71.13,61.2 71,61.33 71,61.59 72.65,63.24 72.65,67.88 72.02,68.52 72.02,71.11 72.03,71.12 72.03,72.17 73.2,73.34 76.29,73.34
+0.95VSP on BOTTOM (solid shape): 76.46,73.02 76.46,65.9 76.08,65.52 73.07,65.52 72.59,66 72.61,66.03 72.62,66.23 72.53,66.4 72.5,66.47 72.63,66.79 72.5,67.11 72.53,67.18 72.62,67.49 72.42,67.75 72.42,73.07 72.72,73.37 76.11,73.37
+1.2V_DDR on TOP (solid shape): 132.38,45.21 117.38,45.21 117.38,55.21 132.38,55.21
+1.2V_DDR on TOP (solid shape): 258.45,31.49 258.45,30.01 258.33,29.89 257.64,29.89 257.57,29.96 257.57,30.24 257.57,30.3 257.57,31.49 257.69,31.61 258.33,31.61
+1.2V_DDR on TOP (solid shape): outline of 26955 points within 72.65,16.32 143.52,82.44
+1.2V_DDR on BOTTOM (solid shape): 119.14,8.14 119.14,7.48 118.88,7.23 116.96,7.23 116.77,7.42 116.77,8.3 116.89,8.41 118.87,8.41
+1.2V_DDR on BOTTOM (solid shape): 145.04,32.5 147.27,32.5 147.58,32.18 147.58,30.79 147.27,30.47 142.88,30.47 142.63,30.72 142.63,32.88 142.82,33.07 144.47,33.07
+1.2V_DDR on BOTTOM (solid shape): 113,18.8 113,18.54 113.01,18.53 113.01,18.43 113.17,18.28 114.12,18.28 114.57,17.83 115,17.83 115.16,17.67 115.16,15.14 115.05,15.03 113.52,15.03 113.52,15.53 112.89,15.53 112.88,15.53 112.81,15.53 112.81,15.45 112.79,15.43 112.79,15 112.34,15 112.34,15.55 112.33,15.56 111.59,15.56 111.59,15.03 110.63,15.03 110.14,15.51 110.14,17.44 109.15,18.43 109.15,18.81 109.2,18.86 112.2,18.86 112.25,18.91 112.89,18.91
+1.2V_DDR on IN1 (solid shape): 119.76,7.91 119.76,6.96 119.52,6.72 117.87,6.72 117.56,7.03 117.56,7.81 117.94,8.19 119.48,8.19
+1.2V_DDR on IN1 (solid shape): 157.95,8.21 157.95,7.03 157.66,6.73 156.77,6.73 156.54,6.96 156.54,8.33 156.7,8.5 157.66,8.5
+1.2V_DDRP on BOTTOM (solid shape): 110.35,14.85 111.72,14.85 111.74,14.87 111.74,15.38 111.77,15.41 112.2,15.41 112.2,14.87 112.23,14.85 112.91,14.85 112.91,15.33 112.96,15.38 113.37,15.38 113.37,14.95 113.41,14.92 113.41,14.88 114.06,14.88 114.11,14.84 114.11,12.61 113.55,12.05 113.55,9.6 111.3,9.6 110.93,9.24 107.66,9.24 107.66,13.3 107.2,13.76 104.99,13.76 104.63,13.4 104.61,13.4 104.18,12.97 103.18,12.97 102.81,12.59 101.99,12.59 101.85,12.73 101.85,13.08 101.85,13.12 101.85,13.46 102.56,14.18 103.63,14.18 104.43,14.98 105.6,14.98 106.11,15.48 109.71,15.48
+1.2V_DTH on TOP (solid shape): 260.75,27.92 260.75,27.23 260.87,27.12 260.87,26.69 260.39,26.2 258.91,26.2 258.89,26.21 258.89,27.96 258.91,27.97 260.7,27.97
+1.2V_DTH on BOTTOM (solid shape): outline of 347 points within 257.51,27.04 275.07,46.14
+1.2V_DTH on IN3 (solid shape): outline of 587 points within 258.07,27.02 263.28,42.66
+1.2V_VCCPLL_OC on IN3 (solid shape): outline of 3086 points within 92.21,79.14 124.22,82.79
+1.05VS_VGA on TOP (solid shape): 211.65,74 211.65,72.58 211.62,72.5 211.53,72.48 211.15,72.54 210.77,72.57 210.66,72.57 206.67,68.53 210.71,64.53 210.8,64.54 210.9,64.54 210.98,64.51 211.01,64.44 211.01,63.34 210.65,62.98 208.8,62.98 208.27,63.51 208.25,63.6 208.31,63.67 208.41,64.25 207.84,64.14 207.76,64.08 207.67,64.11 205.93,65.85 205.93,69.26 206.06,69.54 205.93,69.81 205.93,70.48 206.26,70.81 206.26,70.96 206.32,71.03 206.32,71.17 209.81,74.67 210.98,74.67
+1.05VS_VGA on TOP (solid shape): outline of 926 points within 153.55,86.86 162.95,109.34
+1.05VS_VGA on BOTTOM (solid shape): 211.28,44.75 211.28,44.15 210.73,44.15 210.73,43.39 211.28,43.39 211.28,42.95 210.73,42.95 210.73,42.19 211.28,42.19 211.28,41 211.04,40.76 209.56,40.76 209.55,40.77 208.94,40.77 208.21,41.49 208.21,43.73 209.43,44.95 211.08,44.95
+1.05VS_VGA on BOTTOM (solid shape): 151.26,104.9 151.29,104.83 151.16,104.51 151.29,104.19 151.26,104.12 151.18,103.79 151.41,103.54 151.44,103.53 151.44,102.99 151.32,102.86 150.17,102.86 150.02,103.01 150.02,104.94 150.1,105.02 151.14,105.02
+1.05VS_VGA on BOTTOM (solid shape): outline of 131 points within 156.09,85.72 161.95,98.8
+1.05VS_VGA on IN1 (solid shape): outline of 13482 points within 149.82,62.98 215.78,133.53
+1.05VS_VGA on IN2 (solid shape): outline of 755 points within 206.64,41.77 219.86,74.92
+1.05VS_VGA on IN3 (solid shape): outline of 233 points within 206.38,62.98 215.66,74.67
+1.05VS_VGA on VCC: outline of 293 points within 150.25,71.36 214.53,108.02
+1.05VSP on TOP (solid shape): 214,44.06 214,40.76 213.88,40.63 212.1,40.63 211.85,40.88 211.85,44.06 211.97,44.19 213.88,44.19
+1.05VSP on BOTTOM (solid shape): 215.78,47.32 215.78,44.31 215.02,43.55 214.77,43.55 214.13,42.92 214.13,40.76 211.66,40.76 211.43,40.98 211.43,42.35 210.89,42.35 210.89,42.79 211.43,42.79 211.43,43.55 210.89,43.55 210.89,43.99 211.43,43.99 211.43,45.3 213.62,47.49 215.61,47.49
+1.8VS on TOP (solid shape): 290.1,33.44 290.1,32.35 289.93,32.17 289.49,32.17 289.32,31.99 289.32,31.33 289.27,31.28 287.36,31.28 287.33,31.31 287.33,31.92 287.41,31.99 288.02,31.99 288.53,32.5 288.53,33.24 288.81,33.52 290.03,33.52
+1.35VS_VGA on TOP (solid shape): 188.01,108.87 180.01,108.87 180.01,116.87 188.01,116.87
+1.35VS_VGA on TOP (solid shape): 195.48,99.72 187.48,99.72 187.48,107.72 195.48,107.72
+1.35VS_VGA on TOP (solid shape): outline of 21219 points within 150.82,74.92 211.64,133.47
+1.35VS_VGA on BOTTOM (solid shape): outline of 523 points within 160.17,81.6 176.62,98.03
+1.35VS_VGA on IN3 (solid shape): outline of 695 points within 175.17,81.83 183.02,95.11
+1.35VS_VGAP on TOP (solid shape): 150.66,119.65 150.66,116.75 150.63,116.73 150.63,111.12 150.5,110.99 147.58,110.99 147.2,111.37 147.2,119.29 147.63,119.73 150.58,119.73
+1.35VS_VGAP on BOTTOM (solid shape): 152.8,118.72 152.8,111.51 152.41,111.12 147.71,111.12 147.33,111.5 147.33,120.64 147.46,120.77 150.76,120.77
+1.35VS_VGAP_B+ on TOP (solid shape): 142.17,122.55 142.17,117.95 140.28,116.06 139.91,116.06 139.91,116.54 139.36,116.54 139.36,116.83 139.91,116.83 139.91,117.34 139.36,117.34 139.36,117.63 139.91,117.63 139.91,119.62 140.02,119.73 140.02,121.68 140.11,121.77 140.11,122.61 140.3,122.8 141.92,122.8
+1.35VS_VGAP_B+ on BOTTOM (solid shape): 141.59,121.35 141.59,120.38 141.69,120.27 145.08,120.27 145.4,119.95 145.4,118.13 144.41,117.13 143.68,117.13 143.49,117.33 143.24,117.33 143.05,117.13 141.31,117.13 140.9,116.73 140.36,116.73 139.92,117.17 139.92,117.72 139.91,117.72 139.91,121.53 140.22,121.83 141.1,121.83
+1V_MPHY on TOP (solid shape): 146.99,33.91 146.99,29.45 146.92,29.39 145.64,29.39 145.43,29.61 145.43,34.1 145.6,34.28 146.62,34.28
+1V_MPHY on TOP (solid shape): 168.16,37.07 168.16,36.06 168.54,35.68 168.54,35.3 168.41,35.17 166.89,35.17 166.81,35.1 166.8,35.09 166.62,34.99 166.52,34.81 166.51,34.8 166.13,34.41 165.11,34.41 164.98,34.53 164.98,34.92 165.11,35.04 165.62,35.04 165.74,35.17 165.74,35.8 165.62,35.93 165.62,37.07 165.95,37.4 167.83,37.4
+1V_MPHY on IN1 (solid shape): outline of 1228 points within 150.5,33.01 168.67,38.73
+1V_MPHY on IN2 (solid shape): outline of 1709 points within 145.3,32.25 169.17,41.14
+1V_MPHY_MPHYPLL on TOP (solid shape): 155.97,45.96 155.97,44.57 156.03,44.5 156.03,44.22 156.46,43.79 156.49,43.76 156.5,43.73 156.49,43.69 156.71,43.07 157,43.66 156.97,43.73 157,43.79 157.11,44.06 157,44.33 156.93,44.39 157.11,44.57 157.11,45.76 157.34,45.99 159.2,45.99 159.2,45.32 159.2,45.28 159.05,45.13 159.05,44.23 158.48,43.65 158.37,43.65 157.12,42.41 156.79,42.41 156.79,42.41 156.65,42.44 156.51,42.41 156.5,42.41 155.46,42.41 155.2,42.66 155.2,43.3 154.82,43.68 154.82,44.84 154.85,44.85 155.04,45.03 155.07,45.28 155.07,45.34 155.1,45.38 155.1,45.99 155.94,45.99
+1V_MPHY_MPHYPLL on BOTTOM (solid shape): 158.41,44.17 158.41,43.85 158.27,43.59 158.45,43.36 158.45,43.12 158.29,42.95 158.14,42.95 158.05,43.04 158.05,43.17 157.84,43.37 157.84,43.77 157.13,44.48 156.47,44.48 156.22,44.22 156.22,43.35 156.58,42.99 157.29,42.99 157.44,42.84 157.67,42.84 157.84,42.68 157.84,42.5 157.7,42.37 157.43,42.37 157.24,42.52 157,42.45 155.83,42.45 155.46,42.82 155.46,44.69 155.97,45.19 157.39,45.19
+1V_PCH on TOP (solid shape): outline of 119 points within 168.47,34.43 171.66,37.62
+1V_PCH on IN1 (solid shape): outline of 582 points within 168.41,28.41 174.51,37.33
+1V_PCH_AZPLL on TOP (solid shape): outline of 144 points within 170.01,27.57 174.25,28.82
+1V_PCH_CLK5 on BOTTOM: 180.83,39 184.18,39 184.45,38.73 185.35,38.73 185.37,38.72 185.37,38.13 185.29,38.05 181.48,38.05 181.24,37.81 180.34,37.81 180.06,38.09 180.06,38.14 179.96,38.36 179.73,38.46 179.66,38.49 179.63,38.55 179.46,38.82 179.15,38.83 179.12,38.81 179.08,38.85 177.94,38.85 177.81,38.98 177.81,39.23 178.01,39.44 178.05,39.41 178.14,39.37 178.23,39.36 178.59,39.36 178.81,39.28 179.03,39.36 180.48,39.36
+1V_PCH_PRIM on TOP (solid shape): outline of 1469 points within 163.89,28.62 178.7,38.22
+1V_PCH_USBPLL on BOTTOM (solid shape): 176.98,29.9 176.98,28.63 176.75,28.39 176.75,28.04 176.65,27.95 176.2,27.95 176.06,28.1 176.06,28.33 176.37,28.64 176.37,29.13 176.63,29.4 176.63,29.88 176.74,29.98 176.9,29.98
+1V_VCCDSW on TOP (solid shape): outline of 193 points within 164.22,23.87 167.88,28.26
+1VALW on TOP (solid shape): 132.76,100.07 132.76,99.65 132.98,99.43 134.5,99.43 134.55,99.38 134.55,97.91 133.4,96.76 132.98,96.76 132.67,96.46 129.98,96.46 129.88,96.56 129.88,98.1 129.97,98.2 130.99,98.2 131.27,98.48 131.27,100.07 131.45,100.26 132.58,100.26
+1VALW on TOP (solid shape): 148.85,36.03 148.85,30.59 148.78,30.37 148.85,30.15 148.85,29.61 148.64,29.39 147.24,29.39 147.24,29.78 147.62,29.78 147.62,30.17 147.24,30.17 147.24,34.02 147.11,34.14 147.11,34.32 146.52,34.92 146.52,35.63 147.08,36.18 148.7,36.18
+1VALW on TOP (solid shape): 160.92,45.79 160.92,44.95 160.8,44.83 160.78,44.83 160.51,44.72 160.41,44.44 160.41,44.44 160.41,44.01 160.39,43.92 160.39,43.83 160.21,43.65 159.6,43.65 159.31,43.94 159.31,45.03 159.48,45.2 159.74,45.2 159.88,45.33 159.88,45.96 159.91,45.99 160.72,45.99
+1VALW on TOP (solid shape): outline of 1039 points within 168.41,36.31 186.2,44.54
+1VALW on BOTTOM (solid shape): 133.48,101.16 134.8,101.16 134.87,101.09 134.87,98.65 133.68,97.47 132.48,97.47 132.22,97.73 132.22,99.56 132.45,99.79 132.87,99.79 133.15,100.07 133.15,101.13 133.19,101.16 133.47,101.16
+1VALW on BOTTOM (solid shape): 234.53,15.23 234.53,14.15 234.01,14.15 234.01,13.4 234.53,13.4 234.53,12.95 234.01,12.95 234.01,12.2 234.53,12.2 234.53,11.78 234.45,11.7 231.81,11.7 231.28,12.23 231.28,15.48 231.4,15.61 234.15,15.61
+1VALW on VCC (solid shape): outline of 1585 points within 131.58,39.92 146.29,99.81
+1VALW on IN2 (solid shape): outline of 2281 points within 139.96,34.6 180.72,45.2
+1VALW on VCC: outline of 443 points within 170.19,13.48 235.34,46.09
+1VALWP on TOP (solid shape): 239.91,14.98 239.91,12.28 239.56,11.93 235.98,11.93 235.47,12.44 235.47,14.95 235.62,15.1 239.79,15.1
+1VALWP on BOTTOM (solid shape): 241.01,15.99 241.01,12.36 240.34,11.7 234.66,11.7 234.66,12.3 234.11,12.3 234.11,12.85 234.66,12.85 234.66,13.5 234.11,13.5 234.11,14.05 234.66,14.05 234.66,14.78 234.66,14.78 234.66,15.2 234.93,15.48 238.08,15.48 238.24,15.64 238.24,16.22 238.31,16.3 240.7,16.3
+2.5V_MEM on TOP (solid shape): 142.95,28.18 142.95,26.53 142.44,26.03 139.87,26.03 139.87,26.03 139.15,26.03 139.15,26.03 138.82,26.03 138.59,26.26 138.59,27.22 138.41,27.4 138.41,27.96 138.52,28.06 141.55,28.06 141.81,28.31 142.82,28.31
+2.5V_MEM on TOP (solid shape): 139.07,41.77 139.07,39.87 139.2,39.74 139.78,39.74 139.88,39.65 139.92,39.57 139.96,39.51 139.96,38.98 141.17,37.77 141.17,37.2 141.11,37.14 140.41,37.14 139.2,38.34 138.06,38.34 137.68,38.73 137.68,41.9 137.8,42.03 138.82,42.03
+2.5V_MEM on BOTTOM (solid shape): 139.07,41.9 139.07,41.9 139.07,40.25 138.89,40.06 136.61,40.06 136.49,40.18 136.49,41.81 136.7,42.02 138.95,42.02
+2.5V_MEM on BOTTOM (solid shape): 143.77,27.61 143.77,26.72 143.71,26.66 142.95,26.66 142.63,26.34 141.91,26.34 141.72,26.53 141.72,27.47 141.92,27.68 143.71,27.68
+2.5V_MEM on BOTTOM (solid shape): 138.82,29.06 138.92,29.07 139.71,29.07 139.96,28.82 139.96,26.66 139.71,26.41 137.53,26.41 137.25,26.68 137.25,26.78 136.56,27.46 136.56,28.17 136.56,28.24 136.53,28.32 136.53,28.95 136.66,29.07 138.72,29.07
+3.3V_GFX_AON on TOP (solid shape): outline of 162 points within 153.55,79.52 162.19,86.73
+3.3V_GFX_RUN on TOP (solid shape): outline of 198 points within 170.55,74.7 173.75,81.91
+3.3VDX_SSD on BOTTOM (solid shape): outline of 412 points within 214.23,15.76 220.46,38.85
+3V_DVDD on TOP (solid shape): 276.49,22.72 277.5,22.72 277.72,22.5 277.73,22.49 277.78,22.41 277.87,22.36 277.89,22.34 277.89,21.07 277.76,20.95 276.62,20.95 276.11,20.44 276.11,18.15 275.98,18.02 274.89,18.02 274.76,18.15 274.76,18.84 274.96,19.04 274.96,23.1 275.09,23.23 275.98,23.23
+3V_DVDD on IN2 (solid shape): outline of 180 points within 275.28,20.95 278.14,29.63
+3V_PCH_DSW on IN3 (solid shape): 172.23,14.86 172.23,14.59 172.16,14.52 171.69,14.52 171.33,14.88 169.8,14.88 169.63,14.71 169.34,14.71 169.25,14.8 169.25,15.2 169.52,15.46 171.63,15.46
+3V_PCH_SPI on BOTTOM (solid shape): 153.17,22.47 155.71,22.47 156.73,21.45 157.62,21.45 157.88,21.71 157.88,22.08 157.96,22.16 159.13,22.16 159.2,22.09 159.2,21.9 159.19,21.89 159.19,21.72 159.16,21.7 158.98,21.5 159.01,21.22 159.01,20.82 158.63,20.44 155.88,20.44 155.17,21.15 152.46,21.15 152.03,21.58 152.03,22.67 152.08,22.72 152.92,22.72
+3VALW on TOP (solid shape): 178.95,21.83 178.95,21.45 178.86,21.36 177.37,21.36 177.17,21.55 177.17,21.83 177.3,21.96 178.83,21.96
+3VALW on TOP (solid shape): 202.83,23.71 202.83,20.11 202.7,19.98 201.43,19.98 201.23,20.18 201.23,23.94 201.41,24.12 202.42,24.12
+3VALW on TOP (solid shape): 235.11,37.58 235.11,35.8 234.93,35.63 232.6,35.63 232.18,36.05 232.18,37.63 232.52,37.98 234.72,37.98
+3VALW on TOP (solid shape): 154.01,14.9 157.41,14.9 157.64,14.67 157.64,13.48 157.11,12.94 153.74,12.94 153.24,13.45 153.24,14.91 153.49,15.17 153.74,15.17
+3VALW on TOP (solid shape): 216.82,27.22 216.82,26.74 217.08,26.48 217.08,26.16 216.99,26.08 216.57,26.08 216.27,25.77 216.27,23.84 216.19,23.76 215.5,23.76 215.45,23.82 215.45,27.03 215.85,27.42 216.62,27.42
+3VALW on TOP (solid shape): 68.59,66.26 69.76,66.26 69.91,66.11 69.91,63.69 69.81,63.59 69.33,63.59 69.25,63.67 69.25,64.42 68.33,65.34 68.33,65.94 68.31,66.05 68.27,66.15 68.26,66.16 68.26,66.31 68.34,66.39 68.46,66.39
+3VALW on TOP (solid shape): 215.76,15.2 217.74,15.2 217.74,15.2 219.49,15.2 219.58,15.12 219.58,13.41 219.19,13.02 217.28,13.02 217.04,13.26 216.99,13.26 216.67,13.58 216.62,13.58 216.52,13.68 215.96,13.68 215.94,13.66 215.2,13.66 215.15,13.71 215.15,14.6 215.16,14.61 215.16,14.94 215.43,15.2
+3VALW on TOP (solid shape): 152.22,28.65 152.22,26.98 151.52,26.28 151.01,26.28 150.76,26.53 150.76,27.56 151.43,28.22 151.53,28.46 151.45,28.71 151.44,28.82 151.53,28.88 151.99,28.88
+3VALW on TOP (solid shape): 65.41,39.11 65.61,39.05 65.81,39.11 66.15,39.11 66.91,38.34 67.63,38.34 67.78,38.19 67.78,36.71 67.66,36.59 66.96,36.59 66.05,37.51 65.9,37.51 65.62,37.64 65.33,37.52 65.31,37.51 64.5,36.69 64.17,36.69 63.74,37.12 63.74,38.04 64.81,39.11
+3VALW on TOP (solid shape): 278.04,35.65 277.99,35.6 277.33,35.6 276.95,35.22 276.95,34.93 276.95,34.39 277.48,34.48 278.01,34.48 278.06,34.43 278.06,33.92 278.19,33.8 278.19,33.52 278.14,33.47 275.85,33.47 275.3,34.03 275.3,35.22 276.29,36.21 278.04,36.21
+3VALW on BOTTOM (solid shape): 66.2,38.27 67.88,38.27 68.11,38.04 68.11,37.4 67.47,36.77 63.97,36.77 63.79,36.95 63.79,38.29 64.08,38.59 65.88,38.59
+3VALW on BOTTOM (solid shape): 184.4,20.8 184.4,20.09 184.02,19.71 182.72,19.71 182.64,19.79 182.64,20.33 182.67,20.36 183.47,20.36 184.06,20.95 184.25,20.95
+3VALW on BOTTOM (solid shape): 235.67,21.88 235.67,18.63 235.54,18.5 235.1,18.5 233.99,19.61 233.99,21.05 234,21.1 233.99,21.17 234.82,22 235.55,22
+3VALW on BOTTOM (solid shape): 153.48,36.44 153.67,36.24 153.67,34.55 154.2,34.03 154.2,32.46 154.09,32.36 153.18,32.36 152.89,32.65 152.89,33.51 152.59,33.81 152.59,36.26 152.77,36.44 153.48,36.44
+3VALW on BOTTOM (solid shape): 251.95,11.8 251.95,11.29 252.1,11.14 252.44,11.14 252.46,11.12 252.51,11.12 252.54,11.14 253.2,11.14 253.35,10.99 253.35,10.56 253.15,10.35 251.75,10.35 251.41,10.7 251.41,11.88 251.88,11.88
+3VALW on BOTTOM (solid shape): 249.69,14.44 249.69,14.28 249.68,14.27 249.64,14.17 249.62,14.06 249.62,13.38 249.06,12.82 249.06,12.26 248.55,12.26 248.55,13.07 249.31,13.83 249.31,14.34 249.49,14.52 249.62,14.52
+3VALW on BOTTOM (solid shape): 278.84,52.06 278.84,50.35 277.31,48.82 277.31,46.84 276.29,45.81 275.78,45.81 275.54,46.05 275.54,49.46 278.27,52.19 278.71,52.19
+3VALW on BOTTOM (solid shape): 70.55,19.29 70.55,18.96 71.38,18.13 79.49,18.13 81.29,16.32 81.29,14.6 81.16,14.47 76.97,14.47 76.72,14.72 76.72,15.46 76.11,16.07 69.33,16.07 69.05,16.35 69.05,19.14 69.35,19.45 70.39,19.45
+3VALW on BOTTOM (solid shape): 222.39,42.47 222.39,42.25 222.36,42.17 222.35,42.1 222.35,41.49 222.13,41.27 221.85,41.27 221.03,40.44 220.42,40.44 220.37,40.49 220.37,41.1 221.29,42.03 221.62,42.03 222.14,42.55 222.31,42.55
+3VALW on BOTTOM (solid shape): 157.33,23.94 157.33,23.5 157.57,23.26 158.41,23.26 158.92,22.75 158.92,22.56 158.87,22.51 158.6,22.51 158.35,22.77 157.33,22.77 157.25,22.68 156.05,22.68 156.02,22.72 155.13,22.72 154.87,22.98 154.87,23.46 155.1,23.69 156.67,23.69 156.99,24.01 157.26,24.01
+3VALW on BOTTOM (solid shape): 178.01,22.57 178.01,22.32 178.19,22.15 178.19,21.72 178.29,21.62 178.29,21.31 178.16,21.18 177.31,21.18 177.17,21.31 177.17,21.7 177.31,21.84 177.31,22.04 177.42,22.16 177.48,22.2 177.52,22.26 177.6,22.34 177.6,22.56 177.7,22.66 177.92,22.66
+3VALW on BOTTOM (solid shape): 159.67,29.48 159.65,29.31 159.72,29.15 159.72,28.94 159.63,28.86 159.63,28.84 159.63,28.83 159.6,28.77 159.59,28.71 159.57,28.64 159.51,28.61 159.28,28.46 159.24,28.19 159.24,28.16 159.11,28.02 159.11,27.97 158.67,27.97 158.5,28.14 158.5,28.2 158.5,28.42 158.64,28.56 158.65,28.57 158.75,28.62 158.8,28.71 158.8,28.73 158.93,28.85 158.93,29.9 159.01,29.99 159.17,29.99
+3VALW on BOTTOM (solid shape): outline of 123 points within 149.19,20.28 154.29,29.17
+3VALW on IN1 (solid shape): outline of 469 points within 61.99,17.7 70.83,38.93
+3VALW on IN1 (solid shape): outline of 569 points within 215.96,10.66 253.27,15.22
+3VALW on IN2 (solid shape): outline of 726 points within 169.68,23.49 177.05,28.95
+3VALW on IN2 (solid shape): outline of 1273 points within 248.8,10.66 277.15,35.68
+3VALW on IN3 (solid shape): outline of 334 points within 271.03,33.87 279.33,45.74
+3VALW on IN3 (solid shape): outline of 3158 points within 76.08,6.59 158.12,16.74
+3VALW on VCC: outline of 218 points within 215.78,19.42 278.52,53.34
+3VALW on VCC: outline of 327 points within 150.76,12.31 220.35,46.09
+3VALW_EC on TOP (solid shape): 237.89,17.78 237.89,17.4 237.88,17.39 236.98,17.39 236.73,17.64 235.06,17.64 234.99,17.72 234.99,17.78 235.05,17.84 236,17.84 237.05,17.84 237.11,17.9 237.77,17.9
+3VALWP on BOTTOM (solid shape): 76.97,13.76 81.11,13.76 81.29,13.58 81.29,11.93 82.48,10.73 82.48,9.82 82.18,9.52 72.4,9.52 72.02,9.9 72.02,14.34 72.4,14.72 76.01,14.72
+3VLP on BOTTOM (solid shape): 152.54,16.06 153.04,16.06 153.04,16.56 153.11,16.63 153.3,16.63 153.3,15.87 153.24,15.8 151.84,15.8 151.65,15.99 151.65,16.56 151.71,16.63 152.54,16.63
+3VS on TOP (solid shape): 270.98,46.73 270.98,45.23 270.8,45.05 269.94,45.05 269.73,45.25 269.73,46.73 269.86,46.85 270.85,46.85
+3VS on TOP (solid shape): 274.38,18.68 274.38,17.95 273.85,17.41 273.34,17.41 273.19,17.57 273.19,18.51 273.39,18.71 274.36,18.71
+3VS on TOP (solid shape): 58.46,30.8 58.46,28.39 59.71,27.13 60.25,27.13 60.33,27.04 60.33,26.56 60.22,26.44 59.38,26.44 57.65,28.18 57.65,28.58 57.22,29.01 57.22,30.84 57.39,31 58.25,31
+3VS on TOP (solid shape): 219.85,39.26 219.76,39.17 219.76,38.08 219.76,38.08 219.76,37.37 219.58,37.19 218.87,37.19 218.31,36.63 216.94,36.63 216.91,36.67 215.3,36.67 214.92,37.05 214.92,38.29 215.27,38.65 217.58,38.65 217.68,38.75 219.05,40.12 219.85,40.12
+3VS on TOP (solid shape): 290.28,39.44 290.28,39.2 290.43,39.05 290.43,35.73 290.05,35.35 289.65,35.35 289.54,35.45 289.54,38.73 289.44,38.83 289.16,38.83 289.02,38.97 289.08,39.24 288.93,39.48 288.93,40.02 289.06,40.15 289.57,40.15
+3VS on TOP (solid shape): 10.34,40.5 10.95,40.5 11.08,40.37 11.08,39.01 12.97,37.12 14.13,37.12 14.35,36.91 14.35,36.27 14.26,36.19 11.81,36.19 11.34,36.66 9.9,36.66 9.73,36.66 9.71,36.64 9.46,36.64 9.43,36.67 9.43,37.31 9.53,37.41 9.8,37.41 9.81,37.42 11.16,37.42 11.25,37.51 11.25,37.64 9.89,39 9.89,40.31 10.15,40.57 10.27,40.57
+3VS on TOP (solid shape): 163.38,18.56 163.22,18.4 161.19,18.4 160.73,17.94 160.73,17.03 161.1,16.67 161.1,16.32 161.05,16.27 160.92,16.27 160.79,16.4 160.28,16.4 160.16,16.27 155.03,16.27 154.06,17.24 154.06,17.67 154.57,17.67 154.95,17.29 158.63,17.29 158.93,17.59 158.93,18.35 158.94,18.38 159.27,18.71 160.3,18.71 160.56,18.96 160.56,18.96 160.76,19.16 163.38,19.16
+3VS on TOP (solid shape): outline of 146 points within 238.26,29.12 243.95,36.57
+3VS on TOP (solid shape): outline of 596 points within 202.93,14.4 216.93,32.38
+3VS on BOTTOM (solid shape): 169.5,17.87 169.5,17.08 169.66,16.93 169.66,16.88 169.55,16.88 169.43,16.75 168.67,16.75 168.41,16.5 168.21,16.5 168.12,16.59 168.11,16.92 167.75,17.29 167.75,17.87 167.78,17.9 169.48,17.9
+3VS on BOTTOM (solid shape): 247.69,32.15 247.69,32.12 247.91,31.89 247.91,25.77 247.96,25.72 247.96,22.16 247.02,21.22 246.52,21.22 246.09,21.66 246.09,23.43 246.67,24.02 246.67,25.87 246.7,25.88 246.95,26.22 246.7,26.56 246.67,26.57 246.67,27.93 246.67,27.94 246.67,29.1 246.46,29.31 246.46,32.25 246.44,32.38 246.37,32.5 246.36,32.52 246.36,32.6 246.44,32.68 247.15,32.68
+3VS on IN1 (solid shape): 249.31,22.7 249.44,22.67 249.57,22.7 252.61,22.7 252.61,21.68 252.21,21.28 246.43,21.28 246.16,21.55 246.16,22.41 246.44,22.7
+3VS on IN1 (solid shape): outline of 91 points within 257.97,12.46 274.81,18.53
+3VS on IN2 (solid shape): 10.99,40.46 10.99,39.78 11.38,39.39 11.38,38.55 11.17,38.34 10.79,38.34 9.76,39.37 9.76,40.49 9.91,40.64 10.81,40.64
+3VS on IN2 (solid shape): outline of 588 points within 272.54,17.39 291.5,40.15
+3VS on IN2 (solid shape): outline of 1704 points within 44.59,30.24 69.8,49.52
+3VS on IN3 (solid shape): 273.82,46.09 273.69,45.96 269.95,45.96 269.75,46.17 269.75,46.84 270.14,47.23 272.68,47.23
+3VS on IN3 (solid shape): 289.57,40.07 289.57,39.23 289.51,39.17 289.24,39.17 288.56,39.86 286.08,39.86 286.01,39.92 286.01,40.86 288.78,40.86
+3VS on IN3 (solid shape): outline of 81 points within 238.13,29.33 248.17,33.9
+3VS on IN3 (solid shape): outline of 3334 points within 67.07,28.57 190.5,49.7
+3VS on BOTTOM: 219.55,39.36 219.87,39.04 219.87,37.26 219.77,37.16 217.99,37.16 217.68,37.47 217.68,38.97 218.07,39.36
+3VS on VCC: outline of 135 points within 188.99,29.07 220.74,46.35
+3VS_CAM on BOTTOM (solid shape): 231.15,48.38 231.15,45.08 230.39,44.31 230.39,42.92 230.13,42.66 229.88,42.66 229.5,43.04 229.5,44.44 229.6,44.75 229.4,45.01 229.37,45.03 229.37,47.06 229.87,47.56 229.87,48.71 229.91,48.75 230.78,48.75
+3VS_DTH on TOP (solid shape): 269.85,44.78 269.85,44.41 269.92,44.34 270.82,44.34 271.46,43.7 271.46,41.82 271.21,41.57 270.62,41.57 270.55,41.65 270.55,42.89 270.34,43.09 270.11,43.09 269.94,43.27 269.94,43.6 268.92,44.62 268.23,44.62 267.95,44.9 267.95,45.28 268.11,45.43 269.2,45.43
+3VS_DTH on BOTTOM (solid shape): 271.18,30.83 271.18,27.42 270.44,26.69 268.97,26.69 268.72,26.94 268.72,27.93 270.29,27.93 270.29,27.88 270.31,27.82 270.33,27.78 270.35,27.73 270.39,27.69 270.42,27.65 270.47,27.62 270.52,27.6 270.57,27.58 270.62,27.57 270.67,27.57 270.73,27.58 270.78,27.6 270.83,27.62 270.87,27.65 270.91,27.69 270.94,27.73 270.97,27.78 270.99,27.82 271,27.88 271,27.93 271,27.98 270.99,28.04 270.97,28.08 270.94,28.13 270.91,28.17 270.87,28.21 270.83,28.24 270.78,28.26 270.73,28.28 270.67,28.29 270.62,28.29 270.57,28.28 270.52,28.26 270.47,28.24 270.42,28.21 270.39,28.17 270.35,28.13 270.33,28.08 270.31,28.04 270.29,27.98 270.29,27.93 268.72,27.93 268.72,28.18 269.48,28.95 269.53,28.95 269.53,29 269.63,29.1 269.63,30.98 269.76,31.11 270.9,31.11
+3VS_DTH on IN3 (solid shape): outline of 843 points within 261.1,26.62 273.24,43.93
+3VS_TP on TOP (solid shape): 134.45,15.82 134.45,15.22 134.46,15.22 134.46,15 134.48,15 134.57,14.91 134.57,14.4 134.62,14.35 135.45,14.35 135.55,14.25 135.55,13.79 135.48,13.72 134.64,13.72 134.51,13.85 134.51,14.04 134.31,14.23 133.87,14.23 133.74,14.36 133.74,14.37 133.53,14.57 131.72,14.57 131.56,14.73 131.56,15.82 131.7,15.96 134.31,15.96
+3VS_WLAN on TOP (solid shape): 185.89,29.43 185.89,28.64 185.38,28.13 184.8,28.13 184.72,28.06 184.41,28.06 184.29,28.18 184.29,28.59 183.98,28.9 183.98,29.5 185.81,29.5
+3VS_WLAN on TOP (solid shape): outline of 97 points within 196.81,24.44 203.36,34.05
+3VS_WLAN on IN2 (solid shape): outline of 843 points within 184.29,27.93 199.34,34.42
+5V_AVDD on TOP (solid shape): outline of 126 points within 283.93,17.47 291.27,23.56
+5V_CHGUSB_1 on TOP (solid shape): 291.74,31.57 291.74,30.03 291.97,29.8 293.35,29.8 293.58,30.03 293.58,30.25 293.67,30.34 294.52,30.34 297.08,27.79 297.08,26.55 296.35,25.82 293.15,25.82 292.97,25.64 292.29,25.64 292.29,26.51 292.47,26.69 292.47,28.18 292.14,28.51 290.46,28.51 290.16,28.82 290.16,30.52 290.31,30.67 290.31,31.41 290.64,31.74 291.58,31.74
+5V_CHGUSB_1 on IN2 (solid shape): 297.04,27.52 297.04,26.89 295.87,25.72 293.71,25.72 292.69,26.74 292.69,28.1 292.31,28.48 290.68,28.48 290.29,28.87 290.29,31.14 291.82,31.14 291.83,31.08 291.84,31.03 291.86,30.98 291.89,30.93 291.92,30.89 291.96,30.86 292,30.83 292.05,30.8 292.1,30.79 292.15,30.78 292.21,30.78 292.26,30.79 292.31,30.8 292.36,30.83 292.4,30.86 292.44,30.89 292.48,30.93 292.5,30.98 292.52,31.03 292.53,31.08 292.54,31.14 292.53,31.19 292.52,31.24 292.5,31.29 292.48,31.34 292.44,31.38 292.4,31.41 292.36,31.44 292.31,31.47 292.26,31.48 292.21,31.49 292.15,31.49 292.1,31.48 292.05,31.47 292,31.44 291.96,31.41 291.92,31.38 291.89,31.34 291.86,31.29 291.84,31.24 291.83,31.19 291.82,31.14 290.29,31.14 290.29,31.43 290.66,31.8 292.76,31.8
+5V_CHGUSB_1 on IN3 (solid shape): 297.01,27.5 297.01,27.02 296.94,26.94 296.94,26.1 296.61,25.77 294.12,25.77 293.42,26.47 293.42,28.1 292.9,28.62 292.9,29.77 293.47,30.34 294.17,30.34
+5V_CHGUSB_1 on BOTTOM: 290.64,31.74 292.87,31.74 294.09,30.52 294.09,30.04 294.03,29.97 294.03,29.26 294.21,29.09 294.21,28.6 294.28,28.6 294.98,27.9 296.64,27.9 297.06,27.49 297.06,26.53 296.22,25.69 291.68,25.69 290.28,27.09 290.28,31.38
+5V_CHGUSB_1 on IN1: 297.01,27.52 297.01,26.86 295.84,25.69 290.98,25.69 290.22,26.46 290.22,31.52 290.48,31.79 292.74,31.79
+5V_CHGUSB_2 on TOP (solid shape): 286.01,38.12 286.01,37.25 285.15,36.39 283.91,36.39 283.78,36.52 283.78,38.17 284.01,38.39 285.73,38.39
+5V_CHGUSB_2 on TOP (solid shape): 296.3,48.2 296.3,47.23 296.31,47.22 296.31,45.11 295.74,44.53 295.74,43.5 295.73,43.49 295.73,41.07 294.29,39.64 291.6,39.64 291.02,40.22 291.02,41.29 292.59,42.87 292.59,48.22 293,48.63 295.87,48.63
+5V_CHGUSB_2 on BOTTOM (solid shape): 296.94,48.28 297.04,48.02 297.04,47.79 296.89,47.49 296.63,47.23 296.63,45.42 295.74,44.53 295.74,41.09 294.29,39.64 291.53,39.64 291.02,40.15 291.02,41.29 291.65,41.93 292.29,41.93 292.59,42.23 292.59,47.31 292.85,47.56 292.85,48.48 293,48.63 296.58,48.63
+5V_CHGUSB_2 on IN1 (solid shape): 296.38,48.81 296.38,46.68 296.17,46.47 294.47,46.47 293.61,47.34 293.61,48.45 294.19,49.04 296.15,49.04
+5V_CHGUSB_2 on IN1 (solid shape): outline of 86 points within 283.55,36.03 292.26,41.85
+5V_CHGUSB_2 on IN3 (solid shape): 296.3,48.2 296.3,45.09 295.74,44.53 295.74,43.5 295.73,43.49 295.73,41.07 294.29,39.64 293.66,39.64 293.1,39.08 293.1,38.48 293.09,38.47 293.09,38.17 293.09,38.16 293.09,37.84 293.09,37.84 293.09,37.53 293.09,37.52 293.09,37.22 291.91,36.03 286.67,36.03 286.18,36.53 286.11,36.61 286.03,36.68 285.96,36.74 283.73,36.74 283.63,36.85 283.63,37.72 284.53,38.62 285.82,38.62 285.82,38.57 286.52,37.87 289.19,37.87 289.85,38.53 290.34,38.53 290.92,39.11 290.92,39.11 291.02,39.36 290.92,39.61 290.92,41.6 292.59,43.27 292.59,47.31 292.61,47.32 292.61,48.24 293,48.63 295.87,48.63
+5V_PVDD on TOP (solid shape): 278.77,31.28 278.77,30.67 278.75,30.65 278.75,30.01 278.62,29.89 277.5,29.89 277.3,30.09 277.3,31.03 277.58,31.31 278.75,31.31
+5V_PVDD on TOP (solid shape): 292.31,25.26 292.62,25.26 292.74,25.14 292.74,23.97 292.24,23.46 291.79,23.46 290.94,24.31 290.94,24.91 291.3,25.26 291.68,25.26 291.78,25.36 292.21,25.36
+5V_PVDD on BOTTOM (solid shape): 277.11,33.1 278.6,31.61 279.16,31.05 279.16,30.22 278.65,29.71 277.81,29.71 276.97,30.55 275.45,30.55 275.24,30.75 275.24,33.9 276.31,33.9
+5V_PVDD on IN3 (solid shape): outline of 318 points within 277.2,23.87 293.13,33.65
+5VALW on TOP (solid shape): 36.46,31.99 38.49,31.99 38.49,32.25 38.74,32.5 39.38,32.5 39.51,32.38 39.51,29.07 39,28.57 36.84,28.57 35.82,29.58 35.82,32.38 35.95,32.5 36.46,32.5
+5VALW on TOP (solid shape): 219.67,12.61 219.67,11.88 219.21,11.42 219.21,10.48 219.01,10.28 215.3,10.28 215.15,10.43 215.15,12.13 215.25,12.23 215.94,12.23 216.06,12.23 216.14,12.31 216.93,12.31 217.43,12.82 219.47,12.82
+5VALW on TOP (solid shape): 11.05,24.21 11.05,23.97 11.43,23.59 12.07,23.59 12.28,23.38 12.28,22.42 12.71,21.99 12.71,19.34 11.9,18.53 11.88,18.53 11.68,18.33 9.69,18.33 8.98,19.04 8.98,24.73 9.16,24.91 10.34,24.91
+5VALW on TOP (solid shape): 292.54,35.4 292.54,33.72 292.39,33.56 292.29,33.31 292.39,33.06 292.39,32.22 292.14,31.97 290.76,31.97 290.33,32.4 290.33,35.32 290.74,35.73 292.21,35.73
+5VALW on TOP (solid shape): 281.59,37.96 281.59,36.44 281.52,36.36 280.73,36.36 280.63,36.46 279.86,36.46 279.59,36.59 279.31,36.46 278.77,36.46 278.67,36.57 278.67,38.09 278.98,38.39 281.16,38.39
+5VALW on TOP (solid shape): 256.28,30.98 256.43,30.89 256.61,30.89 256.64,30.89 256.8,30.72 256.8,29.96 256.75,29.91 256.02,29.91 254.21,28.11 254.02,28.11 253.87,27.96 253.86,27.96 253.7,27.87 253.61,27.71 253.61,27.7 253.55,27.64 253.55,27.15 253.55,27.14 253.53,27.02 253.55,26.89 253.55,26.88 253.55,25.83 253.63,25.75 253.63,25.67 255.18,24.13 255.18,24.09 255.97,23.31 256.19,23.31 256.54,22.96 256.54,22.7 255.88,22.04 255.05,22.04 253.43,23.66 252.23,23.66 252.04,23.86 252.04,28.4 252.84,29.2 252.85,29.2 254.63,30.98
+5VALW on BOTTOM (solid shape): 11.82,20.67 11.82,18.66 11.57,18.41 9.66,18.41 9.53,18.53 9.53,20.56 9.92,20.95 11.54,20.95
+5VALW on BOTTOM (solid shape): 140.34,115.59 140.34,114.14 140.29,114.09 140.07,114.09 139.99,114.16 139.99,114.93 139.74,115.18 138.62,115.18 138.49,115.05 138.49,114.32 138.34,114.16 136.81,114.16 136.76,114.21 136.76,115.26 137.45,115.94 139.99,115.94
+5VALW on BOTTOM (solid shape): 145.3,19.74 145.3,17.83 145.23,17.77 145.23,17.33 144.92,17.01 144.03,17.01 143.96,17.07 143.14,17.07 142.52,16.45 138.31,16.45 138.08,16.68 138.08,18.13 138.21,18.25 139.13,18.25 139.58,17.8 141.31,17.8 141.46,17.95 141.46,18.63 142.76,19.93 145.11,19.93
+5VALW on IN2 (solid shape): outline of 1602 points within 191.42,10.15 244.46,19.04
+5VALW on VCC: outline of 699 points within 1.02,5.27 295.79,67.55
+5VALWP on TOP (solid shape): 39.13,35.3 39.13,32.88 39,32.76 35.09,32.76 34.76,33.09 34.76,33.17 34.76,33.18 34.81,33.4 34.76,33.61 34.76,34.55 35.76,35.55 38.87,35.55
+5VALWP on BOTTOM (solid shape): 43.57,36.95 43.57,34.53 43.19,34.15 39.89,34.15 38.87,33.14 38.24,33.14 37.09,31.99 37.09,31.61 36.99,31.36 37.09,31.11 37.09,30.97 36.99,30.72 37.09,30.47 37.09,30.34 36.99,30.09 37.09,29.84 37.09,29.7 36.99,29.45 37.09,29.2 37.09,29.07 36.99,28.82 37.09,28.57 37.09,26.91 36.97,26.79 34.93,26.79 34.68,27.04 34.68,33.05 34.81,33.39 34.68,33.73 34.68,34.08 34.68,34.1 34.68,35.55 34.71,35.55 35.08,35.92 35.12,35.96 35.15,36.02 35.32,36.19 37.47,36.19 38.49,37.2 43.32,37.2
+5VS on TOP (solid shape): 243.85,37.23 243.85,36.68 243.45,36.29 243.45,35.09 243.85,34.69 243.85,34.13 243.8,34.08 243.29,34.08 242.61,34.76 242.61,36.41 242.25,36.77 242.25,37.12 242.61,37.48 243.6,37.48
+5VS on TOP (solid shape): 57.01,31.23 57.01,29.77 56.61,29.38 55.59,29.38 55.46,29.5 55.46,29.84 54.95,30.34 54.77,30.34 54.72,30.39 54.72,30.9 54.8,30.98 55.67,30.98 56.23,31.54 56.7,31.54
+5VS on TOP (solid shape): 209.59,13.07 210.42,13.07 210.65,12.84 210.65,12.05 210.56,11.96 210.15,11.96 209.93,11.74 209.93,10.12 209.88,10.07 207.88,10.07 207.63,10.33 207.63,10.4 207.76,11.53 207.63,12.65 207.63,12.88 208.03,13.28 209.38,13.28
+5VS on BOTTOM (solid shape): 296.68,63.72 296.68,62.91 296.53,62.75 295.03,62.75 294.62,63.16 294.62,63.72 294.98,64.07 296.33,64.07
+5VS on BOTTOM (solid shape): 274.41,33.87 274.41,30.39 273.11,29.1 272.88,29.1 272.42,29.56 272.42,33.22 272.46,33.23 272.62,33.38 272.66,33.6 272.66,33.63 272.82,33.78 272.84,33.78 273.02,33.79 273.18,33.88 274.4,33.88
+5VS on BOTTOM (solid shape): 270.9,22.03 271.08,21.88 271.31,21.87 271.32,21.88 271.56,21.88 271.62,21.8 271.7,21.75 271.79,21.66 271.79,20.03 271.58,19.82 269.81,19.82 269.67,19.96 269.67,20.68 269.81,20.82 269.97,20.82 270.19,21.04 270.19,21.07 270.2,21.08 270.24,21.18 270.26,21.29 270.26,21.38 269.94,21.71 269.94,21.91 270.09,22.06 270.87,22.06
