# Allegro board Dell Inspiron 15 Gaming 7566 Compal LA-D991P BCV00 Rev1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_RAS#: length 50.4
  IN3 w0.178: v2(109.61,75.33) 110.53,76.25 110.86,76.25 111.08,76.03 111.08,75.5 109.53,73.95 109.53,71.77 110.12,71.18 110.12,68.86 110.99,67.98 110.99,56.81 111.82,55.98 111.82,48.34 110.16,46.67 110.16,38.03 110.34,37.85 v2(110.78,37.85)
  BOTTOM w0.076: UH1.AH4 108.78,75.33 v2(109.61,75.33)
  BOTTOM w0.17: v2(110.78,37.85) 111.53,37.09 111.53,35.92 110.99,35.38 110.57,35.38 110.4,35.21 JDIMM1.152
DDR_A_WE#: length 54.2
  IN3 w0.178: v2(110.76,39.37) 110.76,46.59 112.31,48.14 112.31,56.18 111.48,57.01 111.48,68.18 110.6,69.06 110.6,71.71 111.44,72.55 111.44,73.8 112.83,75.19 112.83,75.89 113.69,76.76 113.69,77.19 113.48,77.4 113.05,77.4 111.64,76 111.64,75.32 110.56,74.24 110.56,72.96 110.16,72.55 v2(110.07,72.55)
  BOTTOM w0.076: UH1.AG4 109.47,75.99 110.17,75.99 110.41,75.76 110.41,72.9 v2(110.07,72.55)
  BOTTOM w0.17: JDIMM1.151 110.15,39.55 110.34,39.37 v2(110.76,39.37)
DDR_B_ACT#: length 65.4
  IN1 w0.076: v2(102.23,79.27) 102.77,78.73 102.77,77.53 102.49,77.25 102.49,75.74 101.38,74.62 101.38,63.19 101.65,62.91 101.65,62.69
  IN1 w0.193: 101.65,62.69 101.65,61.11 95.6,55.06 95.6,39.21 95.23,38.84 95.23,29.31 97.58,26.96 97.58,26.5 98.75,25.33 98.75,23.32 v2(99.46,22.61)
  BOTTOM w0.089: UH1.AT9 102.1,79.27 v2(102.23,79.27)
  BOTTOM w0.17: v2(99.46,22.61) 98.91,22.06 JDIMM2.114
DDR_B_ALERT#: length 64.6
  IN1 w0.076: 102.15,62.83 101.64,63.34 101.64,74.62 102.7,75.67 102.7,77.03 103.15,77.48 v2(103.15,78.62)
  IN1 w0.193: v2(99.41,21.25) 99.98,21.82 99.98,22.9 99.25,23.62 99.25,25.53 98.08,26.7 98.08,27.17 96.17,29.08 96.17,36.09 96.37,36.3 96.37,39.37 96.1,39.64 96.1,54.86 102.15,60.9 102.15,62.83
  BOTTOM w0.076: UH1.AR8 102.82,78.3 v2(103.15,78.62)
  BOTTOM w0.17: JDIMM2.116 v2(99.41,21.25)
DDR_B_BG0: length 65.9
  IN1 w0.076: 100.66,63.44 100.66,76.32 101.98,77.64 102.38,77.64 102.6,77.86 102.6,78.28 v2(102.25,78.63)
  IN1 w0.193: v2(98.08,23.99) 96.58,25.49 96.58,26.35 95.7,27.24 94.87,27.24 94.2,27.91 94.2,44.16 94.08,44.27 94.08,55.13 100.66,61.71 100.66,63.44
  BOTTOM w0.076: v2(102.25,78.63) 102.57,78.95 UH1.AR9
  BOTTOM w0.17: v2(98.08,23.99) 98.79,24.71 98.79,26.03 99.16,26.4 JDIMM2.115
DDR_B_BG1: length 65.9
  IN1 w0.076: 101.16,62.81 101.16,63.07 101.05,63.18 101.05,74.74 101.71,75.41 101.71,76.86 v2(102.11,77.26)
  IN1 w0.193: v2(98.07,25.3) 97.49,25.3 97.08,25.71 97.08,26.56 95.72,27.92 95.45,27.92 95.31,27.78 95.03,27.78 94.76,28.05 94.76,28.32 94.9,28.47 94.9,28.74 94.7,28.94 94.7,39.15 94.89,39.35 94.91,39.35 95.1,39.54 95.1,39.93 94.91,40.12 94.89,40.12 94.7,40.31 94.7,40.7 94.89,40.89 94.91,40.89 95.1,41.08 95.1,41.47 94.91,41.66 94.89,41.66 94.7,41.86 94.7,42.24 94.89,42.43 94.91,42.43 95.1,42.63 95.1,43.01 94.91,43.21 94.89,43.21 94.7,43.4 94.7,44.54 94.58,44.65 94.58,45.17 94.77,45.36 94.88,45.36 95.08,45.55 95.08,45.94 94.88,46.13 94.77,46.13 94.58,46.32 94.58,46.7 94.77,46.89 94.89,46.89 95.08,47.08 95.08,47.47 94.89,47.66 94.77,47.66 94.58,47.86 94.58,48.24 94.77,48.44 94.89,48.44 95.08,48.63 95.08,48.92 94.89,49.12 94.86,49.12 94.58,49.4 94.58,49.79 94.77,49.98 94.89,49.98 95.08,50.17 95.08,50.56 94.89,50.75 94.77,50.75 94.58,50.95 94.58,51.33 94.77,51.52 94.91,51.52 95.11,51.72 95.11,52.1 94.91,52.3 94.77,52.3 94.58,52.49 94.58,52.88 94.77,53.07 94.91,53.07 95.1,53.26 95.1,53.65 94.91,53.84 94.77,53.84 94.58,54.03 94.58,54.84 101.16,61.41 101.16,62.81
  BOTTOM w0.076: UH1.AR7 102.5,77.65 v2(102.11,77.26)
  BOTTOM w0.17: v2(98.07,25.3) 98.07,26.11 98.66,26.7 JDIMM2.113
DDR_B_BS0: length 71
  IN1 w0.076: 110.22,66.46 109.3,67.38 109.3,73.83 108.82,74.3 108.82,77.62 109,77.79 109,78.26 v2(108.63,78.62)
  IN1 w0.193: 110.22,66.46 112.13,64.55 112.13,63.92 112.32,63.73 112.49,63.73 112.68,63.53 112.68,63.15 112.49,62.95 112.32,62.95 112.13,62.76 112.13,62.38 112.32,62.18 112.49,62.18 112.74,61.93 112.74,61.66 112.49,61.41 112.32,61.41 112.13,61.22 112.13,60.83 112.32,60.64 112.49,60.64 112.68,60.45 112.68,60.06 112.49,59.87 112.3,59.87 112.11,59.67 112.11,59.16 112.36,58.91 112.89,58.91 113.08,58.72 113.08,58.3 112.84,58.07 111.89,58.07 111.69,57.87 111.69,57.49 111.89,57.3 112.92,57.3 113.12,57.1 113.12,56.53 112.92,56.34 112.49,56.34 112.3,56.14 112.3,55.76 112.49,55.56 112.94,55.56 113.13,55.37 113.13,54.99 112.94,54.79 112.49,54.79 112.3,54.6 112.3,54.21 112.49,54.02 112.91,54.02 113.11,53.83 113.11,53.55 110.38,50.83 110.38,41.25 109.3,40.17 109.3,33.54 109.84,32.99 109.84,27.84 109.97,27.72 109.97,22.61 110.16,22.42 110.4,22.42 110.59,22.23 110.59,21.84 110.4,21.65 110.16,21.65 109.95,21.44 v2(109.91,21.44)
  BOTTOM w0.076: v2(108.63,78.62) 108.5,78.62 UH1.AH8
  BOTTOM w0.17: JDIMM2.150 v2(109.91,21.44)
DDR_B_BS1: length 70.1
  IN1 w0.076: 109.52,65.75 108.9,66.37 108.9,73.51 108.41,74 108.41,77.37 108.1,77.68 108.1,78.21 v2(107.72,78.59)
  IN1 w0.193: 109.52,65.75 110.69,64.58 110.69,52.55 108.91,50.77 108.91,50.47 109.36,50.01 109.36,49.56 109.17,49.37 108.87,49.37 108.44,49.8 108.17,49.8 107.74,49.37 107.74,48.98 107.93,48.79 108.35,48.79 108.54,48.6 108.54,47.61 108.74,47.41 109.13,47.41 109.32,47.22 109.32,46.83 109.13,46.64 108.74,46.64 108.54,46.45 108.54,46.06 108.84,45.77 108.84,45.2 108.54,44.9 108.54,44.52 108.74,44.33 109.13,44.33 109.32,44.13 109.32,43.75 109.12,43.55 107.93,43.55 107.74,43.36 107.74,42.97 107.93,42.78 108.11,42.78 108.31,42.59 108.31,42.08 108.5,41.89 108.85,41.89 109.07,41.67 109.07,41.39 108.79,41.11 108.5,41.11 108.31,40.92 108.31,40.73 108.11,40.54 107.93,40.54 107.74,40.35 107.74,39.96 107.93,39.77 108.11,39.77 108.31,39.57 108.31,38.82 107.72,38.23 107.72,33.23 107.92,33.04 108.11,33.04 108.31,32.84 108.31,31.51 108.1,31.3 107.77,31.3 107.57,31.11 107.57,30.72 107.77,30.53 108.1,30.53 108.31,30.32 108.31,29.03 108.11,28.84 108.04,28.84 107.85,28.65 107.85,28.01 108.25,27.6 108.68,27.6 108.95,27.33 108.95,26.43 108.65,26.13 108.65,25.76 v2(108.97,25.44)
  BOTTOM w0.076: UH1.AH9 108.08,78.95 v2(107.72,78.59)
  BOTTOM w0.17: JDIMM2.145 108.66,27.08 108.14,26.56 108.14,25.64 108.34,25.44 v2(108.97,25.44)
DDR_B_CAS#: length 72.8
  IN1 w0.076: 116.94,63.01 116.94,63.1 117.04,63.2 117.28,63.2 117.43,63.36 117.43,63.9 111.76,69.57 111.76,73.58 110.61,74.73 110.61,77.3 110.1,77.81 110.1,78.27 v2(110.46,78.63)
  IN1 w0.193: v2(113.95,23.61) 113.16,24.4 113.16,28.97 113.09,29.04 113.09,32.61 112.99,32.7 112.99,34.3 112.69,34.6 112.69,36.05 112.99,36.35 112.99,36.82 112.69,37.12 112.69,37.59 112.99,37.89 112.99,38.37 112.69,38.67 112.69,39.1 114.1,40.52 114.1,40.98 113.91,41.17 113.83,41.17 113.64,41.37 113.64,41.75 113.83,41.95 114.08,41.95 114.27,42.14 114.27,42.86 114.08,43.05 113.84,43.05 113.64,43.25 113.64,43.63 113.84,43.83 114.08,43.83 114.27,44.02 114.27,44.41 114.08,44.6 113.84,44.6 113.64,44.79 113.64,45.18 113.84,45.37 114.08,45.37 114.27,45.56 114.27,45.95 114.08,46.14 113.84,46.14 113.64,46.34 113.64,46.72 113.84,46.91 114.08,46.91 114.27,47.11 114.27,47.49 114.08,47.69 113.84,47.69 113.64,47.88 113.64,48.27 113.84,48.46 113.91,48.46 114.1,48.65 114.1,49.14 114.45,49.48 114.72,49.48 115.02,49.18 115.29,49.18 115.56,49.46 115.56,49.73 115.27,50.03 115.27,50.3 115.54,50.57 115.81,50.57 116.11,50.28 116.38,50.28 116.66,50.55 116.66,50.82 116.36,51.12 116.36,51.39 116.94,51.97 116.94,63.01
  BOTTOM w0.076: UH1.AF8 110.13,78.3 v2(110.46,78.63)
  BOTTOM w0.17: v2(113.95,23.61) 113.68,23.61 111.41,21.34 JDIMM2.156
DDR_B_D0: length 73.2
  IN1 w0.114: v2(72.86,23.08) 72.3,23.08 71.83,23.55 71.83,24.75 71.09,25.49 71.09,34.88 70.8,35.17 70.8,38.01 70.63,38.18 70.63,40.26 71.19,40.81 71.19,49.76 73.19,51.76 73.19,56 73.75,56.56 73.75,61.7 76.96,64.91 76.96,73.1 80.77,76.91 80.93,76.91 81.33,76.51 81.64,76.51 81.77,76.65 81.77,76.95 81.37,77.35 81.37,77.51 81.65,77.79 81.81,77.79 82.09,77.51 82.26,77.51 82.53,77.79 82.53,77.95 82.27,78.21 82.27,78.37 82.64,78.74 82.8,78.74 82.97,78.57 83.23,78.57 84.1,79.44 v2(84.85,79.44)
  BOTTOM w0.076: v2(84.85,79.44) 86,79.44 86.58,80.02 87.42,80.02 UH1.BT11
  BOTTOM w0.102: JDIMM2.8 72.41,22.63 v2(72.86,23.08)
DDR_B_D1: length 73.6
  IN1 w0.114: v2(83.98,78.6) 83.81,78.6 82.92,77.72 82.92,76.73 82.3,76.11 80.43,76.11 79.92,75.6 79.92,75.16 80.03,75.05 80.89,75.05 81.01,74.93 81.01,74.54 80.89,74.43 78.75,74.43 77.29,72.97 77.29,64.72 74.11,61.55 74.11,56.48 73.51,55.87 73.51,51.63 71.51,49.63 71.51,40.68 70.95,40.13 70.95,38.31 71.12,38.14 71.12,35.3 71.41,35.01 71.41,25.62 72.7,24.32 v2(72.83,24.32)
  BOTTOM w0.076: v2(83.98,78.6) 85.44,78.6 86.52,79.68 87.72,79.68 UH1.BR11
  BOTTOM w0.102: v2(72.83,24.32) 71.91,25.25 71.91,27.04 72.16,27.3 JDIMM2.7
DDR_B_D2: length 73.2
  IN1 w0.114: v2(84.8,76.89) 84.59,76.69 84.59,68.27 78.72,62.4 78.56,62.4 78.24,62.71 78.08,62.71 77.8,62.44 77.8,62.27 78.12,61.96 78.12,61.8 77.84,61.52 77.68,61.52 77.36,61.83 77.2,61.83 76.92,61.56 76.92,61.39 77.24,61.08 77.24,60.92 76.96,60.64 76.8,60.64 76.48,60.95 76.32,60.95 76.04,60.68 76.04,60.51 76.36,60.2 76.36,60.03 75.84,59.52 75.84,55.83 75.21,55.2 75.21,45.37 73.5,43.67 73.5,22.63 73.39,22.51 72.28,22.51 72.16,22.39 72.16,22.01 72.28,21.89 73.39,21.89 73.5,21.78 73.5,21.68 73.76,21.43 v2(75.41,21.43)
  BOTTOM w0.076: UH1.BR8 87.42,77.8 87.36,77.8 87.31,77.75 86.18,77.75 85.47,77.04 85.27,77.04
  BOTTOM w0.102: v2(75.41,21.43) JDIMM2.20 ; v2(84.8,76.89) 84.94,77.04 85.27,77.04
DDR_B_D3: length 73.5
  IN1 w0.114: v2(86.17,78.3) 86.23,78.25 86.23,77.16 85.22,76.15 85.22,68 76.47,59.25 76.47,54.44 76.36,54.33 75.96,54.33 75.84,54.21 75.84,53.82 75.96,53.7 76.36,53.7 76.47,53.59 76.47,53.2 76.36,53.08 75.96,53.08 75.84,52.97 75.84,52.57 75.96,52.46 76.36,52.46 76.47,52.34 76.47,51.95 76.36,51.84 75.96,51.84 75.84,51.72 75.84,51.33 75.96,51.21 76.36,51.21 76.47,51.1 76.47,50.71 76.36,50.59 75.96,50.59 75.84,50.48 75.84,50.08 75.96,49.97 76.36,49.97 76.47,49.86 76.47,49.46 76.36,49.35 75.96,49.35 75.84,49.23 75.84,48.84 75.96,48.73 76.36,48.73 76.47,48.61 76.47,48.22 76.36,48.1 75.96,48.1 75.84,47.99 75.84,47.59 75.96,47.48 76.36,47.48 76.47,47.37 76.47,46.97 76.36,46.86 75.96,46.86 75.84,46.74 75.84,46.35 75.96,46.24 76.36,46.24 76.47,46.12 76.47,45.74 74.14,43.41 74.14,24.71 74.25,24.59 74.64,24.59 74.93,24.88 v2(75.14,24.88)
  BOTTOM w0.076: v2(86.17,78.3) 86.33,78.15 87.08,78.15 87.3,78.37 87.3,78.5 87.72,78.92 88.58,78.92 UH1.BP8
  BOTTOM w0.102: v2(75.14,24.88) 75.66,25.4 JDIMM2.21
DDR_B_D4: length 73.3
  IN1 w0.114: v2(85.27,79.86) 83.25,79.86 76.63,73.24 76.63,65.03 73.43,61.83 73.43,56.69 72.87,56.13 72.87,51.9 70.87,49.91 70.87,40.94 68.48,38.55 68.48,36.04 70.77,33.75 70.77,25.34 70.95,25.17 v2(70.95,21.85)
  BOTTOM w0.076: v2(85.27,79.86) 85.38,79.75 85.91,79.75 86.39,80.23 87.11,80.23 87.36,80.48 88.59,80.48 UH1.BP11
  BOTTOM w0.102: JDIMM2.4 71.41,21.39 v2(70.95,21.85)
DDR_B_D5: length 73.2
  IN1 w0.114: v2(86.22,80.56) 86.08,80.7 85.54,80.7 85.36,80.88 85.36,81.37 85.25,81.48 84.85,81.48 84.74,81.37 84.74,80.33 84.62,80.21 84.23,80.21 84.12,80.33 84.12,80.59 84,80.7 83.49,80.7 76.3,73.5 76.3,65.15 73.11,61.96 73.11,56.82 72.55,56.26 72.55,52.04 70.55,50.04 70.55,41.09 68.16,38.69 68.16,35.91 69.84,34.23 69.84,26.4 v2(70.29,25.95)
  BOTTOM w0.076: v2(86.22,80.56) 87.08,80.56 87.19,80.67 89.05,80.67 UH1.BN11
  BOTTOM w0.102: JDIMM2.3 71.16,26.51 70.6,25.95 v2(70.29,25.95)
DDR_B_D6: length 73.2
  IN1 w0.114: v2(85.76,77.86) 85.76,77.14 84.91,76.28 84.91,68.14 76.15,59.38 76.15,55.7 75.53,55.07 75.53,45.24 73.82,43.54 73.82,21.92 73.94,21.81 74.48,21.81 74.57,21.89 74.57,21.91 74.68,22.03 75.47,22.03 75.67,21.83 75.83,21.83 76.25,22.25 76.25,22.41 76.01,22.65 74.68,22.65 74.57,22.76 74.57,23.54 74.74,23.71 v2(75.14,23.71)
  BOTTOM w0.076: UH1.BT8 87.56,78.38 87.12,77.94 85.84,77.94 v2(85.76,77.86)
  BOTTOM w0.102: JDIMM2.16 74.41,22.98 v2(75.14,23.71)
DDR_B_D7: length 73.2
  IN1 w0.114: v2(75.14,26.05) 74.91,25.82 74.61,25.82 74.46,25.97 74.46,27.39 74.57,27.51 75.12,27.51 75.24,27.62 75.24,28.01 75.12,28.13 74.57,28.13 74.46,28.24 74.46,28.64 74.57,28.75 75.12,28.75 75.24,28.87 75.24,29.26 75.12,29.37 74.57,29.37 74.46,29.49 74.46,30.1 74.59,30.23 75.12,30.23 75.24,30.34 75.24,30.74 75.12,30.85 74.57,30.85 74.46,30.97 74.46,31.75 74.57,31.87 74.7,31.87 74.82,31.98 74.82,32.37 74.7,32.49 74.57,32.49 74.46,32.6 74.46,33 74.57,33.11 74.7,33.11 74.82,33.22 74.82,33.62 74.7,33.73 74.57,33.73 74.46,33.85 74.46,36.94 74.57,37.06 74.72,37.06 74.83,37.17 74.83,37.56 74.72,37.68 74.57,37.68 74.46,37.79 74.46,39.61 74.57,39.72 74.7,39.72 74.81,39.84 74.81,40.23 74.7,40.35 74.57,40.35 74.46,40.46 74.46,40.65 74.74,40.93 74.74,41.09 74.47,41.35 74.47,41.51 74.75,41.79 74.91,41.79 75.16,41.54 75.33,41.54 75.58,41.79 75.58,41.96 75.45,42.08 75.45,42.66 75.57,42.77 76.03,42.77 76.15,42.89 76.15,43.3 76.03,43.41 75.23,43.41 75.11,43.53 75.11,43.92 75.23,44.03 76.01,44.03 76.15,44.17 76.15,44.97 76.79,45.61 76.79,59.12 85.54,67.87 85.54,75.08 87.49,77.03 87.49,78.13 v2(86.94,78.67)
  BOTTOM w0.076: UH1.BN8 89.13,79.01 88.78,79.01 88.68,79.11 87.39,79.11 86.95,78.67 v2(86.94,78.67)
  BOTTOM w0.102: JDIMM2.17 74.66,26.54 v2(75.14,26.05)
DDR_B_D8: length 68.2
  IN1 w0.076: v2(90.5,79.8) 90.12,79.8 89.43,79.12 89.43,78.72 89.71,78.45
  IN1 w0.114: v2(77.1,23.61) 76.11,24.6 76.11,31.97 75.68,32.4 75.68,39.76 75.79,39.87 75.91,39.87 76.02,39.99 76.02,40.28 75.91,40.39 75.8,40.39 75.68,40.51 75.68,40.68 77.02,42.02 77.02,44.65 77.63,45.26 77.63,58.7 86.38,67.45 86.38,74.68 89.71,78.02 89.71,78.45
  BOTTOM w0.089: UH1.BL11 90.83,80.14 v2(90.5,79.8)
  BOTTOM w0.102: JDIMM2.28 77.41,21.69 77.61,21.88 77.61,23.1 v2(77.1,23.61)
DDR_B_D9: length 68.2
  IN1 w0.076: v2(90.51,79) 90.09,78.58 90.09,77.94 88.43,76.29 88.43,76.09 88.4,76.06
  IN1 w0.114: v2(77.1,24.88) 76.84,24.88 76.43,25.3 76.43,27.96 76.53,28.06 76.53,32.15 76.42,32.26 76.28,32.26 76.16,32.38 76.16,32.77 76.28,32.88 76.42,32.88 76.53,33 76.53,33.39 76.42,33.51 76.13,33.51 76.01,33.62 76.01,34.01 76.13,34.13 76.42,34.13 76.53,34.24 76.53,34.64 76.42,34.75 76.13,34.75 76.01,34.87 76.01,35.26 76.13,35.37 76.42,35.37 76.53,35.49 76.53,37.06 76.65,37.18 76.73,37.18 76.84,37.29 76.84,37.69 76.73,37.8 76.65,37.8 76.53,37.92 76.53,38.31 76.65,38.42 76.73,38.42 76.84,38.54 76.84,38.93 76.73,39.05 76.65,39.05 76.53,39.16 76.53,39.55 76.65,39.67 76.73,39.67 76.84,39.78 76.84,40.18 76.73,40.29 76.49,40.29 76.38,40.4 76.38,40.86 76.49,40.97 77.19,40.97 77.33,41.12 77.33,44.52 77.94,45.13 77.94,58.57 86.7,67.32 86.7,69.87 87.25,70.42 87.25,74.91 88.4,76.06
  BOTTOM w0.089: UH1.BL8 90.51,78.94 v2(90.51,79)
  BOTTOM w0.102: JDIMM2.29 77.66,25.36 77.18,24.88 v2(77.1,24.88)
DDR_B_D10: length 67.9
  IN1 w0.076: 90.52,74 90.52,74.54 90.84,74.85 90.84,76.34 91.79,77.3 91.79,78.24 v2(92.17,78.62)
  IN1 w0.114: v2(80.67,24.74) 80.12,25.28 80.12,28.36 80.69,28.93 80.69,42.19 81.09,42.59 81.09,53.47 80.93,53.63 80.69,53.63 80.58,53.74 80.58,54.14 80.69,54.25 80.93,54.25 81.05,54.36 81.05,54.76 80.93,54.87 80.69,54.87 80.58,54.99 80.58,55.38 80.69,55.5 81.73,55.5 81.85,55.61 81.85,56 81.73,56.12 80.71,56.12 80.59,56.23 80.59,56.77 80.71,56.89 81.75,56.89 81.86,57 81.86,58.09 90.01,66.24 90.01,70.08 90.52,70.59 90.52,74
  BOTTOM w0.089: UH1.BJ8 91.85,78.3 v2(92.17,78.62)
  BOTTOM w0.102: v2(80.67,24.74) 81.29,25.36 81.29,26.83 81.08,27.04 80.86,27.04 80.66,27.24 JDIMM2.41
DDR_B_D11: length 68.1
  IN1 w0.076: v2(92.17,79.27) 91.63,78.72 91.63,77.41 90.67,76.45 90.67,75.28 89.64,74.24
  IN1 w0.114: v2(80.67,23.47) 80.54,23.47 79.8,24.2 79.8,31.48 80.06,31.74 80.06,42 80.24,42.18 80.24,44.17 80.77,44.71 80.77,49.26 80.58,49.46 80.48,49.46 80.36,49.57 80.36,49.97 80.48,50.08 80.58,50.08 80.69,50.19 80.69,50.59 80.58,50.7 80.35,50.7 80.24,50.82 80.24,51.21 80.35,51.32 80.58,51.32 80.69,51.44 80.69,51.83 80.58,51.95 80.35,51.95 80.24,52.06 80.24,52.45 80.35,52.57 80.58,52.57 80.69,52.68 80.69,53.08 80.58,53.19 80.35,53.19 80.24,53.31 80.24,57.28 89,66.05 89,68.92 89.64,69.56 89.64,74.24
  BOTTOM w0.089: UH1.BJ10 92.04,79.27 v2(92.17,79.27)
  BOTTOM w0.102: JDIMM2.42 80.91,21.86 81.33,22.28 81.33,22.8 v2(80.67,23.47)
DDR_B_D12: length 68.4
  IN1 w0.076: 89.1,78.77 89.23,78.91 89.23,79.15 90.51,80.43 v2(90.51,80.58)
  IN1 w0.114: v2(77.09,22.34) 77.05,22.34 75.79,23.6 75.79,31.84 75.36,32.27 75.36,40.82 76.7,42.16 76.7,44.78 77.31,45.39 77.31,58.83 86.06,67.58 86.06,74.86 88.01,76.81 88.01,77.68 89.1,78.77
  BOTTOM w0.076: UH1.BL12 90.83,80.9 v2(90.51,80.58)
  BOTTOM w0.102: JDIMM2.24 76.41,21.66 v2(77.09,22.34)
DDR_B_D13: length 68.1
  IN1 w0.076: v2(90.55,78.18) 90.55,78.08 88.78,76.32 88.78,75.94
  IN1 w0.114: 88.78,75.94 87.57,74.72 87.57,70.29 87.01,69.74 87.01,67.19 83.13,63.31 83.13,63 82.85,62.71 82.54,62.71 82.25,62.43 82.25,62.12 81.97,61.83 81.66,61.83 81.37,61.55 81.37,61.24 81.09,60.95 80.78,60.95 80.49,60.67 80.49,60.36 80.21,60.07 79.9,60.07 79.61,59.79 79.61,59.48 79.33,59.19 79.02,59.19 78.26,58.44 78.26,45 77.65,44.38 77.65,40.66 77.17,40.18 77.17,37 77.05,36.88 76.96,36.88 76.85,36.77 76.85,36.37 76.96,36.26 77.05,36.26 77.17,36.15 77.17,35.75 77.05,35.64 76.96,35.64 76.85,35.52 76.85,35.02 76.96,34.91 77.06,34.91 77.17,34.8 77.17,34.4 77.06,34.29 76.96,34.29 76.85,34.17 76.85,33.78 76.96,33.67 77.53,33.67 77.65,33.55 77.65,33.16 77.53,33.04 76.96,33.04 76.85,32.93 76.85,32.54 76.96,32.42 77.56,32.42 77.67,32.31 77.67,31.91 77.56,31.8 76.96,31.8 76.85,31.68 76.85,30.28 76.96,30.16 77.55,30.16 77.68,30.04 77.68,29.27 77.57,29.16 76.99,29.16 76.87,29.04 76.87,28.65 76.99,28.53 77.58,28.53 77.69,28.42 77.69,28.02 77.58,27.91 76.99,27.91 76.74,27.67 76.74,26.24 76.91,26.08 77.05,26.08 v2(77.12,26.15)
  BOTTOM w0.089: v2(90.55,78.18) 90.55,78 UH1.BL7
  BOTTOM w0.102: v2(77.12,26.15) 77.05,26.15 76.66,26.54 JDIMM2.25
DDR_B_D14: length 68.4
  IN1 w0.076: v2(92.17,79.92) 91.81,79.55 91.81,79.2 91.46,78.85 91.46,77.48 89.95,75.97 89.95,74.96 89.41,74.42
  IN1 w0.114: v2(80.67,22.2) 79.38,23.48 79.38,31.5 79.75,31.87 79.75,42.14 79.92,42.31 79.92,44.56 80.03,44.68 80.16,44.68 80.27,44.79 80.27,45.19 80.16,45.3 80.03,45.3 79.92,45.41 79.92,45.81 80.03,45.92 80.16,45.92 80.27,46.04 80.27,46.43 80.16,46.55 80.03,46.55 79.92,46.66 79.92,47.05 80.03,47.17 80.16,47.17 80.27,47.28 80.27,47.68 80.16,47.79 80.03,47.79 79.92,47.9 79.92,48.3 80.03,48.41 80.16,48.41 80.27,48.53 80.27,48.92 80.16,49.03 80.03,49.03 79.92,49.15 79.92,57.41 88.69,66.18 88.69,69.06 89.32,69.69 89.32,74.32 89.41,74.42
  BOTTOM w0.089: UH1.BJ11 92.04,79.92 v2(92.17,79.92)
  BOTTOM w0.102: JDIMM2.38 79.91,21.44 v2(80.67,22.2)
DDR_B_D15: length 67.9
  IN1 w0.076: v2(92.17,77.97) 92.17,77.37 91.63,76.82 91.63,75.24 90.84,74.46 90.84,73.72
  IN1 w0.114: v2(80.67,26.01) 81.25,26.01 81.36,26.12 81.36,27.45 81.25,27.57 81.12,27.57 81.01,27.68 81.01,28.08 81.12,28.19 81.25,28.19 81.36,28.3 81.36,28.7 81.25,28.81 81.12,28.81 81.01,28.93 81.01,29.32 81.12,29.44 81.25,29.44 81.36,29.55 81.36,29.94 81.25,30.06 81.12,30.06 81.01,30.17 81.01,30.57 81.12,30.68 81.25,30.68 81.36,30.79 81.36,31.19 81.25,31.3 81.12,31.3 81.01,31.42 81.01,31.81 81.12,31.92 81.25,31.92 81.36,32.04 81.36,32.43 81.25,32.55 81.12,32.55 81.01,32.66 81.01,33.05 81.12,33.17 81.25,33.17 81.36,33.28 81.36,33.68 81.25,33.79 81.12,33.79 81.01,33.91 81.01,39.85 81.22,40.06 81.22,40.23 81.03,40.42 81.03,40.81 81.14,40.93 81.29,40.93 81.41,41.04 81.41,41.43 81.29,41.55 81.14,41.55 81.03,41.66 81.03,42.06 81.14,42.17 81.29,42.17 81.41,42.29 81.41,51.33 81.52,51.44 82.07,51.44 82.18,51.55 82.18,51.95 82.07,52.06 81.52,52.06 81.41,52.18 81.41,52.57 81.52,52.68 82.07,52.68 82.18,52.8 82.18,53.19 82.07,53.31 81.52,53.31 81.41,53.42 81.41,53.81 81.52,53.93 82.07,53.93 82.18,54.04 82.18,54.44 82.07,54.55 81.52,54.55 81.41,54.67 81.41,55.06 81.52,55.17 82.07,55.17 82.18,55.29 82.18,57.95 90.33,66.1 90.33,69.95 90.84,70.46 90.84,73.71 90.84,73.72
  BOTTOM w0.089: UH1.BJ7 91.85,77.65 v2(92.17,77.97)
  BOTTOM w0.102: JDIMM2.37 79.66,26.72 80.37,26.01 v2(80.67,26.01)
DDR_B_D16: length 67.4
  IN1 w0.076: v2(94,80.56) 93.5,80.05 93.5,79.83 92.6,78.94 92.6,77.14 92.39,76.93 92.39,74.5 92.11,74.22
  IN1 w0.114: 92.11,74.22 91.36,73.47 91.36,70.24 90.85,69.73 90.85,65.89 82.72,57.75 82.72,50.97 82.53,50.78 82.23,50.78 81.93,50.49 81.93,49.63 82.04,49.51 82.25,49.51 82.36,49.4 82.36,49.01 82.25,48.89 82.04,48.89 81.93,48.78 81.93,24.76 v2(82.48,24.21)
  BOTTOM w0.089: v2(94,80.56) 93.86,80.56 UH1.BG11
  BOTTOM w0.102: JDIMM2.50 82.91,23.79 v2(82.48,24.21)
DDR_B_D17: length 67.4
  IN1 w0.076: v2(94,79.92) 93.64,79.56 93.64,78.52 93.45,78.32 93.45,77.67 92.57,76.8 92.57,74.2 92.29,73.91
  IN1 w0.114: v2(82.46,26.14) 82.46,26.19 82.89,26.61 82.89,26.98 83.04,27.14 83.04,27.69 82.92,27.81 82.39,27.81 82.28,27.92 82.28,28.31 82.39,28.43 82.92,28.43 83.04,28.54 83.04,28.85 82.72,29.18 82.36,29.18 82.25,29.29 82.25,29.71 82.36,29.83 82.6,29.83 82.71,29.94 82.71,30.34 82.6,30.45 82.36,30.45 82.25,30.57 82.25,30.96 82.36,31.07 82.6,31.07 82.71,31.19 82.71,31.58 82.6,31.7 82.36,31.7 82.25,31.81 82.25,32.2 82.36,32.32 82.6,32.32 82.71,32.43 82.71,32.83 82.6,32.94 82.36,32.94 82.25,33.05 82.25,35.26 82.36,35.38 82.53,35.38 82.65,35.49 82.65,35.89 82.53,36 82.36,36 82.25,36.11 82.25,48.44 83.04,49.23 83.04,49.69 82.92,49.8 82.39,49.8 82.27,49.91 82.27,50.31 82.39,50.42 82.92,50.42 83.04,50.54 83.04,57.62 91.17,65.75 91.17,69.6 91.68,70.11 91.68,73.31 92.29,73.91
  BOTTOM w0.089: UH1.BG10 93.87,79.92 v2(94,79.92)
  BOTTOM w0.102: JDIMM2.49 82.66,27.28 82.92,27.02 82.92,26.55 82.51,26.14 v2(82.46,26.14)
DDR_B_D18: length 67.3
  IN1 w0.076: v2(94.9,80.53) 94.9,80.57 95.46,80.01 95.46,78.52 95.69,78.29 95.69,77.52 94.89,76.72 94.89,69.61 94.46,69.18
  IN1 w0.114: 94.46,69.18 94.46,64.27 87.87,57.69 87.87,49.63 86.28,48.04 86.28,31.06 86.4,30.94 86.54,30.94 86.65,30.83 86.65,30.08 86.52,29.95 86.4,29.95 86.28,29.84 86.28,29.4 86.67,29.01 86.67,28.02 86.53,27.88 86.53,23.42 86.81,23.15 86.81,22.84 86.43,22.47 85.94,22.47 v2(85.79,22.62)
  BOTTOM w0.089: UH1.BF11 94.77,80.56 94.88,80.56 v2(94.9,80.53)
  BOTTOM w0.102: v2(85.79,22.62) 85.79,21.63 85.91,21.51 JDIMM2.62
DDR_B_D19: length 67.2
  IN1 w0.076: v2(94.9,78.63) 94.9,78.51 95.29,78.12 95.29,77.68 93.87,76.26 93.87,69.17 93.83,69.12
  IN1 w0.114: 93.83,69.12 93.83,64.54 87.24,57.95 87.24,56.45 87.13,56.33 86.3,56.33 86.14,56.18 86.14,55.74 86.27,55.62 87.11,55.62 87.22,55.5 87.22,55.11 87.11,55 86.26,55 86.15,54.88 86.15,54.49 86.26,54.37 87.11,54.37 87.22,54.26 87.22,53.87 87.11,53.75 86.26,53.75 86.15,53.64 86.15,53.24 86.26,53.13 87.11,53.13 87.22,53.01 87.22,52.62 87.11,52.51 86.26,52.51 86.15,52.39 86.15,52 86.26,51.88 87.11,51.88 87.22,51.77 87.22,51.38 87.11,51.26 86.26,51.26 86.15,51.15 86.15,50.44 86.73,49.85 86.73,49.42 85.65,48.34 85.65,26.75 85.79,26.6 v2(85.79,26.56)
  BOTTOM w0.089: v2(94.9,78.63) 94.8,78.63 UH1.BF8
  BOTTOM w0.102: JDIMM2.63 86.16,26.85 85.87,26.56 85.79,26.56 v2(85.79,26.56)
DDR_B_D20: length 67.7
  IN1 w0.076: v2(94,77.97) 94,77.68 92.91,76.59 92.91,72.34 92.51,71.94
  IN1 w0.114: v2(82.48,22.94) 83.1,23.55 83.1,25.05 83.23,25.18 83.23,26.06 83.67,26.5 83.67,29.12 83.41,29.38 83.41,33.67 83.3,33.79 83,33.79 82.88,33.9 82.88,34.61 83,34.72 83.28,34.72 83.39,34.83 83.39,36.51 83.28,36.62 83,36.62 82.88,36.74 82.88,39.3 83,39.41 83.29,39.41 83.41,39.53 83.41,39.92 83.29,40.04 83,40.04 82.88,40.15 82.88,40.55 83,40.66 83.29,40.66 83.41,40.77 83.41,41.17 83.29,41.28 83,41.28 82.88,41.4 82.88,41.79 83,41.9 83.29,41.9 83.41,42.02 83.41,42.41 83.29,42.53 83,42.53 82.88,42.64 82.88,43.03 83,43.15 83.29,43.15 83.41,43.26 83.41,48.71 83.67,48.97 83.67,57.36 91.81,65.49 91.81,69.34 92.31,69.85 92.31,71.74 92.51,71.94
  BOTTOM w0.089: v2(94,77.97) 93.87,77.97 UH1.BG7
  BOTTOM w0.102: v2(82.48,22.94) 81.91,22.36 JDIMM2.46
DDR_B_D21: length 67.2
  IN1 w0.076: 92.42,72.29 92.74,72.61 92.74,76.67 93.62,77.55 93.62,78.11 94,78.49 v2(94,78.62)
  IN1 w0.114: v2(82.47,24.87) 82.92,25.31 82.92,26.19 83.2,26.48 83.2,26.85 83.36,27 83.36,28.98 83.06,29.28 83.06,33.29 82.9,33.45 82.68,33.45 82.56,33.56 82.56,34.96 82.68,35.08 82.95,35.08 83.07,35.19 83.07,36.17 82.95,36.28 82.68,36.28 82.56,36.4 82.56,43.42 82.68,43.54 82.96,43.54 83.07,43.65 83.07,44.05 82.96,44.16 82.68,44.16 82.56,44.27 82.56,44.67 82.68,44.78 82.96,44.78 83.07,44.9 83.07,45.29 82.96,45.4 82.68,45.4 82.56,45.52 82.56,45.9 82.68,46.01 82.95,46.01 83.06,46.13 83.06,46.52 82.95,46.64 82.68,46.64 82.56,46.75 82.56,47.14 82.68,47.26 82.95,47.26 83.06,47.37 83.06,47.77 82.95,47.88 82.68,47.88 82.56,48 82.56,48.31 83.36,49.1 83.36,57.49 91.49,65.62 91.49,69.47 92,69.98 92,71.87 92.42,72.29
  BOTTOM w0.089: UH1.BG8 93.87,78.62 v2(94,78.62)
  BOTTOM w0.102: v2(82.47,24.87) 81.8,25.53 81.8,27.08 81.66,27.23 JDIMM2.45
DDR_B_D22: length 67.7
  IN1 w0.076: v2(94.92,79.92) 95.27,79.57 95.27,78.42 95.49,78.21 95.49,77.55 94.06,76.12 94.06,69.51 94.14,69.42 94.14,69.24
  IN1 w0.114: 94.14,69.24 94.14,64.41 87.56,57.82 87.56,50.98 87.44,50.86 86.82,50.86 86.71,50.75 86.71,50.36 86.82,50.24 87.44,50.24 87.56,50.13 87.56,49.8 85.97,48.2 85.97,30.84 86.08,30.72 86.08,30.72 86.2,30.61 86.2,30.21 86.08,30.1 86.08,30.1 85.97,29.99 85.97,28.97 86.08,28.86 86.22,28.86 86.34,28.74 86.34,28.35 86.22,28.24 86.08,28.24 85.97,28.12 85.97,27.51 86.22,27.26 86.22,24.13 86.03,23.94 v2(85.79,23.94)
  BOTTOM w0.089: v2(94.92,79.92) 94.79,79.92 UH1.BF10
  BOTTOM w0.102: v2(85.79,23.94) 85.3,23.46 85.3,22.15 84.91,21.75 JDIMM2.58
DDR_B_D23: length 67.6
  IN1 w0.076: 93.51,69.15 93.51,71.24 93.7,71.43 93.7,76.38 94.92,77.61 v2(94.92,77.97)
  IN1 w0.114: v2(85.79,25.29) 85.57,25.29 85.33,25.53 85.33,33.03 85.12,33.24 85.12,33.65 85.33,33.86 85.33,34.3 85.17,34.46 85.17,34.93 85.33,35.09 85.33,35.55 85.17,35.71 85.17,36.17 85.33,36.33 85.33,36.79 85.17,36.95 85.17,37.42 85.33,37.58 85.33,38.04 85.17,38.2 85.17,38.66 85.33,38.82 85.33,39.93 85.22,40.04 85.19,40.04 85.08,40.15 85.08,40.55 85.19,40.66 85.22,40.66 85.33,40.78 85.33,41.17 85.22,41.28 85.19,41.28 85.08,41.4 85.08,41.79 85.19,41.91 85.22,41.91 85.33,42.02 85.33,42.42 85.22,42.53 85.19,42.53 85.08,42.64 85.08,43.04 85.19,43.15 85.22,43.15 85.33,43.27 85.33,43.66 85.22,43.77 85.19,43.77 85.08,43.89 85.08,44.28 85.19,44.4 85.22,44.4 85.33,44.51 85.33,44.9 85.22,45.02 85.19,45.02 85.08,45.13 85.08,45.53 85.19,45.64 85.22,45.64 85.33,45.76 85.33,46.15 85.22,46.26 85.19,46.26 85.08,46.38 85.08,46.77 85.19,46.89 85.22,46.89 85.33,47 85.33,47.39 85.22,47.51 85.19,47.51 85.08,47.62 85.08,48.02 85.19,48.13 85.22,48.13 85.33,48.24 85.33,48.85 85.44,48.97 85.7,48.97 86.01,49.28 86.01,49.46 85.88,49.59 85.44,49.59 85.33,49.7 85.33,50.1 85.44,50.21 85.7,50.21 85.81,50.32 85.81,50.72 85.7,50.83 85.44,50.83 85.33,50.95 85.33,51.34 85.44,51.45 85.7,51.45 85.81,51.57 85.81,51.96 85.7,52.08 85.44,52.08 85.33,52.19 85.33,52.58 85.44,52.7 85.7,52.7 85.81,52.81 85.81,53.21 85.7,53.32 85.44,53.32 85.33,53.44 85.33,53.83 85.44,53.94 85.7,53.94 85.81,54.06 85.81,54.45 85.7,54.57 85.44,54.57 85.33,54.68 85.33,55.07 85.48,55.22 85.71,55.22 85.83,55.33 85.83,55.83 85.71,55.94 85.46,55.94 85.34,56.05 85.34,56.45 85.46,56.56 85.71,56.56 85.83,56.68 85.83,56.99 93.51,64.67 93.51,69.15
  BOTTOM w0.089: UH1.BF7 94.79,77.97 v2(94.92,77.97)
  BOTTOM w0.102: JDIMM2.59 85.16,25.92 v2(85.79,25.29)
DDR_B_D24: length 65.9
  IN1 w0.076: v2(96.75,80.56) 96.2,80.01 96.2,78.44 95.93,78.17 95.93,76.64 95.28,76 95.28,69.57 94.98,69.27 94.98,69.08
  IN1 w0.114: v2(87.82,22.87) 87.05,23.64 87.05,27.67 87.19,27.8 87.19,31.96 86.8,32.35 86.8,47.83 88.4,49.42 88.4,57.47 94.98,64.06 94.98,69.08
  BOTTOM w0.089: UH1.BC11 96.6,80.56 v2(96.75,80.56)
  BOTTOM w0.102: v2(87.82,22.87) 87.82,21.9 87.91,21.81 JDIMM2.70
DDR_B_D25: length 65.8
  IN1 w0.076: 95.62,68.93 95.62,69.33 95.67,69.38 95.67,75.78 96.38,76.5 96.38,78.12 96.75,78.48 v2(96.75,78.62)
  IN1 w0.114: 95.62,68.93 95.62,63.8 89.03,57.21 89.03,49.16 87.44,47.56 87.44,46.5 87.55,46.38 88.08,46.38 88.2,46.27 88.2,45.93 88.08,45.81 87.55,45.81 87.44,45.7 87.44,45.35 87.55,45.24 88.25,45.24 88.36,45.13 88.36,44.78 88.25,44.67 87.55,44.67 87.44,44.55 87.44,44.21 87.55,44.1 88.25,44.1 88.36,43.98 88.36,43.64 88.25,43.53 87.55,43.53 87.44,43.41 87.44,43.07 87.55,42.95 88.25,42.95 88.36,42.84 88.36,42.5 88.25,42.38 87.55,42.38 87.44,42.27 87.44,41.93 87.55,41.81 88.25,41.81 88.36,41.7 88.36,41.35 88.25,41.24 87.55,41.24 87.44,41.13 87.44,32.61 87.83,32.22 v2(87.83,26.67)
  BOTTOM w0.089: UH1.BC8 96.61,78.62 v2(96.75,78.62)
  BOTTOM w0.102: JDIMM2.71 88.16,27 v2(87.83,26.67)
DDR_B_D26: length 65.8
  IN1 w0.076: 98.54,74.82 98.54,75.03 98.58,75.07 98.58,78.07 98.21,78.45 98.21,80.03 v2(97.66,80.57)
  IN1 w0.114: v2(92.19,25.97) 91.72,25.97 91.61,26.09 91.61,27.18 91.72,27.29 91.84,27.29 91.96,27.4 91.96,27.8 91.84,27.91 91.72,27.91 91.61,28.03 91.61,28.42 91.72,28.53 91.84,28.53 91.96,28.65 91.96,29.04 91.84,29.16 91.72,29.16 91.61,29.27 91.61,29.8 91.32,30.09 91.32,30.69 91.43,30.8 91.83,30.8 91.94,30.92 91.94,31.31 91.83,31.43 91.43,31.43 91.32,31.54 91.32,31.93 91.43,32.05 91.83,32.05 91.94,32.16 91.94,32.56 91.83,32.67 91.43,32.67 91.32,32.78 91.32,33.18 91.43,33.29 91.83,33.29 91.94,33.41 91.94,33.8 91.83,33.91 91.43,33.91 91.32,34.03 91.32,38.59 91.96,39.23 91.96,56 98.54,62.58 98.54,74.82 98.54,74.82
  BOTTOM w0.089: v2(97.66,80.57) 97.53,80.57 UH1.BB11
  BOTTOM w0.102: v2(92.19,25.97) 91.84,25.97 91.16,26.65 JDIMM2.83
DDR_B_D27: length 65.3
  IN1 w0.076: 97.59,75.26 97.59,75.39 98,75.81 98,77.63 v2(97.66,77.97)
  IN1 w0.114: 97.59,75.26 97.59,62.98 91,56.39 91,44.44 90.84,44.27 90.62,44.27 90.51,44.16 90.51,43.76 90.62,43.65 90.89,43.65 91,43.53 91,41.92 90.89,41.8 90.6,41.8 90.49,41.69 90.49,41.29 90.6,41.18 90.89,41.18 91,41.07 91,40.65 89.72,39.37 89.72,33.44 90.15,33.01 90.15,25.61 91.29,24.47 91.29,23.89 91.7,23.47 91.7,22.65 v2(92.19,22.16)
  BOTTOM w0.089: v2(97.66,77.97) 97.53,77.97 UH1.BB7
  BOTTOM w0.102: JDIMM2.84 91.41,22 91.57,22.16 v2(92.19,22.16)
DDR_B_D28: length 65.3
  IN1 w0.076: 95.3,69.05 95.3,69.29 95.48,69.48 95.48,75.88 96.21,76.6 96.21,78.19 96.38,78.37 96.38,79.55 v2(96.75,79.92)
  IN1 w0.114: 95.3,69.05 95.3,63.93 88.71,57.34 88.71,49.29 87.12,47.7 87.12,32.48 87.51,32.09 87.51,27.63 87.37,27.49 87.37,24.59 v2(87.82,24.14)
  BOTTOM w0.089: UH1.BC10 96.61,79.92 v2(96.75,79.92)
  BOTTOM w0.102: v2(87.82,24.14) 86.91,23.22 JDIMM2.66
DDR_B_D29: length 65.4
  IN1 w0.076: 95.93,66.91 95.91,66.94 95.91,69.1 95.87,69.13 95.87,75.67 96.61,76.4 96.61,77.83 v2(96.75,77.97)
  IN1 w0.114: 95.93,66.91 95.93,63.66 89.35,57.08 89.35,49.02 88.55,48.23 88.55,48.01 88.74,47.83 88.9,47.83 89.04,47.98 89.21,47.98 89.34,47.84 89.34,46.93 89.2,46.79 88.97,46.79 88.2,47.56 87.89,47.56 87.76,47.43 87.76,46.85 87.91,46.7 88.22,46.7 88.68,46.25 88.68,40.72 88.56,40.6 88,40.6 87.76,40.36 87.76,34 88,33.76 88,33.42 87.76,33.18 87.76,32.74 88.14,32.36 88.14,28.94 88.35,28.74 88.35,25.37 88.22,25.24 87.95,25.24 v2(87.82,25.37)
  BOTTOM w0.089: v2(96.75,77.97) 96.61,77.97 UH1.BC7
  BOTTOM w0.102: v2(87.82,25.37) 87.16,26.03 JDIMM2.67
DDR_B_D30: length 65.7
  IN1 w0.076: 98.22,74.89 98.22,75.18 98.37,75.32 98.37,78.03 98.03,78.37 98.03,79.55 v2(97.66,79.92)
  IN1 w0.114: v2(92.19,24.7) 91.28,25.61 91.28,26.55 91.17,26.67 90.9,26.67 90.78,26.78 90.78,27.18 90.9,27.29 91.17,27.29 91.28,27.4 91.28,27.8 91.17,27.91 90.9,27.91 90.78,28.03 90.78,28.42 90.9,28.54 91.17,28.54 91.28,28.65 91.28,29.04 91.17,29.16 90.9,29.16 90.78,29.27 90.78,29.87 91,30.09 91,38.72 91.64,39.36 91.64,56.13 98.23,62.71 98.23,74.89 98.22,74.89
  BOTTOM w0.089: UH1.BB10 97.53,79.92 v2(97.66,79.92)
  BOTTOM w0.102: v2(92.19,24.7) 90.16,26.73 JDIMM2.79
DDR_B_D31: length 65.3
  IN1 w0.076: v2(97.66,78.62) 97.66,78.49 98.2,77.95 98.2,75.57 97.91,75.28 97.91,75.08
  IN1 w0.114: v2(92.19,23.43) 91.6,24.02 91.6,24.63 90.47,25.77 90.47,33.14 90.04,33.57 90.04,33.76 90.15,33.88 90.49,33.88 90.61,33.99 90.61,34.39 90.49,34.5 90.15,34.5 90.04,34.61 90.04,39.24 91.32,40.52 91.32,56.26 97.91,62.85 97.91,75.08 97.91,75.08
  BOTTOM w0.089: v2(97.66,78.62) 97.53,78.62 UH1.BB8
  BOTTOM w0.102: JDIMM2.80 90.41,21.66 v2(92.19,23.43)
DDR_B_D32: length 65.9
  IN1 w0.076: v2(113.21,80.57) 112.67,80.03 112.67,78.84 112.46,78.64 112.46,77.67 112.84,77.29 112.84,70.47
  IN1 w0.114: v2(115.98,24) 116.09,24.12 116.09,28.37 116.13,28.41 116.13,33.64 116.64,34.15 116.64,39.14 116.88,39.39 116.88,46.09 119.55,48.75 119.55,63.75 112.84,70.47
  BOTTOM w0.089: v2(113.21,80.57) 113.07,80.57 UH1.AC11
  BOTTOM w0.102: JDIMM2.174 115.91,21.52 115.98,21.59 v2(115.98,24)
DDR_B_D33: length 65.4
  IN1 w0.076: v2(113.21,77.97) 113.21,77.75 113.49,77.47 113.49,71.17
  IN1 w0.114: 113.49,71.17 120.5,64.15 120.5,48.36 117.84,45.69 117.84,38.99 117.59,38.74 117.59,38.61 117.7,38.49 117.85,38.49 117.97,38.38 117.97,37.99 117.85,37.87 117.7,37.87 117.59,37.76 117.59,37.36 117.7,37.25 117.88,37.25 117.99,37.14 117.99,36.74 117.88,36.63 117.7,36.63 117.59,36.51 117.59,36.12 117.7,36 117.89,36 118.03,35.87 118.03,35.5 117.92,35.38 117.7,35.38 117.59,35.27 117.59,34.87 117.7,34.76 117.88,34.76 117.99,34.65 117.99,34.25 117.88,34.14 117.7,34.14 117.59,34.02 117.59,33.75 117.08,33.25 117.08,31.58 117.27,31.4 117.27,30.96 117.08,30.77 117.08,30.34 117.27,30.15 117.27,29.71 117.08,29.53 117.08,29.14 117.2,29.03 117.27,29.03 117.39,28.91 117.39,28.52 117.27,28.4 117.2,28.4 117.08,28.29 117.08,25.21 117.33,24.96 v2(117.61,24.96)
  BOTTOM w0.089: v2(113.21,77.97) 113.07,77.97 UH1.AC7
  BOTTOM w0.102: JDIMM2.173 115.66,26.73 117.43,24.96 v2(117.61,24.96)
DDR_B_D34: length 65.4
  IN1 w0.076: 120.81,67.62 120.54,67.89 120.11,67.89 115.4,72.6 115.4,76.8 114.99,77.21 114.99,78.21 114.67,78.53 114.67,79.69 114.58,79.77 114.58,80.11 v2(114.12,80.57)
  IN1 w0.114: v2(120.33,25.97) 120.41,25.97 120.74,26.31 120.74,27.83 120.66,27.92 120.66,33.17 121.52,34.03 121.52,35.43 121.41,35.54 121.14,35.54 121.03,35.66 121.03,36.05 121.14,36.17 121.41,36.17 121.52,36.28 121.52,36.67 121.41,36.79 121.14,36.79 121.03,36.9 121.03,37.3 121.14,37.41 121.35,37.41 121.46,37.53 121.46,39.47 120.45,40.49 120.45,44.61 123.12,47.28 123.12,65.31 120.81,67.62
  BOTTOM w0.089: UH1.AA11 113.99,80.57 v2(114.12,80.57)
  BOTTOM w0.102: v2(120.33,25.97) 120.25,25.97 119.16,27.07 JDIMM2.187
DDR_B_D35: length 65.4
  IN1 w0.076: 120.68,65.69 120.43,65.69 114.24,71.88 114.24,77.85 v2(114.12,77.97)
  IN1 w0.114: 120.68,65.69 121.39,65.69 122.16,64.92 122.16,47.67 119.49,45 119.49,40.09 119.98,39.61 119.98,36.12 119.78,35.92 119.78,35.56 119.98,35.36 119.98,33.84 119.71,33.56 119.71,30.53 119.53,30.35 119.53,28.96 119.25,28.68 119.25,23.25 v2(120.33,22.16)
  BOTTOM w0.089: UH1.AA7 113.99,77.97 v2(114.12,77.97)
  BOTTOM w0.102: v2(120.33,22.16) 120.15,22.16 118.91,20.92 JDIMM2.186
DDR_B_D36: length 65.9
  IN1 w0.076: 113.07,70.69 113.07,77.35 112.67,77.75 112.67,78.61 112.83,78.77 112.83,79.55 v2(113.21,79.92)
  IN1 w0.114: 113.07,70.69 119.87,63.88 119.87,48.62 117.2,45.95 117.2,39.26 116.95,39.01 116.95,34.02 116.45,33.51 116.45,22.89 115.29,21.73 v2(115.29,21.65)
  BOTTOM w0.076: v2(113.21,79.92) 112.88,79.6 UH1.AC10
  BOTTOM w0.102: JDIMM2.170 114.91,21.35 115.21,21.65 v2(115.29,21.65)
DDR_B_D37: length 66.2
  IN1 w0.076: v2(113.21,78.62) 113.21,78.51 112.84,78.14 112.84,77.83 113.28,77.38 113.28,70.92
  IN1 w0.114: v2(117.61,23.69) 116.77,24.53 116.77,33.38 117.27,33.88 117.27,38.88 117.52,39.12 117.52,45.82 120.19,48.49 120.19,64.02 113.28,70.92
  BOTTOM w0.089: UH1.AC8 113.07,78.62 v2(113.21,78.62)
  BOTTOM w0.102: JDIMM2.169 114.66,27.01 116.55,25.13 116.55,24.76 v2(117.61,23.69)
DDR_B_D38: length 65.9
  IN1 w0.076: v2(114.12,79.92) 114.49,79.55 114.49,78.42 114.81,78.1 114.81,77.15 115.2,76.77 115.2,72.57 120.2,67.56 120.42,67.56 120.64,67.34
  IN1 w0.114: 120.64,67.34 122.8,65.18 122.8,47.41 120.13,44.74 120.13,40.36 120.62,39.87 120.62,33.57 120.34,33.3 120.34,30.26 120.17,30.09 120.17,28.7 119.88,28.42 119.88,25.15 v2(120.33,24.7)
  BOTTOM w0.089: v2(114.12,79.92) 113.99,79.92 UH1.AA10
  BOTTOM w0.102: JDIMM2.183 118.16,27.36 118.46,27.05 118.74,27.05 119.78,26.02 119.78,25.25 v2(120.33,24.7)
DDR_B_D39: length 65.7
  IN1 w0.076: 120.52,67.01 120.42,67.11 120.37,67.11 114.99,72.48 114.99,76.73 114.61,77.12 114.61,78.01 114.12,78.5 v2(114.12,78.62)
  IN1 w0.114: v2(120.33,23.43) 119.56,24.2 119.56,28.55 119.85,28.83 119.85,30.22 120.02,30.4 120.02,33.43 120.3,33.71 120.3,39.74 119.81,40.23 119.81,44.87 122.48,47.54 122.48,65.05 120.52,67.01
  BOTTOM w0.089: UH1.AA8 113.99,78.62 v2(114.12,78.62)
  BOTTOM w0.102: JDIMM2.182 117.91,21.01 v2(120.33,23.43)
DDR_B_D40: length 68.1
  IN1 w0.076: v2(115.96,78.07) 115.56,77.67 115.56,77.36 116.07,76.84 116.07,72.86 120.3,68.64 121.57,68.64
  IN1 w0.114: 121.57,68.64 121.7,68.64 123.34,66.99 123.34,66.99 124.27,66.06 124.27,46.8 123.68,46.21 123.68,46.05 124.1,45.63 124.1,45.47 123.82,45.19 123.66,45.19 123.24,45.61 123.08,45.61 122.63,45.16 122.63,44.73 122.75,44.62 123.91,44.62 124.02,44.51 124.02,44.11 123.91,44 122.75,44 122.63,43.88 122.63,43.49 122.75,43.37 123.91,43.37 124.02,43.26 124.02,42.87 123.91,42.75 122.75,42.75 122.63,42.64 122.63,40.84 123.39,40.08 123.39,34.26 122.49,33.36 122.49,27.92 121.9,27.34 121.9,26.44 122.2,26.14 v2(122.27,26.14)
  BOTTOM w0.089: v2(115.96,78.07) 115.72,78.07 UH1.W8
  BOTTOM w0.102: v2(122.27,26.14) 122.2,26.07 121.95,26.07 121.16,26.86 JDIMM2.195
DDR_B_D41: length 67.8
  IN1 w0.076: v2(115.95,77.47) 116.25,77.17 116.25,72.93 120.31,68.88 121.9,68.88 122.01,68.77
  IN1 w0.114: 122.01,68.77 124.59,66.19 124.59,45.49 124.43,45.33 124.43,41.79 124.32,41.68 123.82,41.68 123.64,41.5 123.64,41.23 123.82,41.06 124.32,41.06 124.43,40.94 124.43,38.13 124.6,37.97 124.6,35.02 122.8,33.23 122.8,25.43 122.69,25.31 122.69,23.35 123.6,22.43 123.6,22.27 123.14,21.8 122.97,21.8 122.44,22.33 v2(122.28,22.33)
  BOTTOM w0.076: UH1.W7 115.78,77.65 v2(115.95,77.47)
  BOTTOM w0.102: JDIMM2.194 120.91,21.55 121.69,22.33 v2(122.28,22.33)
DDR_B_D42: length 68.1
  IN1 w0.076: 125.48,68.54 125.34,68.68 124.59,68.68 122.8,70.47 121.56,70.47 117.88,74.14 117.88,77.05 117.52,77.41 117.52,78.33 117.23,78.62 117.23,79.51 v2(116.82,79.92)
  IN1 w0.114: 125.48,68.54 126.97,67.05 126.97,63.58 127.24,63.31 127.24,39.19 127.3,39.13 127.3,33.53 125.94,32.16 125.94,24.67 v2(125.09,23.83)
  BOTTOM w0.089: v2(116.82,79.92) 116.73,79.92 UH1.V10
  BOTTOM w0.102: JDIMM2.207 124.16,27.02 125.5,25.68 125.5,24.24 v2(125.09,23.83)
DDR_B_D43: length 68.3
  IN1 w0.076: v2(116.84,80.57) 117.4,80.01 117.4,78.69 117.69,78.4 117.69,77.48 118.05,77.12 118.05,74.21 121.62,70.64 122.89,70.64 124.68,68.84 125.63,68.84 125.72,68.75
  IN1 w0.114: 125.72,68.75 127.29,67.18 127.29,63.71 127.56,63.44 127.56,39.33 127.62,39.26 127.62,33.4 126.25,32.03 126.25,24.54 125.56,23.84 125.56,23.01 v2(125.11,22.56)
  BOTTOM w0.089: UH1.V11 116.73,80.57 v2(116.84,80.57)
  BOTTOM w0.102: v2(125.11,22.56) 124.68,22.13 124.68,21.23 124.41,20.96 JDIMM2.208
DDR_B_D44: length 67.9
  IN1 w0.076: 121.49,68.26 121.29,68.46 120.22,68.46 115.87,72.81 115.87,76.81 115.37,77.31 115.37,77.93 115.57,78.14 115.57,79.43 115.95,79.8 v2(115.95,79.92)
  IN1 w0.114: v2(122.27,24.87) 121.58,25.57 121.58,27.47 122.17,28.06 122.17,33.49 123.07,34.39 123.07,39.05 122.8,39.32 122.8,39.56 123.03,39.79 123.03,39.95 122.75,40.23 122.59,40.23 122.36,40 122.12,40 121.29,40.84 121.29,44.26 123.95,46.93 123.95,65.8 121.49,68.26
  BOTTOM w0.076: v2(115.95,79.92) 115.62,80.25 UH1.W11
  BOTTOM w0.102: v2(122.27,24.87) 121,26.14 121,26.47 120.16,27.31 JDIMM2.191
DDR_B_D45: length 68
  IN1 w0.076: v2(115.08,79.27) 115.41,78.95 115.41,78.21 115.19,77.99 115.19,77.25 115.67,76.78 115.67,72.76 120.23,68.19 121.11,68.19 121.42,67.89
  IN1 w0.114: v2(122.27,23.6) 122.27,23.69 121.26,24.7 121.26,27.6 121.85,28.19 121.85,33.62 122.75,34.53 122.75,38.92 120.97,40.71 120.97,44.39 123.64,47.06 123.64,65.67 121.42,67.89
  BOTTOM w0.076: v2(115.08,79.27) 115.41,79.6 UH1.W10
  BOTTOM w0.102: v2(122.27,23.6) 122.18,23.6 120.9,22.32 120.9,22.13 119.91,21.14 JDIMM2.190
DDR_B_D46: length 67.6
  IN1 w0.076: v2(116.86,78.62) 117,78.62 117.36,78.26 117.36,77.35 117.72,76.98 117.72,74.08 121.49,70.31 122.63,70.31 124.43,68.51 125.06,68.51 125.27,68.3
  IN1 w0.114: 125.27,68.3 126.65,66.92 126.65,63.45 126.92,63.18 126.92,41.79 126.58,41.45 126.58,40.24 126.92,39.9 126.92,38.17 126.99,38.11 126.99,33.66 125.62,32.29 125.62,29.04 125.5,28.93 125.09,28.93 124.98,28.81 124.98,28.42 125.09,28.31 125.5,28.31 125.62,28.19 125.62,27.8 125.5,27.68 125.09,27.68 124.98,27.57 124.98,27.18 125.09,27.06 125.5,27.06 125.62,26.95 125.62,26.55 125.5,26.44 125.09,26.44 124.98,26.32 124.98,25.93 125.09,25.82 125.47,25.82 125.61,25.67 125.61,25.22 125.47,25.07 125.12,25.07 v2(125.09,25.1)
  BOTTOM w0.089: v2(116.86,78.62) 116.73,78.62 UH1.V8
  BOTTOM w0.102: JDIMM2.203 123.16,27.01 125.07,25.1 v2(125.09,25.1)
DDR_B_D47: length 67.9
  IN1 w0.076: 125.09,68.03 124.78,68.34 124.29,68.34 122.51,70.12 121.44,70.12 117.55,74.01 117.55,76.92 117.19,77.28 117.19,77.8 117.02,77.97 v2(116.86,77.97)
  IN1 w0.114: 125.09,68.03 126.34,66.79 126.34,63.32 126.61,63.05 126.61,41.92 126.27,41.58 126.27,40.11 126.61,39.77 126.61,37.47 126.26,37.13 126.26,36.73 126.37,36.62 126.53,36.62 126.64,36.5 126.64,33.76 126.41,33.53 126.25,33.53 125.96,33.83 125.8,33.83 125.52,33.55 125.52,33.39 125.81,33.09 125.81,32.93 125.3,32.42 125.3,31.16 125.19,31.04 125.12,31.04 125,30.93 125,30.54 125.12,30.42 125.19,30.42 125.3,30.31 125.3,29.77 124.62,29.09 124.62,22.23 124.86,21.99 124.86,21.83 124.56,21.53 124.32,21.53 v2(124.01,21.84)
  BOTTOM w0.089: UH1.V7 116.73,77.97 v2(116.86,77.97)
  BOTTOM w0.102: JDIMM2.204 123.41,20.85 124.01,21.45 v2(124.01,21.84)
DDR_B_D48: length 68.6
  IN1 w0.076: 125.13,69.61 124.52,69.61 123.12,71.01 122.51,71.01 120.38,73.14 120,73.14 119.8,72.94 119.57,72.94 118.26,74.24 118.26,77.41 117.99,77.68 117.99,78.26 118.16,78.42 118.16,80.04 v2(118.69,80.57)
  IN1 w0.114: 125.13,69.61 125.41,69.61 125.94,69.08 126.28,69.08 127.81,67.55 127.81,63.93 128.08,63.66 128.08,39.54 128.6,39.02 128.6,33.64 127.35,32.39 127.35,29.32 126.77,28.74 126.77,23.49 v2(126.41,23.12)
  BOTTOM w0.089: UH1.R11 118.56,80.57 v2(118.69,80.57)
  BOTTOM w0.102: v2(126.41,23.12) JDIMM2.216
DDR_B_D49: length 68.7
  IN1 w0.076: 125.16,70.73 125.13,70.7 124.29,70.7 123.21,71.78 122.68,71.78 120.56,73.9 120.56,73.95 119.88,74.63 119.33,74.63 118.8,75.16 118.8,77.59 118.69,77.7 v2(118.69,77.97)
  IN1 w0.114: v2(128.17,25.06) 127.73,25.51 127.73,25.9 127.84,26.01 127.95,26.01 128.06,26.12 128.06,26.52 127.95,26.63 127.84,26.63 127.73,26.75 127.73,27.14 127.84,27.25 127.95,27.25 128.06,27.37 128.06,27.76 127.95,27.88 127.84,27.88 127.73,27.99 127.73,28.35 128.3,28.92 128.3,29.43 128.52,29.65 128.52,30.06 128.3,30.28 128.3,30.57 129.55,31.82 129.55,35.94 129.66,36.06 130.08,36.06 130.19,36.17 130.19,36.57 130.08,36.68 129.66,36.68 129.55,36.8 129.55,37.19 129.66,37.3 130.08,37.3 130.19,37.42 130.19,37.81 130.08,37.93 129.66,37.93 129.55,38.04 129.55,38.43 129.66,38.55 130.08,38.55 130.19,38.66 130.19,39.06 130.08,39.17 129.66,39.17 129.55,39.28 129.55,39.42 129.03,39.94 129.03,64.05 128.76,64.32 128.76,67.95 126.59,70.12 126.38,70.12 125.76,70.73 125.16,70.73
  BOTTOM w0.089: UH1.R7 118.56,77.97 v2(118.69,77.97)
  BOTTOM w0.102: v2(128.17,25.06) 127.88,25.06 126.16,26.79 JDIMM2.215
DDR_B_D50: length 68.5
  IN1 w0.076: 125.1,72.51 123.14,74.48 122.89,74.48 122.34,75.02 121.89,75.02 120.96,75.95 120.96,76.13 120.07,77.02 120.07,77.51 v2(119.63,77.94)
  IN1 w0.114: 125.1,72.51 126.39,72.51 127.1,71.8 127.28,71.8 130.42,68.65 130.42,65.11 130.69,64.84 130.69,41.32 132.19,39.82 132.19,34.11 131.9,33.82 131.36,33.82 131.25,33.7 131.25,33.31 131.36,33.2 131.46,33.2 131.57,33.08 131.57,32.69 131.46,32.57 131.36,32.57 131.25,32.46 131.25,32.06 131.36,31.95 131.46,31.95 131.57,31.84 131.57,30.36 131.46,30.24 130.75,30.24 130.63,30.13 130.63,28.89 129.8,28.06 129.8,27.01 130.32,26.49 130.32,24.23 129.78,23.7 129.65,23.7 v2(129.57,23.62)
  BOTTOM w0.089: v2(119.63,77.94) 119.61,77.96 119.47,77.96 UH1.P7
  BOTTOM w0.102: JDIMM2.228 129.41,21 130.01,21.6 130.01,23.18 v2(129.57,23.62)
DDR_B_D51: length 68.7
  IN1 w0.076: v2(119.61,80.57) 120.13,80.05 120.13,79.09 120.56,78.65 120.56,77.23 121.48,76.31 121.48,76.14 122.04,75.58 122.56,75.58 122.72,75.73 123.17,75.73 123.43,75.48 123.43,75.28 125.24,73.46 125.85,73.46
  IN1 w0.114: v2(131.38,26.11) 131.38,28.29 132.16,29.07 132.78,29.07 133.1,29.39 133.1,32.83 133.88,33.61 133.88,33.97 133.76,34.09 133.54,34.09 133.42,34.2 133.42,34.59 133.54,34.71 133.76,34.71 133.88,34.82 133.88,35.22 133.76,35.33 133.54,35.33 133.42,35.44 133.42,35.79 133.54,35.91 133.76,35.91 133.88,36.02 133.88,39.48 132.16,41.2 132.16,45.05 131.67,45.54 131.67,65.2 131.37,65.51 131.37,69.05 127.67,72.75 127.5,72.75 126.78,73.46 125.85,73.46
  BOTTOM w0.089: v2(119.61,80.57) 119.47,80.57 UH1.P11
  BOTTOM w0.102: v2(131.38,26.11) 131.27,26.01 130.93,26.01 129.66,27.29 JDIMM2.229
DDR_B_D52: length 68.9
  IN1 w0.076: 125.31,70.37 124.39,70.37 123.18,71.58 122.61,71.58 120.02,74.16 120.02,74.21 119.77,74.46 119.26,74.46 118.63,75.09 118.63,77.52 118.32,77.83 118.32,78.12 118.69,78.49 v2(118.69,78.62)
  IN1 w0.114: 125.31,70.37 125.64,70.37 126.25,69.76 126.5,69.76 128.45,67.81 128.45,64.19 128.71,63.92 128.71,39.81 129.23,39.29 129.23,33.07 129.12,32.96 128.93,32.96 128.82,32.84 128.82,32.45 128.93,32.34 129.12,32.34 129.23,32.22 129.23,31.95 127.98,30.7 127.98,29.06 127.41,28.48 127.41,24.56 v2(128.18,23.79)
  BOTTOM w0.089: v2(118.69,78.62) 118.56,78.62 UH1.R8
  BOTTOM w0.102: JDIMM2.211 125.16,26.81 v2(128.18,23.79)
DDR_B_D53: length 68.2
  IN1 w0.076: 125.36,69.99 124.52,69.99 123.17,71.34 122.59,71.34 120.2,73.73 119.44,73.73 118.43,74.74 118.43,77.49 118.16,77.76 118.16,78.19 118.32,78.35 118.32,79.55 v2(118.69,79.92)
  IN1 w0.114: v2(125.92,21.89) 127.09,23.06 127.09,28.61 127.67,29.19 127.67,32.25 128.92,33.5 128.92,39.16 128.4,39.67 128.4,63.79 128.13,64.06 128.13,67.68 126.38,69.43 126.1,69.43 125.54,69.99 125.36,69.99
  BOTTOM w0.089: v2(118.69,79.92) 118.56,79.92 UH1.R10
  BOTTOM w0.102: v2(125.92,21.89) 125.41,21.37 JDIMM2.212
DDR_B_D54: length 68.4
  IN1 w0.076: 125.68,72.82 125.14,72.82 123.33,74.64 122.96,74.64 122.41,75.19 121.96,75.19 121.13,76.02 121.13,76.2 120.23,77.09 120.23,77.99 119.63,78.6 v2(119.63,78.62)
  IN1 w0.114: v2(129.52,22.38) 130.63,23.5 130.63,26.97 130.52,27.09 130.26,27.09 130.15,27.2 130.15,27.6 130.26,27.71 130.52,27.71 130.63,27.82 130.63,28.44 131.89,29.7 131.89,33.36 132.51,33.98 132.51,39.95 131.53,40.93 131.53,44.79 131.04,45.28 131.04,64.94 130.74,65.24 130.74,68.79 127.41,72.11 127.23,72.11 126.52,72.82 125.68,72.82
  BOTTOM w0.089: UH1.P8 119.31,78.3 v2(119.63,78.62)
  BOTTOM w0.102: v2(129.52,22.38) 128.76,21.62 128.76,21.25 128.41,20.9 JDIMM2.224
DDR_B_D55: length 68.4
  IN1 w0.076: 125.59,73.14 125.18,73.14 123.52,74.81 123.03,74.81 122.48,75.35 122.03,75.35 121.31,76.07 121.31,76.24 120.4,77.16 120.4,78.55 119.96,78.98 119.96,79.56 v2(119.61,79.92)
  IN1 w0.114: v2(131.38,24.84) 130.95,25.27 130.95,28.31 132.21,29.57 132.21,33.22 132.83,33.84 132.83,40.08 131.84,41.07 131.84,44.92 131.36,45.41 131.36,65.07 131.05,65.38 131.05,68.92 127.54,72.43 127.36,72.43 126.65,73.14 125.59,73.14
  BOTTOM w0.089: v2(119.61,79.92) 119.47,79.92 UH1.P10
  BOTTOM w0.102: v2(131.38,24.84) 130.94,25.28 130.94,25.55 129.78,26.71 129.28,26.71 128.66,27.34 JDIMM2.225
DDR_B_D56: length 71.4
  IN1 w0.076: v2(121.42,77.36) 121.59,77.19 122.57,77.19 123.71,76.05 124.27,76.05 124.82,75.5 125.23,75.5
  IN1 w0.114: v2(132.7,26.68) 132.7,27.05 134.25,28.61 134.25,32.36 135.03,33.13 135.03,33.76 135.15,33.88 135.62,33.88 135.74,33.99 135.74,34.39 135.62,34.5 135.15,34.5 135.03,34.61 135.03,35.27 135.24,35.48 135.24,35.89 135.03,36.1 135.03,36.51 135.27,36.75 135.27,37.11 135.03,37.35 135.03,37.76 135.24,37.97 135.24,38.38 135.03,38.59 135.03,39 135.24,39.22 135.24,39.63 135.1,39.77 135.1,40.28 134.77,40.62 134.6,40.62 134.57,40.58 134.41,40.58 134.13,40.86 134.13,41.02 134.16,41.06 134.16,41.22 133.99,41.39 133.8,41.39 133.78,41.37 133.62,41.37 133.32,41.68 133.32,42.09 133.43,42.21 133.6,42.21 133.71,42.32 133.71,42.72 133.6,42.83 133.43,42.83 133.32,42.94 133.32,43.34 133.43,43.45 133.6,43.45 133.71,43.57 133.71,43.96 133.6,44.07 133.44,44.07 133.33,44.19 133.33,44.58 133.44,44.7 133.6,44.7 133.71,44.81 133.71,45.21 133.62,45.3 133.41,45.3 133.32,45.39 133.32,45.77 133.23,45.86 132.99,45.86 132.84,46.01 132.84,46.37 132.96,46.49 133.73,46.49 133.84,46.6 133.84,47 133.73,47.11 132.94,47.11 132.83,47.23 132.83,47.62 132.94,47.73 133.73,47.73 133.84,47.85 133.84,48.24 133.73,48.36 132.94,48.36 132.83,48.47 132.83,48.86 132.94,48.98 133.7,48.98 133.81,49.09 133.81,49.49 133.7,49.6 132.94,49.6 132.83,49.72 132.83,65.68 132.53,65.99 132.53,69.55 128.18,73.9 127.98,73.9 127.26,74.62 126.12,74.62 125.23,75.5
  BOTTOM w0.076: v2(121.42,77.36) 121.38,77.39 121.23,77.39 UH1.M7
  BOTTOM w0.102: v2(132.7,26.68) 132.07,26.68 131.66,27.09 JDIMM2.237
DDR_B_D57: length 71.8
  IN1 w0.076: v2(121.43,80.57) 121.05,80.19 121.05,79.61 120.87,79.43 120.87,77.16 121.71,76.31 122.98,76.31 123.57,75.72 124.14,75.72 124.73,75.12 124.86,75.12 126,73.98 126.32,73.98
  IN1 w0.114: v2(131.53,21.38) 131.95,21.79 131.95,22.99 131.83,23.1 131.27,23.1 131.16,23.22 131.16,23.61 131.27,23.72 131.83,23.72 131.95,23.84 131.95,28.12 132.37,28.55 132.99,28.55 133.62,29.17 133.62,32.62 134.4,33.4 134.4,39.7 132.68,41.41 132.68,45.27 132.2,45.76 132.2,65.42 131.89,65.72 131.89,69.29 127.91,73.27 127.71,73.27 127,73.98 126.32,73.98
  BOTTOM w0.089: v2(121.43,80.57) 121.3,80.57 UH1.M11
  BOTTOM w0.102: v2(131.53,21.38) 131.41,21.25 JDIMM2.236
DDR_B_D58: length 71.6
  IN1 w0.076: 126.17,79.59 126.14,79.63 123.44,79.63 123.33,79.52 123.05,79.52 122.79,79.77 122.79,80.1 v2(122.32,80.57)
  IN1 w0.114: 126.17,79.59 126.22,79.54 127.18,79.54 131.1,75.62 131.1,75.4 135.47,71.03 135.47,67.21 135.77,66.91 135.77,55.86 136.87,54.75 136.87,42.67 138.75,40.8 138.75,39.38 140.29,37.84 140.29,36.15 139.6,35.46 139.6,33.33 139.45,33.18 139.45,31.64 137.69,29.88 137.69,27.61 137.49,27.41 137.49,27.25 137.86,26.88 137.86,26.72 137.58,26.44 137.42,26.44 137.05,26.81 136.89,26.81 v2(135.83,25.75)
  BOTTOM w0.089: v2(122.32,80.57) 122.22,80.57 UH1.L11
  BOTTOM w0.102: v2(135.83,25.75) 135.38,25.75 134.66,26.48 JDIMM2.249
