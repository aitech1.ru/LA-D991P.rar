# Allegro board Dell Inspiron 15 Gaming 7566 Compal LA-D991P BCV00 Rev1.0 BoardView.brd (continued)
## Nets (continued)
N131307439: QV2.1 RV570.2
N131311358: DC2.2 RC11.1
N131431549: QE20.2 QE20.3 RH504.2
N131431604: QE23.5 QE23.6 RH505.2
N131431963: LED3.2 RW3.1
N131431980: LED4.2 RW4.1
N131432059: QE24.5 QE24.6 RH506.2
N131436195: JFAN1.1 Q12.1 RE100.2
N131438652: QV3.5 RV56.1
N131522020: PQ103.5 PR113.2 PR115.1
N132541936: CA66.2 QA2.3 RA79.1 RA80.2
N132541970: QA1.1 RA79.2
N132753431: PC1516.1 PC1517.1 PC1518.1 PC1519.1 PJP1501.2 PL1504.2 PU1503.6
N132753897: PR1532.1 PU1503.12
N132753926: PC1523.1 PR1533.2 PU1503.11
N132753938: PC1522.1 PR1527.1
N132753962: PR1527.2 PU1503.5
N132753966: PC1522.2 PU1503.4
N132754030: PR1530.2 PU1503.1
N132754050: PC1520.2 PR1531.2 PU1503.2
N133033957: PQ306.4 PR325.1
N133034293: PQ301.4 PR303.1
N201821498: CA23.1 HDA1.19
N201821507: CA15.2 HDA1.34
N201821575: CA16.2 HDA1.28
N201821604: CA27.1 HDA1.7
N201821615: CA20.2 HDA1.35
N201821733: CA20.1 HDA1.37
N201821740: CA19.2 HDA1.27 RA11.2
N1290221070: CA34.2 RA36.1
N1290221251: CA35.2 RA37.1
N1323149380: T91.1(TP-1) UH2.R44
N1323150428: T94.1(TP-1) UH2.U42
N13231504269: T182.1(TP-1) UH2.AG35
N13248890811: T120.1(TP-1) UH2.AL42

Pads without a net: FD1 1; FD2 1; FD3 1; FD4 1; HDA1 11 12 14 15 23 48; JAPS 16 17 18; JBAT10 8; JBL1 3; JCAM1 11 13; JDIMM1 87 88 91 92 95 97 100 101 104 105 134 162 165; JDIMM2 87 88 91 92 95 97 100 101 104 105 134 162 165; JEDP1 4 15 23; JHDD1 4 15 16; JIO1 6 27; JKB1 2 3; JNGFF1 6 8 9 11 12 13 14 21 23 24 26 32 34 38 40 50 51 52 53 54 56 57 58 59 60 62 63 65; JNGFF2 6 8 20 22 24 26 28 30 32 34 36 40 42 44 46 48 56 58 67; PU600 9 10 12; PU700 10 12; PU800 10 12; PU1000 12; PU1400 6 25 27; PU1401 6 25 27; PU1402 6 25 27; PU1500 6 25 27; PU1501 6 25 27; PU1800 5; RP15 4 5; SW5 2 3; UA1 4; UA2 30; UC1 1; UC16 1; UE1 31 69; UE6 1; UH1 A27 AA14 AD2 AD4 AE1 AE5 AE9 AE10 AE11 AE29 AF10 AF29 AF30 AF31 AF32 AF33 AF34 AG13 AG14 AG31 AG32 AG33 AG34 AG35 AG36 AH13 AH14 AH29 AH30 AH31 AH32 AH35 AH36 AJ8 AJ10 AJ11 AJ13 AJ14 AK3 AL1 AL2 AL3 AM10 AM11 AT3 AT5 AT7 AT11 AT13 AU13 AW7 AW8 AW9 AW10 AW11 AW13 AY1 AY2 AY3 AY4 AY5 AY7 AY8 AY9 AY10 AY11 AY13 B2 B27 B30 B33 B34 B36 B38 BA1 BA2 BA3 BA4 BA5 BH30 BJ13 BJ14 BJ16 BJ17 BJ19 BJ20 BJ21 BJ23 BJ24 BJ26 BJ27 BJ28 BJ33 BJ34 BJ35 BJ36 BK16 BK17 BK19 BK20 BK21 BK23 BK24 BK26 BK27 BK28 BL14 BL15 BL16 BL17 BL18 BL19 BL20 BL21 BL22 BL23 BL24 BL25 BL26 BL27 BL28 BL31 BL33 BL34 BM14 BM15 BM16 BM17 BM19 BM22 BM24 BM31 BM33 BN1 BN15 BN16 BN17 BN22 BN23 BN27 BN28 BN33 BN35 BP1 BP13 BP15 BP16 BP17 BP19 BP22 BP23 BR1 BR2 BR15 BR16 BR17 BR19 BR22 BR23 BR27 BR31 BR35 BT2 BT15 BT16 BT17 BT19 BT22 BT23 BT27 BT30 C1 C30 C33 C34 C38 D1 D34 E1 E2 E3 E26 E30 E33 E36 E37 F26 F30 F33 F34 F35 F37 G3 G13 G38 H24 H33 H34 J3 J24 N29 R14; UH2 A14 A16 A21 A39 A40 A41 AA44 AA45 AB13 AB33 AB35 AB36 AB39 AB41 AB42 AB43 AB44 AC2 AC3 AC43 AD31 AD35 AD38 AE17 AE45 AF2 AF3 AF17 AG14 AG15 AG39 AG44 AH43 AH44 AJ7 AJ8 AJ11 AJ13 AJ33 AJ35 AJ42 AJ43 AJ44 AK44 AK45 AL7 AL8 AL39 AL43 AM43 AM44 AN17 AN24 AN29 AN36 AN38 AN41 AN42 AN43 AR15 AR19 AR22 AR29 AT2 AT31 AT43 AT44 AU41 AU43 AU44 AV2 AV3 AV4 AV44 AW2 AW31 AW35 AY2 B13 B14 B15 B16 B19 B20 B21 B23 B24 B36 B39 BA4 BA35 BA41 BB3 BB13 BB17 BB19 BB36 BB38 BC8 BC19 BC22 BC35 BC36 BC38 BD1 BD6 BD8 BD14 BD18 BD21 BD23 BD27 BD34 BD35 BD38 BD39 BE2 BE5 BE6 BE21 BE34 BE39 C14 C15 C19 C20 C23 C24 C36 D5 D7 D8 D43 E6 E11 E17 E20 E35 E41 E42 E45 F41 F45 G11 G13 G15 G17 G19 G35 G37 G44 G45 H13 H15 H40 H42 H43 H44 J45 K13 K15 K17 K22 K24 K37 K44 L1 L2 L5 L7 L17 L22 L24 L37 L39 L44 M44 M45 N2 N3 N7 N8 N29 N31 N38 N39 N42 N43 N44 P1 P2 P3 P24 P27 P29 P31 P43 P44 R2 R3 R4 R11 R13 R24 R27 R35 R36 R39 R41 R42 R43 T44 U5 U7 U13 U35 U36 U39 U41 V1 V2 W2 W3 W7 W10 W11 W13 W39 Y5; UM1 C5 D3 D7 F3 F7; US1 9; UT1 8; UV1 A9 A26 A27 A30 AA1 AA2 AA3 AA4 AA5 AA6 AA7 AA8 AB3 AB4 AB8 AC1 AC2 AC3 AC4 AC5 AC6 AC7 AC8 AC28 AC32 AD1 AD2 AD3 AD4 AD5 AD6 AE3 AE4 AF1 AF2 AF3 AF4 AF5 AF6 AF7 AF8 AF30 AF32 AG1 AG2 AG3 AG4 AG5 AG6 AG7 AG8 AG9 AG10 AH3 AH4 AH6 AH8 AH9 AH31 AJ1 AJ2 AJ3 AJ4 AJ5 AJ6 AJ8 AJ9 AJ11 AJ28 AJ31 AJ32 AJ33 AK1 AK2 AK3 AK4 AK5 AK6 AK8 AK9 AK31 AL3 AL4 AL6 AL7 AL8 AL9 AL10 AL11 AM1 AM2 AM3 AM4 AM5 AM6 AM7 AM8 AM9 AM34 AN2 AN3 AN5 AN6 AN8 AN9 AP3 AP5 AP6 AP8 AP9 B2 B6 B23 C6 C12 C15 C20 D6 D7 D9 D19 D20 D22 D23 D26 D28 E4 E26 E34 F1 F2 F26 G14 G20 H26 H30 H31 J30 J31 J32 J33 K3 K4 L2 L6 M3 M6 M30 M34 N4 N8 P2 P3 P4 P5 P7 P8 R1 R8 R28 R32 T8 U1 U2 U3 U4 U5 U6 U7 U8 V1 V2 V3 V4 V5 V6 V7 V8 V32 W2 W3 W4 W5 W7 W8 Y1 Y2 Y3 Y4 Y5 Y6 Y7 Y8; UV6 A5 U5; UV7 A5 U5; UV8 A5 U5; UV9 A5 U5; UZ8 3

## Via types
v1: diameter 0.305, hole 0.152, TOP to BOTTOM, 677 vias
v2: diameter 0.457, hole 0.203, TOP to BOTTOM, 7630 vias
v3: diameter 0.406, hole 0.203, TOP to BOTTOM, 264 vias
v4: diameter 0.508, hole 0.254, TOP to BOTTOM, 162 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.2V_DDR_OT: length 4.8
  BOTTOM w0.254: PR500.1 96,9.18 v1(96.28,9.46) 96.71,9.9 99.21,9.9 99.35,10.04 PU500.19
1.2V_DTH: length 1.6
  TOP w0.102: 258.51,28.26 258.51,28.84 v1(259.22,29.56)
1.2V_VCCPLL_OC: length 0.6
  TOP w0.102: 71.99,46.85 v1(71.99,46.29)
1.2V_VDDQ_EN: length 64.2
  TOP w0.102: RZ102.2 150.38,14.48 CZ102.1 150.26,14.32 v2(150.26,13.01) 150.26,12.81 v1(150.63,12.44)
  IN1 w0.114: v2(94.87,15.9) 95.74,15.02 103.02,15.02 104.38,16.39 109.73,16.39 111.34,14.77 116.82,14.77 117.97,15.92 123.27,15.92 127.9,11.29 148.54,11.29 v2(150.26,13.01)
  BOTTOM w0.114: PR507.1 94.65,15.55 94.87,15.77 v2(94.87,15.9)
1.05V_DGPU_PG: length 122.3
  TOP w0.102: DV13.2 161.9,74.02 v2(162.39,73.52) ; v2(231.33,41.8) 231.77,41.36 232.64,41.36 233.05,41.77 233.05,43.4 232.56,43.89 232.56,44.05 v3(232.12,44.49) 231.76,44.14 PR801.2
  IN1 w0.114: v2(195.67,48.55) 195.12,48.55 194.27,49.4 190.39,49.4 188.57,51.23 180.7,51.23 177.78,54.14 177.78,55.92 176.29,57.41 176.29,58.13 175.63,58.79 173.62,58.79 168.94,63.47 168.94,69.86 167.56,71.24 167.56,72.33 166,73.89 162.76,73.89 v2(162.39,73.52) 158.63,73.52 157.74,74.41 154.19,74.41 153.55,75.05 152.41,75.05 147.84,79.62 v2(147.84,81.27)
  IN2 w0.127: v2(231.33,41.8) 231.33,41.11 230.16,39.94 220.35,39.94 220.09,39.69 208.02,39.69 199.08,48.63 195.74,48.63 v2(195.67,48.55)
  BOTTOM w0.102: v2(147.84,81.27) 148.09,81.52 148.6,81.52 148.77,81.69 148.77,84.48 148.53,84.71 UV11.1
1.35V_DGPU_PG: length 33.9
  IN2 w0.127: v2(146.44,109.46) 145.68,110.23 144.15,110.23 143.44,109.51 143.44,87.57 146.44,84.57 v2(146.44,84.06)
  BOTTOM w0.102: UV11.2 147.71,84.06 147.46,84.32 146.69,84.32 v2(146.44,84.06) ; v2(146.44,109.46) 146.77,109.79 PR908.1
3.3V_CAM_EN#: length 69.9
  TOP w0.102: v2(194.75,43.68) 195.23,43.68 195.51,43.4 195.51,42.97 194.65,42.1 194.65,40.12 189.01,34.48 189.01,33.21 187.41,31.61 v2(187.26,31.61)
  IN3 w0.127: v2(187.26,31.61) 187.26,31 186.73,30.47 185.87,30.47 185.26,29.86 182.6,29.86 181.56,28.82 179.98,28.82 179.7,28.54 177.22,28.54 176.31,27.64 175.44,27.64 175.09,27.98 174.46,27.98 174.29,27.82 171.19,27.82 170.6,28.41 168.89,28.41 167.93,27.45 166.63,27.45 165.72,26.53 v2(165.72,26.46)
  BOTTOM w0.102: UH2.AR27 166.07,26.91 165.72,26.56 v2(165.72,26.46)
  BOTTOM w0.114: v2(194.75,43.68) 197.47,43.68 199.48,45.68 v1(200.09,45.68) 207.76,45.68 QZ9.2 208.44,47.28 RZ38.1 206.89,47.28 206.56,47.62 206.56,50.94 208.06,52.44 PR113.1
3V3_MAIN_EN: length 157.5
  TOP w0.102: v2(174.51,75.66) 174.32,75.66 173.73,75.07 173.42,75.07 173.24,74.89 173.24,73.24 RV55.1 173.49,72.76 172.17,71.44 170.65,71.44 170.26,71.83 166.27,71.83 166.08,72.02 166.08,72.46 166.38,72.77 UZ17.3
  IN1 w0.114: v2(205.01,53.1) 205.01,53.33 208.81,57.12 208.81,62.21 208.17,62.84 208.17,63.99 v2(208.16,64)
  IN2 w0.127: v2(230.85,42.23) 230.87,42.2 230.87,41.19 229.92,40.24 220.29,40.24 219.99,39.94 208.15,39.94 204.45,43.64 204.45,52.16 205.01,52.72 v2(205.01,53.1) ; v2(174.3,80.51) 174.3,79.7 174.63,79.37 174.63,76.95 174.51,76.83 v2(174.51,75.66) 176.03,74.13 189.04,74.13 189.16,74.26 206.66,74.26 207.73,73.19 207.73,64.43 v2(208.16,64)
  BOTTOM w0.102: UV1.L7 173.8,81.01 v2(174.3,80.51) ; v2(205.01,53.1) 204.91,53.2 191.83,53.2 187.92,57.11 187.92,59.27 185.94,61.25 177.76,61.25 176.92,60.42 PR1008.2 ; PR806.1 226.91,36.57 227.74,36.57 230.85,39.68 v2(230.85,42.23)
3V/5VALW_EN: length 20.4
  IN1 w0.254: v2(55.1,25.57) 55.28,25.75 56.88,25.75 58,24.63 58,23.76 57.4,23.17 57.4,19.81 v2(54.62,17.03)
  BOTTOM w0.254: v2(54.62,17.03) 54.49,17.16 PR407.1 ; PD401.2 54.28,27.36 54.91,28 PQ403.1 55.69,27.69 PC422.1 PR418.2 55.56,26.03 v2(55.1,25.57) ; PD401.2 PD401.3 ; PD401.2 53.6,27.35 PR409.2
3V_GFX_AON: length 3.8
  TOP w0.508: QV85.1 152.53,81.58 153.03,82.08 v1(153.4,82.08) 154.69,82.08 RV533.1
3V_GFX_RUN: length 5.8
  TOP w0.102: v1(172.76,74.54) 172.76,74.24 172.2,73.69 RZ69.1 171.32,73.69
  TOP w0.254: UZ17.8 171.25,73.77 171.32,73.69 170.9,73.27 UZ17.7
3VS:
  vias: v1(213.37,15.48)
3VS_TP: length 3.8
  TOP w0.102: v1(137.42,17.77) 137.42,17 UE4.1
  TOP w0.508: RE93.1 135.84,16.25 136.41,16.25 136.6,16.43 UE4.1
5VS:
  vias: v1(213.4,10.71)
5VS_FAN1: length 7.9
  TOP w0.508: v3(58.33,34.03) 58.33,34.71 56.93,36.11 56.02,36.11 55.26,35.35 JFAN1.2 55.26,33.11 55.25,33.11 RE104.2
5VS_FAN2: length 9.1
  TOP w0.508: RE105.2 244.55,35.6 246.61,35.6 JFAN2.2 247.43,35.68 248.07,36.31 248.07,38.57 246.85,39.79 246.42,39.79 v3(245.86,40.35)
+0.6VS: length 39.8
  TOP w1.016: 137.04,22.85 137.8,22.85 138.39,22.27 138.39,21.21 ; 137.04,22.85 137.04,24.63 137.78,25.37 ; 137.04,22.85 136.08,22.85 135.34,22.11 135.34,21.15 134.38,20.18 133.68,20.18 132.53,19.04 132.53,18.47 131.82,17.76 122.3,17.76 121.7,17.16 119.69,17.16 119.59,17.06 116.24,17.06 113.97,14.79 106.94,14.79
  vias: v2(105.52,15.87) v2(106.11,15.88) v2(137.04,21.2) v2(137.3,31.49) v2(137.3,30.88) v2(137.47,21.61) v3(137.88,26.03)
+0.6VSP:
  vias: v1(101.46,13.96)
+0.95VSP: length 10.4
  TOP w0.254: PR703.1 66.43,62.52 66.89,62.98 66.89,63.27 67.75,64.13 PC712.1 67.75,64.58 v2(67.57,64.76)
  BOTTOM w0.254: v2(73.8,66.16) 72.4,64.76 71.64,64.76 70.88,65.52 68.34,65.52 v2(67.57,64.76)
  vias: v2(72.93,72.46) v2(72.94,71.85) v2(72.9,71.23) v2(73.44,72.79) v2(73.44,72.17) v2(73.46,71.57) v2(74.18,66.67) v2(74.43,66.13) v2(74.69,67.05) v2(74.94,66.49) v2(75.19,67.43) v2(75.42,66.87) v2(75.7,67.81) v3(73.42,70.14)
+1.2V_DDR: length 361.6
  TOP w0.102: 116.46,80.27 116.42,80.3 116.42,80.98 116.53,81.09
  TOP w0.254: v2(117.71,31.56) 116.94,32.32 CD71.1 ; CD78.1 106.34,32.09 105.77,31.52 v2(104.94,31.52) ; CD5.1 112.61,44.41 CD79.1 ; v2(104.95,30.19) 104.74,30.19 104.34,29.8 CD26.1 ; v2(101.15,30.15) 100.66,30.15 99.86,30.95 CD72.1 100.85,31.44 v2(101.14,31.44) ; v2(78.97,43.04) 78.99,43.03 CD2.1 ; CD23.1 v2(121.39,29.45) ; CD85.1 98.15,29.4 v2(98.38,29.63) ; v2(83.97,31.35) 84.06,31.44 CD74.1
  TOP w0.508: CD84.1 113.13,28.96 v2(113.62,29.45) ; CH129.1 CH130.1 CH131.1 CH132.1 ; v2(90.15,43.06) 89.76,43.44 CD8.1 ; CD79.1 v2(111.84,43.28) ; v2(109.41,18.68) 109.41,18.68 CD22.1 ; v2(97.56,43.01) 97.26,43.01 97.04,42.79 CD1.1 96.61,43.78 CD73.1 ; CD70.1 122.49,43.96 v2(122.08,43.96) ; v2(95.7,31.3) 94.7,32.3 CD75.1 ; 73.11,43.73 72.88,43.96 RH206.1 ; CD6.1 101.36,44.44 101.13,44.21 v2(101.13,44.06) ; v2(101.15,42.54) 101.81,42.54 102.04,42.76 CD77.1 ; v2(88.63,30.14) 88.3,30.47 CD86.1 ; v2(81.98,82.39) 82.89,83.3 86.83,83.3 87.23,83.71 92.15,83.71 94.56,81.3 94.58,81.28 95.05,81.28 95.36,80.97
  IN1 w1.016: 119.45,7.24 156.92,7.24
  IN2 w0.508: v2(257.95,31.23) 257.95,31.14 257.29,30.48 255.81,30.48 254.39,29.06 250.35,29.06 246.88,25.6 244.46,25.6 243.53,24.66 243.53,23.67 243,23.14 241.09,23.14 240.64,22.7 239.84,22.7 239.17,22.03 239.17,20.86 238.24,19.94 233.75,19.94 232.96,19.15 232.96,19.08 230.43,16.55 229.37,16.55 228.41,15.59 228.41,14.22 227.59,13.4 222.82,13.4 222.31,13.91 222.31,14.8 221.83,15.28 220.15,15.28 219.33,16.11 216.69,16.11 215.41,14.82 209.87,14.82 208.54,16.16 199.46,16.16 198.36,15.06 197.52,15.06 195.5,13.05 190.74,13.05 188.86,11.17 185.89,11.17 183.27,8.55 182.59,8.55 181.09,7.05 171.66,7.05 166.76,11.95 161.29,11.95 v2(157.47,8.14) v2(156.84,8.14)
  BOTTOM w0.203: v2(109.61,76.65) 109.71,76.65 UH1.AF6 ; v2(109.61,76.65) 109.92,76.34 UH1.AF5 ; v2(109.61,76.65) 109.3,76.34 UH1.AG5 ; v2(123.14,80.59) 123.09,80.64 123.09,80.64 122.83,80.9 UH1.K12 122.56,81.07 122.06,81.07 UH1.L12 ; v2(99.55,76.64) 99.89,76.99 UH1.AW6 ; v2(106.82,80.61) 106.81,80.61 106.44,80.25 UH1.AL11 106.35,80.17 105.9,79.72 v2(105.9,79.26) ; UH1.W6 115.03,76.99 114.64,76.6 v2(114.62,76.6) 114.24,76.98 UH1.AA6 ; v2(109.53,79.38) 109.52,79.38 UH1.AG9 108.99,78.95 108.62,79.31 v2(108.62,79.26) ; UH1.AP7 103.6,77.24 UH1.AP6 UH1.AR6 102.14,76.62 v2(102.07,76.62) ; UH1.AY6 v2(99.53,77.36) ; UH1.J6 UH1.K6 122.43,77.18 121.98,77.18 121.79,76.99 UH1.L6 ; UH1.AT12 101.91,80.9 v2(102.23,80.57) 102.56,80.9 UH1.AR12 ; v2(117.09,76.63) 117.12,76.63 117.47,76.99 UH1.T6 UH1.R6
  BOTTOM w0.254: v2(111.83,42.46) 111.9,42.46 112.15,42.2 JDIMM1.159 ; UH1.J5 123.57,76.34 v2(123.89,76.65) 123.55,76.99 UH1.J6 ; v2(73.06,31.49) 73.4,31.83 JDIMM1.12 ; UH1.AJ12 107.47,80.9 v2(107.71,80.66) ; JDIMM1.54 83.9,31.61 83.97,31.55 v2(83.97,31.35) ; UH1.AE12 110.84,80.9 v2(110.47,80.53) ; JDIMM2.75 89.16,29.64 88.66,30.14 v2(88.63,30.14) ; JDIMM2.33 78.66,29.29 78.38,29.57 v2(77.26,29.57)
  BOTTOM w0.305: JDIMM1.136 104.4,31.82 104.71,31.52 v2(104.94,31.52) 105.63,31.52 105.9,31.8 JDIMM1.142 ; v2(78.97,43.04) 78.95,43.04 78.93,43.02 78.61,43.02 78.39,42.8 78.39,42.23 78.65,41.97 JDIMM1.33 ; v2(117.71,31.56) 117.18,31.56 116.9,31.83 JDIMM1.178 ; CH197.1 81.53,83.23 82.13,83.23 82.24,83.11 UC1.5 ; v2(128.15,31.49) 127.77,31.49 127.4,31.85 JDIMM1.220 ; v2(131.11,44.51) 131.12,44.51 132.65,42.97 JDIMM1.241 ; v2(101.15,42.54) JDIMM1.123 ; JDIMM2.124 101.41,18.95 v2(101.67,18.69) ; JDIMM2.54 v2(83.91,18.66) ; JDIMM2.178 v2(116.91,18.66) ; JDIMM2.117 99.66,29.09 100.09,29.52 v2(101.16,29.52) JDIMM2.123 ; JDIMM1.112 98.4,31.58 v2(98.34,31.51) ; JDIMM2.220 v2(127.41,18.66) ; JDIMM2.163 113.16,29.4 113.17,29.4 113.22,29.45 v2(113.62,29.45) ; JDIMM2.96 94.41,18.72 ; v2(104.66,18.66) 104.41,18.91 JDIMM2.136 ; v2(98.38,29.63) 98.16,29.41 JDIMM2.111 ; JDIMM1.141 105.65,42.78 104.3,44.14 101.2,44.14 v2(101.13,44.06) ; JDIMM2.12 v2(73.41,18.66) ; JDIMM1.129 102.65,41.9 102.99,42.23 v2(103.64,42.23) 103.81,42.23 104.15,41.89 JDIMM1.135 ; v2(109.38,30.01) 109.16,29.79 JDIMM2.147 ; JDIMM2.118 99.91,18.71 v2(99.96,18.66) ; v2(104.95,30.19) 103.55,30.19 102.66,29.3 JDIMM2.129 ; v2(101.15,30.15) 100.92,30.15 99.9,31.16 JDIMM1.118 ; JDIMM2.159 112.16,29.12 111.79,29.48 v2(111.3,29.48) 111.3,29.48 110.96,29.48 110.66,29.17 JDIMM2.153 ; JDIMM1.163 113.15,42.17 112.15,43.17 112.02,43.17 111.91,43.28 v2(111.84,43.28) 110.03,43.28 109.15,42.41 JDIMM1.147 ; JDIMM1.153 110.65,42.21 110.93,42.48 111.81,42.48 v2(111.83,42.46) ; v2(98,18.71) 98,18.74 98.41,19.14 JDIMM2.112 ; v2(121.39,29.45) 121.74,29.45 122.16,29.02 JDIMM2.199 ; JDIMM2.135 104.16,29.25 104.46,29.55 v2(104.94,29.55) 105.25,29.55 105.66,29.15 JDIMM2.141 ; JDIMM1.96 94.4,31.78 94.96,31.23 95.64,31.23 v2(95.7,31.3) ; JDIMM1.148 109.4,31.51 v2(109.35,31.46) ; JDIMM1.199 122.15,42.25 122.63,42.73 122.63,43.41 v2(122.08,43.96) ; JDIMM1.111 98.15,42.59 97.78,42.97 97.6,42.97 v2(97.56,43.01) 97.88,43.33 98.86,43.33 99.65,42.54 JDIMM1.117 ; JDIMM1.75 89.15,42.4 89.81,43.06 v2(90.15,43.06) ; v2(132.65,29.58) 132.66,29.57 JDIMM2.241 ; v2(111.3,31.44) 111.21,31.44 110.9,31.74 JDIMM1.154 ; JDIMM1.130 102.9,31.78 102.56,31.44 v2(101.14,31.44) 101.4,31.7 JDIMM1.124 ; v2(111.3,30.83) 111.54,30.83 112.4,31.69 JDIMM1.160 ; v2(102.91,18.73) JDIMM2.130
  BOTTOM w0.33: JDIMM2.154 110.91,18.85 110.76,18.71 v2(110.76,18.67) ; v2(112.63,18.66) 112.74,18.66 112.41,18.99 JDIMM2.160 ; JDIMM2.148 v2(109.41,18.68) ; JDIMM2.142 v2(105.91,18.68)
  BOTTOM w0.508: CD11.1 91.53,15.74 94.4,18.61 94.4,18.65 v2(94.41,18.66) 94.41,18.72 ; RD35.1 97.85,18.59 97.94,18.68 v2(98,18.71) ; v2(81.98,82.39) 81.92,82.39 81.4,82.91 CH197.1
  BOTTOM w1.016: 117.22,7.76 115.4,7.76 114.31,8.85 114.31,11.74 115.02,12.45 115.02,15.18 114.78,15.42
  vias: v2(111.03,18.1) v2(111.47,17.52) v2(111.62,18.1) v2(111.85,18.68) v2(111.9,17.11) v2(112.23,18.23) v2(112.23,17.64) v2(112.56,17.11) v2(112.94,18.1) v2(113.01,17.52) v2(113.37,17.03) v2(113.55,17.97) v2(113.8,17.44) v2(114.13,17.95) v2(114.31,17.08) v2(114.77,17.54) v2(118.12,7.71) v2(118.7,7.71) v2(142.86,32.25) v2(142.86,31.23) v2(143.22,32.76) v2(143.22,31.74) v3(88.2,33.01) v3(93.84,36.41) v3(123.61,32.89)
+1.2V_DDRP: length 20.7
  IN1 w0.254: v2(112.81,11.39) 114.28,9.92 114.28,7.52 113.64,6.87 104.07,6.87 102.35,8.6 101.06,8.6 v2(100.8,8.85)
  BOTTOM w0.254: PR503.1 PC508.1 100.57,8.63 v2(100.8,8.85)
  vias: v3(111.92,12.16)
+1.2V_DTH:
  vias: v2(258.52,41.09) v2(259.13,41.09) v2(259.85,27.3) v2(260.49,27.3) v3(260.43,26.72)
+1.2V_PWROK: length 4.3
  BOTTOM w0.254: PR501.1 96.89,8.73 v1(97.6,9.44) 97.67,9.52 99.49,9.52 99.8,9.83 PU500.18
+1.2V_VCCPLL_OC: length 55.1
  TOP w0.508: RZ67.2 69.24,48.44 CZ49.1 v3(69.17,49.7) 68.08,50.79 68.08,53.46 68.74,54.12 77.12,54.12 88.15,65.14 88.15,69.13 89.27,70.25 89.27,74.29 88.4,75.15 88.4,79.08 87.89,79.59 87.89,80.5 88.16,80.76 88.56,80.76 89.07,81.27 v2(93.1,81.27) ; RH107.1 115.9,80.69 v2(115.98,80.61)
  BOTTOM w0.305: UH1.G11 124.31,80.34 v2(123.98,80.02) ; UH1.BH13 92.91,81.27 v2(93.1,81.27)
+1.05VS_VGA: length 6.2
  TOP w0.508: v2(161.91,80.38) 162.13,80.16 LV7.1 ; LV8.2 164.51,78.23 165.44,79.16 165.44,79.29 v2(165.87,79.72)
  BOTTOM w0.254: v2(155.13,98.97) 155.49,98.61 UV1.AN28 155.63,98.42 156.15,98.42 UV1.AM28 156.29,98.73 156.02,99 v2(155.86,99)
  vias: v2(150.53,103.37) v2(151.14,103.37) v2(154.94,107.41) v2(154.94,106.77) v2(154.94,106.14) v2(158.4,103.09) v2(158.4,102.28) v2(159.14,97.3) v2(159.17,96.48) v2(159.99,96.48) v2(159.99,95.63) v2(160,93.11) v2(160,90.62) v2(160.82,95.63) v2(161.07,95.07) v2(161.09,88.41) v2(161.09,87.78) v2(161.18,93.41) v2(161.17,92.54) v2(161.47,87.14) v2(161.64,90.18) v2(161.7,95.07) v2(161.64,91.52) v2(161.85,87.65) v2(209,43.4) v2(209,42.79) v2(209,42.2) v2(209.2,64.56) v2(209.18,63.97) v2(209.53,43.04) v2(209.53,42.46) v2(209.97,64.33) v2(209.94,63.74) v2(210.07,43.4) v2(210.07,42.79) v2(210.07,42.15) v2(210.14,73.57) v2(210.45,73.07) v2(210.6,64.23) v2(210.55,63.62) v2(210.65,74.11) v2(210.86,73.55) v2(211.16,72.99) v2(211.31,74.03) v3(209.41,73.62)
+1.05VSP: length 9.4
  BOTTOM w0.254: PC810.1 213.56,40.53 213.71,40.39 218.97,40.39 219.47,39.89 PC806.1 219.77,39.89 220.3,39.36 221.62,39.36 PR805.1
  vias: v2(212.16,43.42) v2(212.16,42.79) v2(212.48,43.93) v2(212.8,43.42) v2(212.8,42.79) v2(212.8,42.15) v2(213.12,43.93) v2(213.43,43.42) v2(213.75,43.93) v3(212.16,41.52)
+1.8V_AVDD: length 12.4
  TOP w0.203: 282.61,29.53 282.36,29.28 282.36,29.17 282.35,29.17 282.35,28.27 282.31,28.23 HDA1.40
  TOP w0.381: v3(284.93,31.85) 283.83,30.75 v2(283.83,30.29)
  TOP w0.508: v2(288.17,29.33) 288.41,29.09 CA2.1 288.41,27.73 CA1.1 ; v2(283.83,30.29) 283.65,30.29 283.09,29.73 CA63.2 282.98,29.53 282.61,29.53
  BOTTOM w0.508: v2(288.17,29.33) 287.27,30.23 RA1.1 285.24,30.23 285,30.47 284.01,30.47 v2(283.83,30.29)
+1.8V_DVDD: length 7.5
  TOP w0.127: v1(289.29,30.24) RA3.1
  TOP w0.203: 284.77,28.06 284.36,27.65 HDA1.36
  TOP w0.508: 284.77,28.06 285.28,28.57 CA3.1 285.63,28.82 286.14,29.33 v2(286.9,29.33) 286.98,29.33 RA3.1
  BOTTOM w0.508: RA1.2 286.22,29.33 v2(286.9,29.33)
+1.8VS: length 1.9
  TOP w0.127: RA3.2 287.33,31.64 v1(286.39,30.7)
+1.35VS_VGA: length 158.3
  TOP w0.508: 162.21,107.63 RV95.1 ; v2(165.5,127.29) 165.53,127.25 RV117.2 ; v2(158.3,128.89) 158.3,128.56 CV74.1 ; CV164.1 166.17,131.42 v2(166.3,131.29) ; v2(201.06,98.99) 201.02,99.03 CV395.1 ; v2(202.66,96.59) 202.65,96.58 RV131.2 ; v2(205.86,97.39) 205.77,97.31 CV387.1 ; v2(164.21,102.31) 164.21,102.31 CV203.1 CV194.1 ; CV183.1 208.42,103.64 v2(208.26,103.79) ; v2(207.06,99.94) 207.11,99.89 CV388.1 ; v2(164.7,127.29) 164.6,127.38 CV167.1 ; CV374.1 178.35,90.52 v2(178.45,90.62) ; v2(198.66,96.59) 198.66,96.03 CV400.1 ; CV208.1 199.35,83.77 v2(199.32,83.8) ; CV172.1 200.82,102.75 v2(201.06,102.99) ; v2(200.26,96.59) 200.26,96.3 CV171.1 ; v2(156.7,120.09) 156.69,120.08 CV207.1 ; CV179.2 201.1,84.64 v2(201.06,84.68) ; v2(205.09,78.27) 205.65,78.27
  IN3 w0.508: v2(184.82,126.51) 184.82,127.02 185.2,127.4 v2(186.52,127.4)
  BOTTOM w0.254: v2(198.66,79.11) 198.66,79.08 UV8.B12 ; UV8.N5 v2(207.06,83.71) ; v2(206.66,97.39) UV9.F3 v2(205.86,98.19) UV9.G4 ; UV9.P1 v2(200.26,96.59) ; UV1.AB33 164.61,102.71 v2(164.21,102.31) ; UV6.T14 v2(186.6,130.89) ; UV6.C5 v2(178.39,120.08) ; 202.65,79.09 UV8.G11 ; 202.65,79.09 v2(202.65,79.11) ; 202.65,79.09 UV8.H12 ; UV7.N10 v2(159.9,122.49) ; UV8.G14 v2(201.86,77.48) UV8.F14 ; UV9.B3 v2(209.06,97.39) ; UV7.N5 v2(163.9,122.49) ; UV9.B14 v2(209.06,106.99) ; UV7.C5 v2(163.9,129.69) ; UV9.R10 v2(199.46,103.79) ; UV9.N5 v2(201.06,98.99) ; UV9.B1 v2(209.86,96.59) ; v2(159.9,128.88) 159.5,128.49 UV7.E10 159.34,128.49 158.94,128.09 158.5,128.09 158.1,127.69 UV7.F12 ; UV6.P12 v2(184,128.89) UV6.P11 ; v2(208.26,98.21) 208.26,98.18 207.88,97.79 UV9.D3 ; v2(206.18,107.51) 206.26,107.43 UV9.F14 ; UV7.F14 v2(156.71,127.28) 156.68,127.28 UV7.G14 ; UV8.D14 v2(199.46,77.48) ; v2(169.53,103.24) 169.53,102.82 UV1.T33 ; UV8.B14 v2(197.87,77.47) ; UV7.H3 v2(165.5,126.49) UV7.G2 ; UV9.M3 v2(201.86,97.39) ; 201.86,78.28 v2(201.86,78.25) ; 201.86,78.28 UV8.F12 ; 201.86,78.28 UV8.G13 ; UV7.T1 v2(166.3,120.09) ; UV8.R5 v2(209.06,84.68) ; UV1.B19 182.37,91.06 v2(182.66,90.77) ; UV6.D3 v2(177.6,120.89) ; UV8.L4 v2(205.86,84.68) ; UV6.B14 186,119.74 v2(186.35,120.09) 186.44,120.18 186.44,120.85 UV6.D14 ; v2(175.04,130.79) 175.15,130.89 UV6.T1 ; v2(201.86,87.08) UV8.G1 ; v2(201.86,87.08) UV8.G2 ; v2(201.86,87.08) UV8.F1 ; UV8.D1 v2(200.26,87.88) ; UV9.D12 v2(208.26,104.59) UV9.D11 ; UV7.B3 v2(165.5,130.49) ; UV7.K12 v2(157.5,124.09) UV7.L13 ; UV8.L11 v2(205.06,79.88) ; UV8.P12 v2(208.26,79.08) UV8.P11 ; v2(163.1,120.11) 163.12,120.11 UV7.R5 ; UV7.L14 v2(156.7,123.29) UV7.M14 ; v2(182.35,85.94) 182.32,85.94 182.21,86.06 UV1.B13 ; UV6.T3 v2(177.6,131.29) ; UV9.D1 v2(208.26,95.79) ; UV8.M12 v2(206.66,79.08) ; UV9.G2 205.53,96.92 205.53,96.27 UV9.G1 ; UV9.G2 v2(205.86,97.39) ; UV9.G2 v2(205.06,97.39) UV9.H3 ; UV9.H12 v2(205.06,105.39) UV9.G13 UV9.G14 ; UV7.P14 v2(156.7,121.69) ; UV8.B1 v2(198.66,87.88) ; v2(176.06,127.29) 176.06,127.23 UV6.L2 ; UV8.G4 v2(202.66,85.48) UV8.H3 ; UV6.L4 v2(177.63,126.51) ; UV7.G2 166,126.99 166.6,126.99 UV7.G1 ; UV7.G2 v2(165.5,127.29) ; UV7.H12 v2(157.5,126.49) UV7.G13 ; UV7.D11 v2(158.3,128.89) UV7.D12 ; UV8.P14 v2(207.86,76.53) ; v2(209.62,76.56) 209.62,76.92 UV8.T14 ; UV7.D3 v2(164.7,128.89) ; UV7.D14 v2(156.7,129.69) ; v2(206.07,88.04) 206.26,87.85 UV8.M1 ; UV6.B1 175.97,119.32 v2(176.01,119.32) ; UV8.K3 v2(204.26,86.28) ; v2(176,123.29) UV6.F1 ; v2(176,123.29) UV6.G1 ; v2(176,123.29) UV6.G2 ; v2(175.05,127.71) 175.08,127.69 UV6.M1 175.57,127.66 175.57,126.91 UV6.L1 ; UV9.P11 v2(200.26,104.59) UV9.P12 ; UV6.F12 v2(184.8,123.29) UV6.G13 ; UV7.K3 UV7.L4 v2(163.9,124.09) ; UV9.M12 v2(201.86,104.59) UV9.L11 ; UV6.D11 v2(184,121.69) UV6.D12 ; UV8.D11 200.24,79.1 200.24,79.09 ; UV6.G11 v2(184,124.09) UV6.H12 ; UV7.P1 v2(166.3,121.69) ; UV7.L2 v2(166.3,124.09) UV7.L1 166.79,123.6 166.79,122.98 UV7.M1 ; UV6.R5 v2(178.4,130.49) ; UV6.P14 v2(185.62,129.67) ; v2(206.08,95.65) 206.08,95.69 206.26,95.87 UV9.F1 ; UV8.R10 v2(209.06,79.88) ; v2(186.52,127.4) 186.52,127.43 186.27,127.69 UV6.M14 ; UV6.G14 v2(185.6,123.29) UV6.F14 ; UV8.P3 v2(208.26,85.48) ; v2(209.26,88.02) 209.33,87.95 209.33,87.61 UV8.T1 ; UV6.K12 v2(184.82,126.51) 184.84,126.51 185.2,126.87 UV6.L13 185.28,126.96 185.76,126.96 185.84,126.89 UV6.L14 ; UV8.D3 v2(199.46,85.48) ; UV7.T3 v2(164.7,120.09) ; 205.09,78.25 UV8.L13 205.54,77.8 205.54,77.15 UV8.L14 ; 205.09,78.25 UV8.K12 ; 205.09,78.25 v2(205.09,78.27) ; UV9.P3 v2(200.26,98.19) ; UV7.F1 166.57,127.69 166.17,128.09 v2(165.5,128.09) UV7.F3 v2(164.7,127.29) UV7.G4 ; UV9.C5 v2(208.26,98.99) ; 200.24,79.09 v2(200.25,79.09) ; 200.24,79.09 200.24,79.06 UV8.D12 ; UV9.K3 v2(202.66,98.19) UV9.L4 ; UV6.L11 v2(183.2,126.49) ; UV7.E5 163.03,128.49 163,128.46 v2(162.95,128.46) ; UV7.R10 v2(159.1,120.89) ; UV8.C10 v2(198.66,79.88) ; UV9.T12 v2(198.66,104.59) ; UV9.M1 201.51,96.14 202.21,96.14 UV9.L1 v2(202.66,96.59) UV9.L2 ; UV8.P1 v2(208.26,87.08) ; UV9.B12 v2(209.86,104.59) ; v2(182.4,128.89) UV6.N10 182.94,128.49 183.34,128.09 183.85,128.09 184.25,127.69 UV6.M12 ; UV7.T12 v2(158.3,120.09) ; UV9.C10 v2(208.26,103.79) ; UV9.K12 v2(202.66,105.39) UV9.L13 ; UV9.F12 206.26,104.96 v2(206.66,104.56) 206.66,103.95 207.06,103.55 UV9.E10 ; UV7.M3 v2(165.5,123.29) ; UV9.T14 v2(198.66,106.19) ; UV8.F3 v2(201.06,86.28) ; UV7.B12 v2(158.3,130.49) ; UV9.G11 v2(205.06,103.79) ; UV6.K3 v2(176.8,125.69) ; UV6.R10 v2(183.2,130.49) ; UV6.B12 v2(184,120.09) ; UV8.L1 v2(205.46,88.05) ; UV8.E10 v2(201.03,79.9) ; UV9.M14 v2(201.86,106.19) UV9.L14 ; UV6.P3 v2(177.6,129.69) ; UV9.E5 v2(207.06,99.94) ; UV9.T3 v2(198.66,98.19) ; UV7.P11 v2(158.3,121.69) UV7.P12 ; UV8.B3 v2(198.66,86.28) ; UV6.F3 v2(176.8,122.49) ; UV7.D1 v2(167.1,129.69) ; v2(176.03,121.69) 176.02,121.68 175.99,121.68 UV6.D1 ; UV7.B14 v2(156.68,131.25) ; UV8.L2 v2(205.06,86.28) ; UV8.M3 v2(206.66,86.28) ; UV6.B3 v2(176.8,120.09) ; UV7.B1 v2(166.3,131.29) ; UV8.E5 v2(201.06,84.68) ; UV6.P1 v2(176,129.69) ; UV7.T14 v2(156.7,120.09) ; UV6.E5 v2(178.4,122.49) ; UV6.G4 v2(177.6,124.09) UV6.H3 ; UV6.E10 v2(183.2,122.49) ; UV8.T12 v2(209.86,79.08) ; UV9.N10 v2(201.06,102.99) ; UV8.M14 v2(206.26,76.54) ; UV9.R5 v2(198.66,99.79) ; UV7.P3 v2(164.7,121.69) ; UV8.C5 199.06,84.06 v2(199.32,83.8) ; UV6.N5 v2(178.4,128.89) ; UV6.T12 v2(184,130.49) ; UV7.G11 v2(159.1,126.49) ; UV6.C10 v2(183.2,120.09) ; UV7.C10 v2(159.1,129.69) ; UV6.M3 v2(176.8,128.09) ; UV9.D14 v2(208.26,106.19) ; UV8.N10 v2(207.46,79.88) ; UV9.P14 v2(200.26,106.19) ; UV9.T1 v2(198.66,96.59)
  BOTTOM w0.3: UV1.B16 181.38,88.47 182.4,88.47 v2(182.67,88.19)
  BOTTOM w0.305: UV7.M12 157.95,122.89 v2(158.3,123.23) 158.7,123.63 UV7.L11 ; 170.09,97.4 v2(170.06,97.4) ; v2(170.06,97.4) 170.47,97.81 UV1.R27 ; v2(170.06,97.4) 169.66,97.81 UV1.T27 ; v2(178.46,88.13) 178.89,88.56 UV1.E16 ; UV1.N27 172.08,97.81 v2(171.68,97.4) 171.29,97.79 UV1.P27 ; UV1.E19 178.89,91.06 v2(178.45,90.62) ; v2(178.49,86.45) 178.88,86.06 UV1.E13 ; UV1.W30 167.2,100.31 167.55,99.96 v2(167.56,99.96) ; UV1.W33 167.26,102.82 167.26,104.28 v2(167.28,104.26) ; UV1.T30 169.64,100.3 169.64,100.25 v2(170.06,99.84) ; UV8.T3 209.46,85.83 v2(209.81,85.48) ; UV1.AA30 v2(165.06,99.88)
  vias: v2(162.6,97.37) v2(164.21,97.37) v2(165.09,97.38) v2(166.71,97.38) v2(166.94,96.75) v2(172.48,97.3) v2(175.73,83.18) v2(175.91,94.83) v2(175.99,93.12) v2(176.02,91.48) v2(175.99,90.61) v2(175.97,88.11) v2(175.97,85.57) v2(176.02,82.21) v3(165.08,112.94)
+1.35VS_VGAP: length 12.5
  IN1 w0.508: v2(149.36,111.5) 148.47,110.61 142.12,110.61 140.6,109.08 v2(138.57,109.08)
  BOTTOM w0.508: PR906.2 v2(138.57,109.08)
  vias: v2(148.09,117.85) v2(148.73,117.85) v2(148.73,117.21) v2(148.73,116.58) v2(149.36,117.85) v2(149.36,117.21) v2(149.36,116.58) v2(149.36,114.04) v2(149.36,113.4) v2(149.36,112.77) v2(149.36,112.13) v2(150,117.85) v2(150,117.21) v2(150,116.58) v2(150,115.94) v2(150,114.67) v2(150,114.04) v2(150,113.4) v2(150,112.77) v2(150,112.13) v2(150,111.5) v3(147.48,118.71)
+1.35VS_VGAP_B+:
  vias: v2(140.7,116.97) v2(141.16,121.42) v2(141.23,117.36) v2(141.28,120.51) v2(141.28,119.91) v2(141.26,119.29) v2(141.32,118.36) v2(141.63,117.84) v2(141.68,118.86) v3(141.84,122.19)
+1V_MPHY: length 3.3
  BOTTOM w0.127: UH2.V28 v2(165.29,34.74)
  BOTTOM w0.152: UH2.U26 v2(166.06,35.51) ; UH2.U21 v2(168.39,35.51) ; UH2.V26 v2(166.06,34.74) ; UH2.U23 v2(167.61,35.51) ; v2(166.84,35.51) UH2.U25
  vias: v2(145.7,33.7) v2(145.68,32.9) v2(146.14,33.29) v2(146.62,32.9) v2(146.72,33.52) v2(151.08,37.9) v2(151.71,37.9) v2(152.35,37.9) v2(152.98,37.9) v3(146.16,31.87)
+1V_MPHY_MPHYPLL:
  vias: v2(156.35,42.79) v2(158.17,44.09) v3(157.67,43.45)
+1V_PCH: length 5
  BOTTOM w0.152: v2(171.36,37.4) 171.36,37.56 171.09,37.83 UH2.N17 ; UH2.R17 170.48,36.61 v2(170.25,36.84) ; UH2.V17 v2(170.71,34.74) ; UH2.AD15 v2(172.26,31.57) ; v2(170.7,32.47) UH2.AC17 ; v2(169.2,36.85) 169.44,36.61 UH2.R19 ; UH2.U20 v2(169.16,35.51)
  BOTTOM w0.203: v2(169.17,28.84) 169.02,28.99 UH2.AL22
+1V_PCH_AZPLL: length 5.7
  TOP w0.381: LH2.2 178.36,27.68 178.3,27.74 176.9,27.74 176.76,27.6 175.73,27.6 175.38,27.95 174.02,27.95
  BOTTOM w0.152: v2(170.24,28.03) 170.13,28.03 UH2.AN19
  vias: v1(172.07,27.9)
+1V_PCH_CLK5:
  vias: v1(180.3,39.16)
+1V_PCH_PRIM: length 8.8
  BOTTOM w0.152: UH2.AC26 v2(166.84,33.19) ; UH2.AA26 166.52,33.65 v2(166.84,33.96) UH2.Y25 ; UH2.AJ25 v2(167.61,30.09) UH2.AJ23 v2(168.39,30.09) UH2.AJ21 v2(169.16,30.09) UH2.AJ20 ; UH2.AA28 v2(166.06,33.19) ; UH2.AC23 v2(167.61,32.41) UH2.AE23 ; UH2.Y23 v2(167.61,33.96) 167.93,33.65 UH2.AA23 ; UH2.AC28 v2(166.06,32.41) ; UH2.AE26 v2(166.84,32.41)
  vias: v3(167.15,31.49)
+1V_PCH_USBPLL: length 5.9
  TOP w0.102: v2(176.29,28.18) 175.66,28.18 175.4,28.45 174.19,28.45 v1(174.13,28.51)
  TOP w0.508: v2(176.29,28.18) 176.29,28.76 CH202.1 176.98,28.69 CH201.1 178.83,28.69 RH123.2
+1V_VCCDSW: length 7.4
  TOP w0.127: v1(168.59,28.31) 168.26,27.98 RH196.2
  TOP w0.381: RH196.2 167.04,27.5 166.6,27.5 166.25,27.14 166.25,25.61 166.19,25.61 165.26,24.68 CH176.1 165.11,24.63 164.7,24.22 v2(164.47,24.22)
  BOTTOM w0.254: UH2.BA29 164.52,24.23 v2(164.47,24.22)
+1VALW: length 32.4
  TOP w0.508: LH2.1 179.94,27.5 180.5,27.5 v2(180.53,27.47) 180.53,27.5 180.58,27.55 180.58,28.59 RH123.1
  IN3 w0.508: v2(237.78,30.42) 237.78,30.03 238.03,29.77 240.17,29.77 v2(241.03,30.64) ; v2(242.02,19.55) 241.25,18.78 240.16,18.78 239.56,18.18 239.01,18.18 238.38,17.54 237.43,17.54 235.38,15.5 233.58,15.5 233.13,15.05 v2(233.13,14.8)
  BOTTOM w0.508: RH122.1 185.81,39.8 v2(185.81,39.79) ; v2(242.02,19.55) 243.67,21.2 243.67,23.84 243.1,24.41 243.1,26.15 242.75,26.5 242.26,26.5 241.31,27.45 241.31,30.35 241.13,30.53 241.13,30.53 v2(241.03,30.64) ; RE116.2 237.83,29.76 237.78,29.81 v2(237.78,30.42)
  vias: v2(133.09,98.35) v2(133.09,97.74) v2(133.67,98.36) v2(133.67,97.75) v2(140.27,40.54) v2(140.4,41.11) v2(140.83,40.71) v2(140.74,40.13) v2(146.82,35.42) v2(147.14,34.92) v2(147.46,35.42) v2(148.05,35.42) v2(148.6,35.93) v2(159.55,44.74) v2(159.62,44.14) v2(170.55,41.27) v2(171.49,41.09) v2(171.46,40.5) v2(171.46,39.87) v2(172.53,40.53) v2(172.5,39.74) v2(173.3,39.69) v2(175.65,42.36) v2(177.76,38.5) v2(178.88,38.12) v2(179.21,37.58) v2(179.3,38.53) v2(179.73,38.13) v2(179.79,37.53) v2(180.38,37.43) v2(231.53,14.26) v2(231.81,13.73) v2(231.89,14.8) v2(232.14,14.24) v2(232.42,13.71) v2(232.47,14.82) v2(232.75,14.24) v2(233.05,13.71) v2(233.36,14.21) v3(181.09,43.09)
+1VALWP: length 15
  TOP w0.254: PR602.1 PC606.1 250.73,11.22 250.35,11.6 247.84,11.6 246.77,10.53 239.56,10.53 238.95,11.14 238.95,12.44 238.92,12.46
  vias: v2(235.98,14.82) v2(235.98,14.19) v2(235.98,13.6) v2(236.61,14.21) v2(236.61,13.58) v2(237.25,14.21) v2(237.25,13.58) v2(237.91,14.8) v2(237.91,14.16) v2(237.91,13.58) v3(239.23,12.84)
+2.5V_MEM: length 12.2
  TOP w1.016: 142.31,27.93 142.31,29.2 144.28,31.17 144.28,33.96 140.47,37.77
  vias: v2(138.32,41.82) v2(138.9,41.8) v2(138.85,26.66) v2(139.48,26.66) v2(142.08,27.16) v2(142.38,26.6) v2(142.69,27.1) v3(141.06,27.73)
+2.5VSP_ON: length 4.8
  BOTTOM w0.102: v1(147.46,16.87) 147.58,17 147.58,17.58 147.37,17.8 147.03,17.8 PR1801.2
  BOTTOM w0.254: PR1801.2 PC1800.1 145.68,17.71 146.23,18.25 PU1800.2
+3.3V_GFX_AON: length 193.8
  TOP w0.203: CV214.1 175.37,81.62 175.37,79.46 v2(175.9,78.92)
  TOP w0.381: UV18.5 155.6,74.05 155.41,73.85 155.41,73.6 v2(154.98,73.17)
  TOP w0.508: RV149.2 RV147.2 RV148.2 v2(187.33,72.61) ; RV57.2 150.17,81.85 149.58,81.27 149.5,81.27 149.15,80.92 v2(149.15,80.89) ; v2(175.05,82.48) 175.17,82.36 CV214.1 ; v2(158.86,71.92) 165.57,71.92 166.09,71.4 170.08,71.4 170.48,71 172.61,71 173.01,71.4 v3(173.57,71.4) 174.29,71.4 174.63,71.75 RV55.2 174.63,72.77 RV60.1 174.94,73.65 v2(175.35,73.24) ; v2(183.52,72.76) RV146.2 RV150.2 ; v2(175.9,78.92) 176.01,78.82 CV213.1
  IN1 w0.381: v2(175.35,73.24) 175.9,73.8 176.82,73.8 176.97,73.95 176.97,75.53 175.9,76.6 v2(175.9,78.92)
  IN1 w0.508: v2(154.98,73.17) 155.46,72.68 157.69,72.68 158.46,71.92 v2(158.86,71.92) ; 176.82,73.8 176.84,73.78 179.64,73.78 181.54,71.87 182.63,71.87 v2(183.52,72.76) ; v2(149.15,80.89) 149.15,82.76 146.95,84.95 146.19,84.95 145.81,84.57 v2(145.81,84.19)
  IN2 w0.254: v2(204.33,52.64) 204.28,52.7 204.28,53.69 206.51,55.92 206.51,71.67 205.88,72.3 204.02,72.3 203.59,72.74 190.87,72.74 190.26,72.13 189.72,72.13 189.24,72.61 v2(187.33,72.61)
  IN2 w0.508: v2(187.33,72.61) 187.33,72.89 186.82,73.4 184.15,73.4 v2(183.52,72.76)
  IN3 w0.508: v2(149.15,80.89) 148.36,80.1 148.36,78.21 147.96,77.82 v2(147.96,76.88) 148.46,76.38 v2(149.74,76.38) 150.52,76.38 152.39,74.51 153.02,74.51 154.37,73.17 v2(154.98,73.17)
  BOTTOM w0.254: v2(158.86,71.92) RV192.2 ; v2(204.33,52.64) 204.07,52.9 191.7,52.9 187.61,56.99 187.61,59.15 185.81,60.95 178.47,60.95 177.81,60.29 PR1001.1 ; v2(175.35,73.24) 174.97,73.24 174.43,72.71 174.43,71.87 173.95,71.39 173.27,71.39 171.88,72.77 RV526.2
  BOTTOM w0.305: UV1.J8 175.49,82.05 v2(175.05,82.48) 174.64,82.07 UV1.K8 ; UV1.AH12 159.59,85.15 v2(159.99,84.75) 160.39,85.16 UV1.AG12 160.57,85.21 160.92,84.86 v2(160.92,84.95)
  BOTTOM w0.356: UV11.5 146.07,84.71 145.81,84.45 v2(145.81,84.19)
  BOTTOM w0.381: RV191.2 159.6,74.23 159.5,74.34 ; RV42.2 162.34,72.71 161.76,73.29 161.76,73.88 161.3,74.34 159.5,74.34 ; RV41.2 150.37,75.61 RV34.2 150.29,75.83 v2(149.74,76.38) ; 159.5,74.34 156.14,74.34 v2(154.98,73.17)
  BOTTOM w0.457: 161.59,83.68 161.59,84.87 161.5,84.95 v2(160.92,84.95)
  BOTTOM w0.508: v2(147.96,76.88) 148.47,76.37 RV532.2 ; 161.59,83.68 162.43,82.85 162.88,82.85 163.1,82.62 171.62,82.62 171.63,82.6 172.49,82.6 172.98,83.1 174.39,83.1 174.41,83.12 v2(175.05,82.48) ; v2(153.78,80.48) 153.71,80.56 151.39,80.56 150.69,81.26 149.52,81.26 v2(149.15,80.89) 149.02,80.76 148.6,80.76 148.01,80.17 RV39.1
+3.3V_GFX_RUN: length 140.8
  TOP w0.102: RV159.2 v3(191.27,73.45)
  TOP w0.508: RV157.2 RV158.2 v2(186.44,72.63) ; RV159.2 v2(189.99,72.81)
  IN2 w0.508: v2(230.31,41.9) 230.31,41.44 229.91,41.04 220.45,41.04 219.87,40.45 208.37,40.45 205.83,42.99 v2(205.83,53.46) 205.83,54.32 207.02,55.51 207.02,72.18 205.7,73.5 190.68,73.5 v2(189.99,72.81)
  IN3 w0.508: v2(189.99,72.81) 189.57,73.23 186.97,73.23 186.44,72.7 v2(186.44,72.63) 185.42,73.65 180.44,73.65 180.34,73.75 175.72,73.75 175.29,74.18 174.18,74.18 172.73,75.63 v2(172.56,75.63)
  BOTTOM w0.254: PR1007.2 175.04,59.98 175.04,60.71 175.89,61.56 186.06,61.56 188.22,59.4 188.22,57.24 191.86,53.61 205.67,53.61 v2(205.83,53.46)
  BOTTOM w0.305: UV1.L8 173.79,81.81 v2(173.39,81.42) 173,81.81 UV1.M8
  BOTTOM w0.508: v2(230.31,41.9) 230.31,39.78 227.61,37.07 PR804.1
+3.3VDX_SSD: length 4.1
  TOP w0.254: v3(216.88,35.14) 216.41,35.61 216.41,35.95 v2(216.75,36.29) 217.09,35.95 v3(218.4,35.95) ; v2(217.74,30.24) 218.07,30.57 v3(218.07,30.98)
+3V_DVDD: length 10.3
  TOP w0.203: HDA1.1 277.72,26.95 277.49,27.18 ; HDA1.9 277.24,23.76 277.22,23.74 276.38,23.74 275.88,23.23 275.88,22.94
  TOP w0.508: v2(276.31,29.4) 275.73,29.4 275.5,29.17 RA23.1 275.47,28.67 275.47,27.6 CA26.1 275.7,27.55 276.07,27.18 276.23,27.18 276.24,27.19 276.68,27.19 276.7,27.18 277.49,27.18
  BOTTOM w0.508: v2(276.31,29.4) 276.15,29.24 276.15,28.52 276.49,28.18 RA70.2
  vias: v1(276.97,22.19) v2(277.33,21.15) v2(277.76,21.61)
+3V_PCH_AZIO: length 4.8
  TOP w0.127: CH200.1 171.99,25.19 172.38,25.58 172.75,25.58 172.92,25.74 172.92,25.75 v1(173.16,25.99)
  TOP w0.381: CH200.1 171.97,25.12 v2(171.49,24.64) 171.5,24.64 172.22,23.92 LH1.2
  BOTTOM w0.203: UH2.BA15 172.1,24.14 171.74,24.5 171.61,24.5 171.49,24.63 v2(171.49,24.64)
+3V_PCH_DSW: length 33.8
  TOP w0.254: v2(172.35,18.02) 172.33,18.02 171.85,17.54 171.85,14.97 172,14.82 v2(172,14.75)
  TOP w0.508: CH82.1 172.22,34.27 v2(171.96,34) ; v2(169.48,14.94) 168.58,14.94 168.09,15.42 168.09,15.87 167.95,16.01 167,16.01 166.48,16.53 166.48,17.39 166.35,17.52 166.35,19.55 166.61,19.8 166.61,21.33 v1(166.79,21.5) 166.79,22.04 166.97,22.22 v2(166.97,23.02)
  IN2 w0.508: v2(171.96,34) 171.96,34 171.96,32.13 171.65,31.83 171.65,30.03 171.1,29.48 168.26,29.48 167.42,28.64 167.42,25.67 167.4,25.64 167.4,23.45 v2(166.97,23.02)
  BOTTOM w0.127: UH2.BA24 167.23,23.76 167.23,23.28 v2(166.97,23.02)
  BOTTOM w0.203: UH2.W15 171.81,34.17 171.96,34.01 v2(171.96,34)
  BOTTOM w0.254: RH125.2 172.32,18.68 172.32,18.05 v2(172.35,18.02)
  BOTTOM w0.508: RH181.2 172,15.31 v2(172,14.75) ; RH81.2 170.9,15.23 RH17.2
+3V_PCH_SPI:
  vias: v1(153.88,21.88)
+3V_ROM: length 17.6
  IN3 w0.254: v2(160.54,15.99) 161.78,15.99 161.96,16.17 163.64,16.17 164.32,15.48 167.01,15.48 169.86,12.64 v2(170.88,12.64)
  BOTTOM w0.254: RH74.1 160.08,15.15 160.54,15.61 v2(160.54,15.99) ; UH8.8 172.91,11.55 172.21,12.25 RH121.1 171.27,12.25 v2(170.88,12.64)
+3VALW: length 496.5
  TOP w0.254: v2(240.57,21.99) 240.6,22.01 240.6,22.61 ; RPE5.3 225.1,11.53 v2(225.38,11.24) 225.6,11.46 RPE5.4 ; RPE7.3 240.8,23.61 ; 240.8,23.61 240.8,23.11 ; 240.8,23.61 240.8,23.92 240.61,24.11 RPE7.4 ; RT1.1 108.98,83.4 v2(108.9,83.33) ; RPE7.2 240.8,23.11 ; 240.8,23.11 240.8,22.81 240.6,22.61 ; 240.6,22.61 RPE7.1 ; RPE5.1 224.1,11.46 v2(224.32,11.24) 224.6,11.53 RPE5.2
  TOP w0.305: JAPS.3 174.18,11.09 174.48,10.79 175.96,10.79 v2(175.98,10.76) 176.18,10.96 JAPS.7 ; RH21.1 148.52,21.2 149.03,20.69 151.62,20.69 v2(151.75,20.82) ; 10.96,36.01 10.71,36.25 JIO1.28 ; v2(172.87,12.63) 172.96,12.53 172.96,12.25 173.18,12.04 JAPS.1 ; RI10.1 277.78,33.98 278.17,33.59 281.19,33.59 282.05,32.73 RI9.1 ; RH23.1 158.76,24.34 158.76,25.59 RH25.1
  TOP w0.381: CH186.1 170.77,24.32 v2(170.29,23.84) 170.29,23.43 170.77,22.95 RH126.2 170.83,22.41 171.6,22.41 171.87,22.68 LH1.1 ; RZ12.1 205.8,71.29 v2(205.88,71.21) ; UZ21.5 185.16,21.69 184.26,20.79 184.03,20.79 v2(184.01,20.82) ; RH137.1 169.81,16.18 169.81,17.24 v2(169.96,17.39) 169.68,17.67 RH67.2 ; RH92.1 164.86,18.2 RH82.1 165.67,18.02 v2(165.67,17.5) ; v2(159.37,29.38) 158.84,28.85 CH191.1 ; v2(222.36,23.99) 222.36,23.97 222.5,23.83 v2(222.5,20.31) ; UC16.5 131.9,75.67 CC298.1
  TOP w0.457: RZ32.2 140.3,16.43 139.39,16.43
  TOP w0.508: v2(151.89,28.46) 151.89,28.63 150.24,30.28 150.24,32.18 150.49,32.43 150.49,33.75 151.03,34.28 151.91,34.28 151.99,34.2 v2(153.14,34.2) RH135.2 RH68.2 RH110.2 153.83,31.58 RH131.2 ; RZ33.1 138.19,13.97 v2(138.19,14.47) 138.19,15.87 138.75,16.43 UE4.5 139.39,16.43 ; v2(13.45,34.92) 13.83,34.92 14.01,35.09 CZ105.1 13.88,35.6 11.36,35.6 10.96,36.01 ; v2(163.26,29.4) 163.73,29.4 RH130.1 RH65.1 ; RE39.2 216.49,29.73 v2(216.84,30.08) ; 153.52,14.49 153.52,19.05 v2(151.75,20.82) ; RH66.1 RH63.1 155.33,20.31 v2(155.08,20.06) ; RH64.1 159.61,24.29 RH23.1 158.71,23.79 158.69,23.77 158.69,23.5 v2(158.22,23.03) ; v2(34.3,33.39) 33.97,33.72 33.97,34.48 35.24,35.75 35.42,35.93 35.42,38.12 34.93,38.6 v2(34.93,39.11) ; v2(155.15,23.1) 154.77,22.72 RH22.1 ; v2(145.29,75.5) 144.9,75.11 143.25,75.11 142.96,74.82 137.46,74.82 v2(136.51,73.87) 134.74,73.87 133.64,74.97 131.94,74.97 131.66,75.25 CC298.1 ; RE113.2 230.72,35.7 v2(230.72,36.15) ; PR101.1 15.81,25.47 v2(16.39,24.88) ; CH189.1 176.22,27.03 v2(176.49,27.03) ; CH190.1 159,32.17 v2(159.42,31.74) ; v2(70.44,64.07) PC713.1 ; v2(242.43,25.82) 242.37,25.77 RE25.1 ; v2(156.67,22.97) 156.65,22.99 CH192.1 ; RE12.1 241.13,20.06 v2(241.39,19.8) ; v2(48.8,41.87) 50.7,43.77 53.01,43.77 54.73,42.05 62.06,42.05 62.45,41.66 v2(63.75,41.66) ; PR800.2 v2(231.73,42.28) ; v2(221.7,41.8) 220.69,42.81 218.78,42.81 217.84,41.87 217.84,41.01 216.95,40.12 211.66,40.12 211.15,40.63 211.15,44.73 209.81,46.07 209.81,55.08 212.4,57.67 212.4,61.05 211.5,61.96 208.81,61.96 v2(208.35,61.5) ; v2(280.5,17.26) 280.68,17.44 RA17.2 ; PR707.1 v2(65.47,62.47)
  IN1 w0.508: v2(63.75,41.66) 63.75,38.58 63.69,38.52 ; v2(205.88,71.21) 207.15,69.94 207.15,63.08 208.35,61.87 v2(208.35,61.5) ; v2(150.35,23.26) 149.43,24.18 148.32,24.18 145.01,27.5 143.7,27.5 141.93,29.26 141.93,33.96 142.45,34.48 142.45,39.99 139.84,42.61 v2(138.59,42.61)
  IN2 w0.254: v2(132.65,82.79) 132.67,82.77 132.67,82.07 134.25,80.49 134.25,78.6 134.76,78.1 134.76,76.06 133.74,75.05 133.74,70.32 137.65,66.41 137.65,54.67 137.09,54.11 137.09,51.4 137.86,50.64 137.86,43.91 138.59,43.17 v2(138.59,42.61)
  IN2 w0.381: v2(222.36,23.99) 222.39,23.99 226.15,27.75 v2(226.15,28.13)
  IN2 w0.508: v2(13.45,34.92) 14.23,34.13 ; 14.23,34.13 19.11,34.13 20.71,32.53 24.11,32.53 27.77,36.19 27.77,38.37 28.51,39.11 v2(34.93,39.11) 34.93,38.47 35.42,37.99 38.77,37.99 39.13,37.63 43.57,37.63 43.57,37.63 43.74,37.63 45.35,39.25 46.67,39.25 47.37,39.94 47.37,41.13 48.12,41.87 v2(48.8,41.87) ; 14.23,34.13 14.23,27.04 v2(16.39,24.88) 16.47,24.81 16.47,21.05 20.16,17.35 24.79,17.35 26.65,15.48 v2(26.65,15) ; v2(216.84,30.08) 216.96,29.97 217.23,29.69 217.23,29.57 217.22,29.56 217.22,26.77 v2(216.82,26.38) ; v2(169.96,17.39) 169.12,17.39 168.71,17.8 165.96,17.8 v2(165.67,17.5) 164.99,17.5 163.98,18.51 160.03,18.51 157.34,21.2 156.54,21.2 155.15,22.58 v2(155.15,23.1) ; 260.06,14.82 260.11,14.77 261.96,14.77 263.38,16.2 279.18,16.2 280.27,17.29 280.48,17.29 v2(280.5,17.26)
  IN3 w0.254: v2(108.9,83.33) 108.93,83.35 108.93,83.68 109.56,84.32 119.59,84.32 119.85,84.57 122.62,84.57 123.89,83.3 123.89,82.36 124.39,81.85 125.49,81.85 125.92,82.29 127.19,82.29 128.28,83.38 132.06,83.38 v2(132.65,82.79)
  IN3 w0.508: v2(172.87,12.63) 172.81,12.57 172.81,12.23 173.34,11.7 174.66,11.7 175.6,10.76 v2(175.98,10.76) ; v2(138.59,42.61) 139.46,43.47 139.46,65.78 135.89,69.35 135.89,73.25 v2(136.51,73.87) ; v2(63.75,41.66) 63.32,41.66 62.77,42.2 62.77,45.19 63.95,46.37 63.95,60.96 v2(65.47,62.47)
  BOTTOM w0.203: RE28.2 226.07,28.21 v2(226.15,28.13) ; v2(163.31,24.32) 163.66,23.96 UH2.BA31 ; UH2.AN5 176.49,27.34 v2(176.49,27.03)
  BOTTOM w0.254: UH2.BC42 159.42,22.64 UH2.BD40 ; 230.06,30.37 230.06,30.47 229.77,30.76 RPE3.8 ; 230.06,30.37 230.26,30.57 230.26,31.16 RPE3.7 ; 230.06,30.37 v2(230.06,30.34) ; v2(230.95,30.34) 230.95,30.42 ; 230.95,30.42 230.76,30.6 RPE3.6 ; 230.95,30.42 230.95,30.6 231.15,30.8 231.15,30.82 231.26,30.94 RPE3.5 ; UH2.AD41 159.06,32.01 159.32,31.76 v2(159.42,31.74) ; UH2.BA20 170.22,23.91 v2(170.29,23.84) ; v2(102.6,9.29) 102.5,9.29 102.05,9.74 PU500.13
  BOTTOM w0.381: RE38.1 232.24,23.87 v2(231.98,24.12) ; v2(151.4,26.53) 151.52,26.4 QH5.5 ; RH128.2 170.52,17.95 v2(169.96,17.39) ; RH62.1 152.42,25.01 v2(152.38,24.97) ; v2(145.29,75.5) CV212.1 145.23,76.3 UV14.5 ; RE34.1 v2(222.5,20.31)
  BOTTOM w0.508: v2(102.6,9.29) 102.7,9.29 103.29,8.7 PC506.1 ; PR112.2 26.25,14.54 26.68,14.98 v2(26.65,15) ; PR809.1 224.71,39.41 225.36,38.76 v2(225.36,38.55) ; PR208.1 PR202.1 49.37,41.86 48.82,41.86 v2(48.8,41.87) ; v2(65.47,62.47) 67.04,62.47 68.64,64.07 v2(70.44,64.07) ; v2(34.3,33.39) 34.17,33.52 PR312.1 ; v2(172.87,12.63) 172.87,13.21 172.44,13.64 RH121.2 ; v2(97.77,6.64) PR504.1 ; v2(183.42,15.05) 182.94,15.53 182.94,17.72 183.78,18.56 183.78,20.31 ; v2(34.93,39.11) 34.81,38.98 PR320.2 ; RZ96.2 v2(234,46.68)
  vias: v2(64.14,37.76) v2(64.14,37.07) v2(64.48,38.32) v2(67.6,37.99) v2(69.25,18.68) v2(69.86,18.68) v2(70.49,18.66) v2(77.23,15.61) v2(77.23,15) v2(77.86,15.61) v2(77.86,15) v2(78.5,15.61) v2(78.5,15) v2(79.13,15.61) v2(79.13,15) v2(79.77,15.61) v2(79.77,15) v2(80.4,15.61) v2(80.38,15) v2(151.27,21.2) v2(154.95,14.57) v2(154.95,13.96) v2(154.95,13.35) v2(155.56,14.57) v2(155.56,13.96) v2(155.56,13.35) v2(156.17,14.57) v2(156.17,13.96) v2(156.17,13.35) v2(156.78,14.57) v2(156.78,13.96) v2(157.34,14.39) v2(158.89,28.18) v2(177.4,21.5) v2(178,21.49) v2(201.41,20.46) v2(202.02,20.44) v2(202.6,20.44) v2(216.24,14.06) v2(216.8,14.98) v2(216.8,14.34) v2(217.41,14.98) v2(217.41,14.39) v2(217.99,14.98) v2(217.99,14.39) v2(218.58,14.98) v2(218.63,14.37) v2(219.19,14.98) v2(219.22,14.39) v2(219.31,13.81) v2(233.04,36.72) v2(233.41,37.2) v2(234.45,21.3) v2(249.06,13.2) v2(251.09,13.2) v2(252.41,10.79) v2(252.99,10.81) v2(271.43,44.59) v2(271.74,44.03) v2(272.02,44.59) v2(271.97,43.47) v2(275.47,34.28) v2(275.93,34.66) v2(276.16,46.07) v2(276.54,34.66) v2(276.59,46.5) v2(276.79,34.13) v2(277.05,46.9) v3(154.09,13.48) v3(201.97,21.68) v3(276.13,35.42)
+3VALW_EC: length 153
  TOP w0.203: UE1.19 221.28,22.94 221.83,22.39 v2(221.83,22.24) ; UE1.115 227.05,30.44 v2(226.96,30.34) ; CE65.1 217.33,21.78 217.77,21.78 218.08,22.1 218.85,22.1 219.2,21.74 UE1.22 ; v2(237.09,24.81) 237.09,24.73 236.91,24.54 UE1.82 ; UE1.43 225.85,17.07 v2(226.2,17.41) ; UE1.103 231.85,32.7 231.96,32.81 v1(231.96,33.42) 231.96,34.28 CE63.2 ; v2(221.5,28.13) 221.5,28.16 221.52,28.18 221.52,28.23 221.22,28.54 UE1.5
  TOP w0.381: v2(218.31,21.54) 218.08,21.31 217.4,21.31 CE65.1
  TOP w0.508: CE63.2 231.28,34.46 231.2,34.38 v2(231.2,33.62) ; v2(226.96,30.34) 228.48,28.82 229.8,28.82 v2(230.49,28.13) 229.42,27.07 229.42,26 228.99,25.57 v2(228.99,25.17) ; CE89.1 RE12.2 ; CE89.1 v2(239.28,18.79) ; CE89.1 238.58,18.32 238.82,18.07 CE64.2 237.37,17.64 ; RE53.2 222.92,12.44 223.35,12.87 223.35,13.81 v2(223.12,14.04) ; v2(255.79,35.17) 255.79,34.13 254.29,32.63 254.29,31.36 253.39,30.46 v2(252.85,30.46)
  IN2 w0.508: v2(226.2,17.41) 226.2,17.95 227.57,19.32 v2(227.57,20.13) ; v2(228.99,25.17) 228.99,25.52 228.48,26.03 225.57,26.03 v2(224.72,25.17) 224.67,25.12 224.67,24.22 v2(224.65,24.2) 224.62,24.17 224.6,24.17 224.43,24.01 224.2,24.01 222.44,22.24 v2(221.83,22.24) ; v2(221.83,22.24) 221.71,22.12 220.7,22.12 220.12,21.54 v2(218.31,21.54) ; v2(221.83,22.24) 221.83,22.77 220.76,23.84 220.76,27.4 v2(221.5,28.13) ; v2(226.96,30.34) 226.96,30.57 228.89,32.5 228.89,33.29 229.25,33.65 231.18,33.65 v2(231.2,33.62)
  IN3 w0.508: v2(238.94,33.65) 239.8,34.51 243.16,34.51 244.92,36.26 v2(245.2,36.26) 245.63,36.26 247.99,33.9 247.99,33.59 250.17,31.41 251.9,31.41 v2(252.85,30.46)
  BOTTOM w0.381: CE69.1 221.37,28.11 221.45,28.11 221.5,28.16 v2(221.5,28.13)
  BOTTOM w0.508: RE13.1 230.49,28.65 v2(230.49,28.13) ; v2(238.94,33.65) 238.31,34.28 231.86,34.28 v2(231.2,33.62) ; RE125.1 226.16,34.74 225.82,34.4 225.82,32.12 226.96,30.98 v2(226.96,30.34) CE66.1 ; RE64.1 RE65.1 RE63.1 254.01,30.88 253.59,30.46 v2(252.85,30.46) ; RE43.2 RE44.2 RE45.2 224.63,25.26 v2(224.72,25.17) ; CE67.1 226.1,16.6 227.66,16.6 228.13,17.07 RE15.1 228.67,17.38 230.29,18.99 231.48,18.99 233.84,16.63 235.21,16.63 235.93,17.34 CE68.1 236.41,18.13 237.74,18.13 238.4,18.79 v2(239.28,18.79) 239.28,19.73 238.83,20.18 238.67,20.18 RE119.2 238.39,20.95 238.92,21.48 238.92,22.49 239.25,22.82 239.25,23.33 238.85,23.74 238.11,23.74 238.01,23.84 237.48,23.84 237.09,24.22 v2(237.09,24.81) 236.97,24.81 236.89,24.88 CE62.1 ; CE67.1 226.07,17.29 v2(226.2,17.41) ; CE67.1 224.95,16.58 224.29,15.92 224.29,14.34 223.81,13.86 223.3,13.86 v2(223.12,14.04) ; v2(227.57,20.13) 227.57,20.67 229.73,22.82 229.73,24.44 v2(228.99,25.17) 228.99,25.59 228.86,25.72 CE81.1 ; RE60.2 244.54,35.6 v2(245.2,36.26) ; v2(224.65,24.2) 224.6,24.25 RE46.2 ; v2(255.79,35.17) 255.79,34.52 256.75,33.56 RE118.1 ; v2(221.83,22.24) 221.57,22.49 CE79.1
+3VALWP: length 22.6
  BOTTOM w0.254: 76.03,14.54 76.03,14.7 75.12,15.61 63,15.61 60.08,18.53 57.62,18.53 PR410.1 57.16,18.23 PR401.1 PC401.1
  vias: v3(81.57,10.68)
+3VLP: length 197.6
  TOP w0.127: v2(140.06,21.51) v3(140.06,22.53)
  IN1 w0.508: v2(140.06,21.51) 140.84,22.29 147.23,22.29 148.3,21.22 v2(148.3,20.54)
  IN2 w0.508: v2(59.57,24.5) 60.36,25.29 61.95,25.29 63.3,26.64 64.97,26.64 66.24,25.38 70,25.38 70.04,25.34 70.26,25.34 71.38,24.22 71.38,23.24 72.58,22.04 76.01,22.04 77.18,20.87 79.56,20.87 79.66,20.97 92.11,20.97 93.13,21.99 95.13,21.99 95.84,21.28 98.52,21.28 99.28,20.51 126.1,20.51 126.3,20.72 135.04,20.72 136.69,22.37 138.31,22.37 139.17,21.51 v2(140.06,21.51) ; v2(226.37,22.32) 225,22.32 223.56,20.87 223.56,20.18 223.07,19.7 221.02,19.7 220.23,18.91 216.65,18.91 216.06,19.5 209.86,19.5 209.24,20.12 205.75,20.12 205.43,19.8 199.69,19.8 197.62,17.73 192.58,17.73 192.12,17.27 189.38,17.27 187.73,15.62 187.7,15.62 187.64,15.56 184.87,15.56 183.68,14.37 182.81,14.37 180.06,11.61 180.06,10.65 179.32,9.91 175.13,9.91 173.54,11.5 173.01,11.5 172.78,11.72 170.47,11.72 167.76,14.43 159.12,14.43 157.93,15.61 152.73,15.61 v2(151.9,16.44) 152.03,16.56 152.03,17.2 150.28,18.95 150.28,20.03 149.77,20.54 v2(148.3,20.54)
  BOTTOM w0.508: PR400.1 57.19,21.07 58.13,22.01 58.13,23.05 v2(59.57,24.5) ; RE20.2 225.18,25.85 225.77,25.26 225.77,23.99 226.37,23.38 v2(226.37,22.32)
+3VS: length 612.1
  TOP w0.254: v2(61.1,52.21) 65.77,56.89 75.83,56.89 84.77,65.83 84.77,72.08 82.18,74.67 80.45,74.67 79.92,75.2 79.92,80.66 v2(80.4,81.14) ; UZ17.1 166.27,73.77 165.62,73.12 v2(165.62,72.56) 165.59,72.58 165.67,72.58 166.35,73.27 UZ17.2 ; v2(187.27,24.79) 187.27,25.26 187.68,25.67 UH14.5
  TOP w0.381: QH4.2 154.07,22.02 154.52,21.58 RH27.1 ; RH15.1 153.04,24.63 v2(152.79,24.37) 152.79,24.2 151.6,23.01 151.6,22.72 150.9,22.02 QH4.5 149.14,22.02 148.52,22.65 RH26.1 ; v2(215.38,16.86) 215.4,16.88 216.09,16.88 RE108.1
  TOP w0.406: CH188.1 173.19,32.08 173.56,31.71 v2(173.56,31.61)
  TOP w0.508: RE83.1 RE81.1 v2(52.08,32.55) ; v2(61.1,52.21) 59.47,52.21 57.22,49.96 52.47,49.96 v2(51.32,48.81) ; RH87.2 RH111.2 179.03,23.99 RH141.2 ; v2(187.27,24.79) 187.33,24.86 188.57,24.86 RH180.1 ; v2(205.11,46.17) 205.11,47.49 v2(207.12,49.49) ; v2(138.31,33.71) 136.97,32.38 134.82,32.38 134.38,31.93 134.38,28.18 134.96,27.6 CD35.1 CD34.1 136.28,26.58 v2(136.84,26.03) ; 154.31,17.36 154.31,20.49 v2(154.47,20.64) 154.52,20.69 RH27.1 ; QV85.3 153.49,78.87 153.93,79.31 153.93,79.54 v2(153.93,79.54) ; UZ23.5 67.25,27.36 68.33,28.44 68.84,28.44 69.38,28.97 69.38,32.22 v2(69.1,32.5) ; v2(151.65,33.65) 151.14,33.14 151.14,31.57 RH80.2 151.06,30.37 151.58,29.85 152.55,29.85 v2(152.92,30.22) 153.3,30.6 RH86.1 RH129.2 RH494.1 RH159.1 153.15,27.93 v2(153.07,27.85) ; v2(137.68,43.17) 137.53,43.02 136.81,43.02 136.75,43.08 CD16.1 CD17.1 134.91,42.78 v2(134.56,42.43) ; v2(177.8,24.87) 177.9,24.87 178.78,23.99 RH141.2 ; v2(153.17,26.84) 153.35,26.66 RH119.1 ; RH142.2 RH141.2 ; v2(241.44,33.11) 241.72,32.83 241.72,32.47 243.39,30.79 Q13.2 243.77,29.56 RE122.1 ; RH14.1 RH15.1 ; RH179.2 RH500.2 RH85.2 168.79,17.18 v2(168.32,16.71) ; v2(147.26,77.53) 146.77,77.04 144.39,77.04 143.41,76.06 137.96,76.06 137.6,76.42 137.6,77.51 137.75,77.66 v2(137.75,77.71)
  TOP w1.016: 219.63,39.6 219.67,39.64 234.95,39.64 238.53,36.06 239.63,36.06
  IN1 w0.254: v2(68.95,81.09) 69.25,80.79 80.05,80.79 v2(80.4,81.14)
  IN1 w0.381: v2(215.38,16.86) 215.5,16.73 215.5,16 214.76,15.26 212.25,15.26 211.29,16.22 210.8,16.22 v2(210.56,16.46)
  IN1 w0.508: v2(96.2,6.62) 97.06,7.48 98.95,7.48 100,6.43 102.53,6.43 v2(102.55,6.46) ; v2(152.79,24.37) 152.79,23.1 154.47,21.42 v2(154.47,20.64) ; v2(177.8,24.87) 178.27,24.4 182.13,24.4 182.92,25.19 186.88,25.19 v2(187.27,24.79) ; v2(152.81,72.93) 152.81,72.74 154.28,71.26 160.64,71.26 161.63,72.25 165.36,72.25 165.62,72.51 v2(165.62,72.56)
  IN1 w1.016: 251.88,21.83 252.08,22.04 252.92,22.04 256.37,18.58 256.37,14.87 257.21,14.04 258.89,14.04 259.12,13.81
  IN2 w0.508: v2(52.08,32.55) 52.54,32.1 54.04,32.1 54.59,32.65 58.36,32.65 ; v2(147.81,75.03) 147.81,75.86 147.26,76.41 v2(147.26,77.53) 147.26,77.83 146.99,78.1 146.99,81.34 147.77,82.12 147.77,86.93 144.59,90.1 v2(144.59,108.12) ; v2(136.84,26.03) 137.35,25.52 v2(139.46,25.52) ; v2(173.56,31.61) 173.56,31.28 174.08,30.76 174.08,30.75 175.42,29.4 176.11,29.4 177.55,27.96 178.03,27.96 178.44,27.54 178.44,25.54 177.8,24.9 v2(177.8,24.87) ; v2(187.27,24.79) 187.27,26.11 190.64,29.48 193.28,29.48 193.76,29 197.29,29 v2(198.89,30.6) ; v2(153.07,27.85) 153.17,27.75 v2(153.17,26.84) 153.17,24.76 v2(152.79,24.37) ; v2(161.01,16.5) 161.01,17.05 161.78,17.82 163.54,17.82 165.11,16.25 v2(165.52,16.25) 165.69,16.07 168.06,16.07 168.32,16.33 v2(168.32,16.71)
  IN2 w1.016: 10.63,39.24 11.81,38.06 15.17,38.06 18.78,41.67 33.28,41.67 34.07,42.46 34.07,43.43 34.58,43.93 37.45,43.93 39.1,45.58 43.88,45.58 44.92,46.62
  IN3 w0.305: v2(151.34,17) 152.58,17 153.07,16.5 v2(157.23,16.5)
  IN3 w0.508: v2(241.44,33.11) 241.13,33.11 v2(238.44,30.42) ; 139.53,37.4 137.68,39.26 v2(137.68,43.17) 138.82,44.31 138.82,65.52 133.61,70.73 133.61,74.89 136.43,77.71 v2(137.75,77.71) ; v2(207.12,49.49) 209.24,51.62 209.24,59.41 210.26,60.43 212.48,60.43 213.47,61.42 v2(213.47,62.42) ; v2(147.81,75.03) 147.99,75.03 149.46,73.55 152.19,73.55 v2(152.81,72.93)
  IN3 w1.016: 272.04,46.6 274.28,46.6 276.72,44.16 276.72,42.48 278.06,41.14 279.71,41.14 280.5,40.35 286.39,40.35
  BOTTOM w0.152: v2(173.56,31.61) 173.56,31.62 173.55,31.64 173.51,31.64 UH2.AD13
  BOTTOM w0.203: 169.04,16.86 170.11,16.86 170.71,17.46 171.02,17.46 171.46,17.9 RH90.2
  BOTTOM w0.254: RP23.1 158.46,16.8 v2(158.16,16.5) 157.96,16.7 RP23.2 ; RP22.4 159.75,16.82 v2(160.08,16.5) 160.25,16.67 RP22.3 ; RP23.4 156.96,16.76 v2(157.23,16.5) 157.46,16.74 RP23.3 ; RP22.1 161.25,16.73 v2(161.01,16.5) 160.75,16.76 RP22.2 ; v2(61.1,52.21) 60.72,51.83 60.72,50.96 CT81.1 60.68,50.08 61,49.76 UT1.1 ; v2(68.95,81.09) 68.42,81.61 68.42,82.88 PR1112.1
  BOTTOM w0.305: RT4.1 55.18,48 QT2.5 QT2.2 ; CE85.1 236.55,27.31 UE6.5 ; JDIMM2.260 137.41,20.62 138.44,21.66 ; v2(151.34,17) QE19.5 QE19.2 ; JDIMM2.255 136.16,27.16 136.84,26.48 v2(136.84,26.03) ; JDIMM1.255 136.15,42.13 135.85,42.43 v2(134.56,42.43) ; v2(289.32,39.31) 289.24,39.23 289.24,38.62 288.93,38.32 288.93,37.58 288.6,37.25 RL33.1
  BOTTOM w0.381: RH79.2 153.54,37.26 151.71,37.26 150.89,36.44 150.89,34.41 ; v2(153.17,26.84) 153.45,27.12 RH120.1 ; v2(165.52,16.25) 165.52,15.15 166.11,14.55 UH7.5 ; RH160.1 153.22,28.01 v2(153.07,27.85) ; RH69.2 153.81,31.11 v2(152.92,30.22)
  BOTTOM w0.508: PR501.2 PR500.2 96,6.82 v2(96.2,6.62) ; v2(144.59,108.12) 145.17,108.7 145.17,110.66 144.84,110.99 PR900.1 ; 138.44,21.66 139,22.22 140.92,22.22 141.87,23.17 141.87,24.04 140.4,25.52 v2(139.46,25.52) ; v2(152.81,72.93) 152.85,72.93 153.42,73.5 153.42,78.68 153.93,79.18 153.93,79.54 v2(153.93,79.54) ; RT4.1 55.38,47.5 v2(54.99,47.11) ; RT3.1 56.99,46.47 56.6,46.08 v2(56.6,45.9) ; RT5.1 v2(51.32,48.81) ; QZ9.3 208.9,50.49 208.67,50.71 CZ43.1 207.65,50.71 207.12,50.18 v2(207.12,49.49) 207.12,48.28 RZ38.2 ; v2(102.55,6.46) 102.66,6.56 120.15,6.56 120.33,6.74 157.83,6.74 158.44,7.36 158.44,15.64 ; v2(238.44,30.42) 238.52,30.34 238.52,28.95 238.01,28.44 236.99,28.44 236.31,27.75 CE85.1 ; v2(80.4,81.14) 80.49,81.23 RH93.1 ; v2(144.84,38.83) 144.28,38.27 144.28,36.19 146.19,34.28 150.76,34.28 150.89,34.41 v2(151.65,33.65) ; PR110.1 v2(213.47,62.42)
  vias: v2(10.1,40.28) v2(10.73,40.28) v2(57.49,30.7) v2(58.15,30.75) v2(68.77,33.04) v2(69.4,33.09) v2(189.77,40.45) v2(190.33,41.04) v2(190.36,40.45) v2(203.77,31.49) v2(204.3,31.18) v2(204.28,30.57) v2(204.89,30.57) v2(205.98,29.81) v2(206.41,29.38) v2(206.87,29.78) v2(207.48,29.78) v2(212.63,29.76) v2(212.94,29.25) v2(213.07,30.24) v2(213.32,29.71) v2(218.84,38.66) v2(218.84,38.05) v2(218.86,37.43) v2(219.45,38.67) v2(219.45,38.09) v2(219.48,37.48) v2(241.92,33.57) v2(246.39,22.29) v2(246.8,30.64) v2(247.02,22.29) v2(247.34,30.39) v2(270.06,46.55) v2(270.75,46.55) v2(273.44,18.3) v2(273.44,17.67) v2(289.32,39.89) v3(205.37,21.45) v3(207.05,27.85) v3(208.87,24.3)
