# Allegro board Dell Inspiron 15 Gaming 7566 Compal LA-D991P BCV00 Rev1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D13: length 53.7
  IN3 w0.117: v2(76.1,39.49) 76.1,54.63 76.21,54.75 76.62,54.75 76.73,54.87 76.73,55.22 76.62,55.33 76.21,55.33 76.1,55.45 76.1,55.8 76.21,55.92 76.83,55.92 76.95,56.03 76.95,56.38 76.83,56.5 76.21,56.5 76.1,56.62 76.1,56.97 76.21,57.09 76.83,57.09 76.95,57.2 76.95,57.55 76.83,57.67 76.21,57.67 76.1,57.79 76.1,58.47 84.01,66.39 84.01,71.71 86.43,74.13 86.7,74.13 86.82,74.26 86.82,74.5 86.95,74.62 87.33,74.62 87.46,74.5 87.46,74.22 87.59,74.09 88.15,74.09 88.41,74.35 88.41,74.5 87.73,75.19 87.73,75.37 88,75.63 88.18,75.63 88.86,74.95 89.01,74.95 89.38,75.32 90.56,75.32 91.22,75.97 v2(91.22,76.01)
  BOTTOM w0.076: v2(91.22,76.01) 90.89,76.34 UH1.BL5
  BOTTOM w0.102: v2(76.1,39.49) 76.52,39.49 76.65,39.62 JDIMM1.25
DDR_A_D14: length 54.3
  IN3 w0.117: v2(87.99,71.24) 87.99,70.61 87.11,69.73 87.11,64.84 81.58,59.31 81.58,47.99 81.46,47.87 80.22,47.87 80.1,47.76 80.1,47.4 80.22,47.29 81.46,47.29 81.58,47.17 81.58,46.82 81.46,46.7 80.22,46.7 80.1,46.59 80.1,46.24 80.22,46.12 81.46,46.12 81.58,46 81.58,45.49 81.19,45.1 81.02,45.1 80.68,45.44 80.52,45.44 80.27,45.2 80.27,45.03 80.61,44.69 80.61,44.52 80.1,44.01 80.1,41.27 79.54,40.71 79.54,37.94 78.75,37.15 v2(78.54,37.15)
  BOTTOM w0.076: UH1.BK1 91.17,73.34 90.47,72.64 89.38,72.64 88.9,72.16
  BOTTOM w0.102: 88.9,72.16 v2(87.99,71.24) ; JDIMM1.38 79.9,36.24 78.99,37.15 v2(78.54,37.15)
DDR_A_D15: length 54.1
  IN3 w0.117: v2(78.52,39.51) 78.67,39.67 78.67,41.06 79.46,41.85 79.46,53.47 79.58,53.59 80.74,53.59 80.86,53.71 80.86,54.06 80.74,54.17 79.58,54.17 79.46,54.29 79.46,54.64 79.58,54.76 80.74,54.76 80.86,54.88 80.86,55.23 80.74,55.34 79.58,55.34 79.46,55.46 79.46,55.81 79.58,55.93 80.74,55.93 80.86,56.04 80.86,56.39 80.74,56.51 79.58,56.51 79.46,56.63 79.46,56.98 79.58,57.1 80.74,57.1 80.86,57.21 80.86,57.56 80.74,57.68 79.58,57.68 79.46,57.8 79.46,58.1 86.47,65.11 86.47,70.47 86.58,70.59 v2(86.88,70.59)
  BOTTOM w0.076: 89.41,71.95 89.89,72.44 90.93,72.44 91.61,73.12 UH1.BK2
  BOTTOM w0.102: v2(78.52,39.51) 79.1,39.51 79.65,40.07 JDIMM1.37 ; v2(86.88,70.59) 88.04,70.59 89.41,71.95
DDR_A_D16: length 51.2
  IN3 w0.117: v2(90.1,72.06) 89.32,71.29 89.32,70.18 88.27,69.13 88.27,64.36 83.81,59.9 83.81,56.07 82.74,55.01 82.74,42.27 81.04,40.57 81.04,37.16 v2(81.51,36.68)
  BOTTOM w0.076: UH1.BG5 93.62,76.05 93.62,75.57 93.42,75.37 93.26,75.37 93.03,75.14 93.03,74.26 92.82,74.05 92.82,72.73 92.15,72.06 v2(90.1,72.06)
  BOTTOM w0.102: v2(81.51,36.68) 81.86,36.68 82.9,35.64 JDIMM1.50
DDR_A_D17: length 50.8
  IN3 w0.117: v2(89.42,68.67) 89.37,68.62 89.1,68.62 88.91,68.43 88.91,64.09 84.45,59.63 84.45,48.62 84.33,48.5 83.5,48.5 83.38,48.39 83.38,48.04 83.5,47.92 84.33,47.92 84.45,47.8 84.45,47.45 84.33,47.34 83.5,47.34 83.38,47.22 83.38,46.87 83.5,46.75 84.33,46.75 84.45,46.64 84.45,46.28 84.33,46.17 83.5,46.17 83.38,46.05 83.38,45.7 83.5,45.58 84.33,45.58 84.45,45.47 84.45,45.12 84.33,45 83.5,45 83.38,44.88 83.38,44.53 83.5,44.42 83.83,44.42 83.95,44.3 83.95,43.89 83.83,43.77 83.5,43.77 83.38,43.66 83.38,42 81.92,40.55 81.92,38.93 v2(81.51,38.51)
  BOTTOM w0.076: 92.7,71.34 92.7,71.8 93.34,72.44 UH1.BG1
  BOTTOM w0.102: 92.7,71.34 91.58,70.22 90.41,70.22 89.42,69.23 v2(89.42,68.67) ; v2(81.51,38.51) 82.65,39.66 JDIMM1.49
DDR_A_D18: length 50.4
  IN3 w0.117: v2(84.76,36.41) 85.91,36.41 86.03,36.53 86.03,36.98 85.91,37.1 85.45,37.1 85.33,37.22 85.33,37.57 85.45,37.69 86.31,37.69 86.43,37.8 86.43,38.15 86.31,38.27 85.8,38.27 85.68,38.39 85.68,38.74 85.8,38.85 86.31,38.85 86.43,38.97 86.43,39.5 86.31,39.61 85.82,39.61 85.7,39.73 85.7,40.06 86.97,41.33 86.97,50.26 88.01,51.3 88.01,59.8 91.55,63.34 91.55,70.43 93.31,72.19 93.31,72.9 v2(94.47,74.06)
  BOTTOM w0.089: UH1.BF2 v2(94.47,74.06)
  BOTTOM w0.102: v2(84.76,36.41) 85.9,35.26 JDIMM1.62
DDR_A_D19: length 50
  IN3 w0.117: v2(94.47,76.01) 93.25,74.79 93.25,73.78 92.65,73.18 92.65,72.46 90.89,70.7 90.89,69.95 90.77,69.83 90.22,69.83 90.1,69.72 90.1,69.36 90.22,69.25 90.77,69.25 90.89,69.13 90.89,68.78 90.77,68.66 90.22,68.66 90.1,68.55 90.1,68.2 90.22,68.08 90.77,68.08 90.89,67.96 90.89,63.58 87.37,60.07 87.37,55.52 86.27,54.42 86.27,42.23 84.26,40.23 84.26,38.18 v2(84.76,37.68)
  BOTTOM w0.089: UH1.BF5 v2(94.47,76.01)
  BOTTOM w0.102: v2(84.76,37.68) 85.17,37.68 86.15,38.67 JDIMM1.63
DDR_A_D20: length 50.1
  IN3 w0.117: v2(92.2,72.62) 90.06,72.62 88.99,71.55 88.99,70.4 87.95,69.36 87.95,64.49 83.49,60.03 83.49,56.21 82.42,55.14 82.42,42.4 80.68,40.66 80.68,36.2 81.45,35.43 v2(81.51,35.43)
  BOTTOM w0.076: v2(92.2,72.62) 92.62,73.04 92.62,74.08 92.81,74.27 92.81,75.23 93.27,75.69 UH1.BG4
  BOTTOM w0.102: JDIMM1.46 81.9,33.75 82.06,33.9 82.06,34.89 v2(81.51,35.43)
DDR_A_D21: length 50.6
  IN3 w0.117: v2(81.5,39.72) 81.5,40.58 83.06,42.14 83.06,48.82 83.25,49.01 83.63,49.01 83.74,49.13 83.74,49.57 83.63,49.69 83.18,49.69 83.06,49.81 83.06,50.16 83.18,50.27 84.01,50.27 84.13,50.39 84.13,50.74 84.01,50.86 83.18,50.86 83.06,50.97 83.06,51.32 83.18,51.44 84.01,51.44 84.13,51.56 84.13,51.91 84.01,52.03 83.18,52.03 83.06,52.14 83.06,52.49 83.18,52.61 84.01,52.61 84.13,52.73 84.13,53.08 84.01,53.19 83.18,53.19 83.06,53.31 83.06,53.66 83.18,53.78 84.01,53.78 84.13,53.89 84.13,54.25 84.01,54.36 83.18,54.36 83.06,54.48 83.06,54.83 83.18,54.95 84.01,54.95 84.13,55.06 84.13,59.77 88.59,64.23 88.59,68.98 89.65,70.04 89.65,70.38 v2(90.1,70.83)
  BOTTOM w0.076: 92.16,71.65 93.05,72.54 93.05,73.88 93.34,74.17 UH1.BG2
  BOTTOM w0.102: v2(90.1,70.83) 91.34,70.83 92.16,71.65 ; v2(81.5,39.72) 81.65,39.87 JDIMM1.45
DDR_A_D22: length 50
  IN3 w0.117: v2(94.47,73.41) 93.66,72.6 93.66,72.07 91.88,70.29 91.88,63.22 88.33,59.67 88.33,51.16 87.29,50.12 87.29,41.07 86.75,40.52 86.75,35.27 86.63,35.16 86.17,35.16 86.05,35.27 86.05,35.98 85.93,36.09 85.58,36.09 85.47,35.98 85.47,35.26 85.35,35.14 v2(84.76,35.14)
  BOTTOM w0.089: UH1.BF1 v2(94.47,73.41)
  BOTTOM w0.102: JDIMM1.58 84.9,33.77 85.01,33.87 85.5,33.87 85.6,33.97 85.6,34.33 85.5,34.43 85.28,34.43 85.18,34.53 85.18,34.73 85.46,35.01 85.46,35.28 85.25,35.49 85.04,35.49 84.76,35.2 v2(84.76,35.14)
DDR_A_D23: length 50.4
  IN3 w0.117: v2(84.76,38.95) 85.38,39.58 85.38,40.41 86.65,41.68 86.65,50.39 87.69,51.43 87.69,51.67 87.57,51.79 86.71,51.79 86.59,51.91 86.59,52.26 86.71,52.38 87.57,52.38 87.69,52.49 87.69,52.84 87.57,52.96 86.71,52.96 86.59,53.08 86.59,53.43 86.71,53.54 87.57,53.54 87.69,53.66 87.69,54.01 87.57,54.13 87.01,54.13 86.89,54.24 86.89,54.6 87.01,54.71 87.57,54.71 87.69,54.83 87.69,59.93 91.22,63.46 91.22,70.56 92.98,72.32 92.98,73.04 93.58,73.64 93.58,74.47 v2(94.47,75.36)
  BOTTOM w0.076: UH1.BF4 94.31,75.69 94.47,75.52 v2(94.47,75.36)
  BOTTOM w0.102: v2(84.76,38.95) 85.03,38.95 85.1,38.88 85.1,38.65 85.21,38.55 85.61,38.55 85.85,38.79 85.85,39.77 85.74,39.89 85.31,39.89 85.15,40.04 JDIMM1.59
DDR_A_D24: length 49
  IN3 w0.117: v2(94.43,70.38) 94.01,70.38 93.07,69.45 93.07,62.77 89.49,59.19 89.49,46.27 88.45,45.23 88.45,39.77 88.83,39.39 88.83,39.11 88.95,38.99 89.26,38.99 89.38,38.87 89.38,38.52 89.26,38.41 88.95,38.41 88.83,38.29 88.83,35.7 89.68,34.85 89.68,34.52 89.46,34.29 89.16,34.29 v2(88.28,35.18)
  BOTTOM w0.076: v2(94.43,70.38) 94.86,70.81 94.86,71.6 95.29,72.02 95.29,72.64 95.57,72.93 95.57,73.87 95.85,74.15 UH1.BD2
  BOTTOM w0.102: JDIMM1.70 87.9,33.63 87.77,33.77 87.77,34.66 v2(88.28,35.18)
DDR_A_D25: length 49
  IN3 w0.117: v2(94.47,69.75) 93.93,69.75 93.42,69.24 93.42,62.66 89.81,59.05 89.81,46.14 88.78,45.11 88.78,44.8 88.9,44.68 89.58,44.68 89.7,44.57 89.7,44.22 89.58,44.1 88.9,44.1 88.78,43.98 88.78,43.63 88.9,43.52 89.58,43.52 89.7,43.4 89.7,43.05 89.58,42.93 88.9,42.93 88.78,42.81 88.78,42.46 88.9,42.35 89.58,42.35 89.7,42.23 89.7,41.88 89.58,41.76 88.9,41.76 88.78,41.65 88.78,41.3 88.9,41.18 89.58,41.18 89.7,41.06 89.7,40.71 89.58,40.59 88.9,40.59 88.78,40.48 88.78,39.99 89.67,39.11 v2(90.51,39.11)
  BOTTOM w0.076: v2(94.47,69.75) 95.26,70.54 95.26,71.71 95.46,71.91 95.46,72.58 95.85,72.97 UH1.BD1
  BOTTOM w0.102: v2(90.51,39.11) 89.03,39.11 88.15,39.99 JDIMM1.71
DDR_A_D26: length 49.1
  IN3 w0.117: v2(91.79,35.8) 92.73,35.8 92.96,36.04 92.96,43.73 92.79,43.91 92.79,58.62 95.83,61.67 95.83,68.15 v2(96.27,68.59)
  BOTTOM w0.076: v2(96.27,68.59) 97.48,69.8 97.48,72.98 97.03,73.43 97.03,74.24 96.94,74.34 96.94,75.09 96.59,75.44 UH1.BC4
  BOTTOM w0.102: JDIMM1.83 91.15,39.61 92.27,38.5 92.27,36.28 v2(91.79,35.8)
DDR_A_D27: length 49.4
  IN3 w0.117: v2(96.27,67.36) 96.17,67.26 96.17,61.56 93.12,58.5 93.12,44.05 93.29,43.87 93.29,35.62 93.1,35.43 92.37,35.43 92.24,35.3 92.24,35.05 92.37,34.92 93.1,34.92 93.25,34.77 93.25,34.52 93.12,34.39 v2(91.82,34.39)
  BOTTOM w0.076: UH1.BC5 96.88,76.05 96.88,75.39 97.19,75.08 97.19,74.34 97.2,74.33 97.2,73.59 97.93,72.86 97.93,69.02 v2(96.27,67.36)
  BOTTOM w0.102: v2(91.82,34.39) 91.4,33.98 JDIMM1.84
DDR_A_D28: length 49.3
  IN3 w0.076: v2(94.49,72.15) 94.48,72.15 93.99,71.67 93.99,71.62 93.86,71.49
  IN3 w0.117: 93.86,71.49 92.41,70.04 92.41,63.01 88.85,59.45 88.85,50.95 87.81,49.91 87.81,40.8 87.27,40.26 87.27,36.48 87.46,36.29 87.73,36.29 v2(88.24,36.79)
  BOTTOM w0.076: UH1.BD5 95.34,75.82 95.34,74.29 95.24,74.2 95.24,73.15 94.91,72.82 94.91,72.53 94.54,72.15 v2(94.49,72.15)
  BOTTOM w0.102: JDIMM1.66 86.9,35.46 v2(88.24,36.79)
DDR_A_D29: length 48.7
  IN3 w0.076: v2(94.43,71.55) 93.99,71.11
  IN3 w0.117: v2(88.2,38.62) 87.59,39.23 87.59,39.84 88.13,40.39 88.13,46.34 88.25,46.46 89,46.46 89.11,46.57 89.11,46.92 89,47.04 88.25,47.04 88.13,47.16 88.13,47.51 88.25,47.63 89,47.63 89.11,47.74 89.11,48.09 89,48.21 88.25,48.21 88.13,48.33 88.13,48.68 88.25,48.79 89,48.79 89.11,48.91 89.11,49.26 89,49.38 88.25,49.38 88.13,49.5 88.13,49.77 89.17,50.82 89.17,59.32 92.74,62.89 92.74,69.86 93.99,71.11
  BOTTOM w0.076: UH1.BD4 95.56,75.39 95.56,74.19 95.41,74.04 95.41,73.03 95.12,72.74 95.12,72.18 94.49,71.55 v2(94.43,71.55)
  BOTTOM w0.102: JDIMM1.67 87.15,39.5 88.04,38.62 v2(88.2,38.62)
DDR_A_D30: length 49.2
  IN3 w0.076: 95.17,68.16 95.17,68.6 95.8,69.23 95.8,69.98 v2(96.31,70.49)
  IN3 w0.117: 95.17,68.16 95.17,61.91 91.57,58.31 91.57,56.22 91.68,56.11 92.02,56.11 92.14,55.99 92.14,55.64 92.02,55.52 91.68,55.52 91.57,55.41 91.57,55.06 91.68,54.94 92.02,54.94 92.14,54.82 92.14,54.47 92.02,54.36 91.68,54.36 91.57,54.24 91.57,53.89 91.68,53.77 92.02,53.77 92.14,53.65 92.14,53.3 92.02,53.19 91.68,53.19 91.57,53.07 91.57,52.72 91.68,52.6 92.02,52.6 92.14,52.49 92.14,52.14 92.02,52.02 91.68,52.02 91.57,51.9 91.57,51.55 91.68,51.43 92.02,51.43 92.14,51.32 92.14,50.97 92.02,50.85 91.68,50.85 91.57,50.73 91.57,44.18 92.26,43.49 92.26,42.78 92.14,42.66 91.69,42.66 91.58,42.54 91.58,42.19 91.69,42.07 92.14,42.07 92.26,41.96 92.26,41.61 92.14,41.49 91.69,41.49 91.58,41.37 91.58,41.02 91.69,40.91 92.14,40.91 92.26,40.79 92.26,38.21 v2(91.79,37.74)
  BOTTOM w0.076: v2(96.31,70.49) 96.35,70.49 96.87,71.01 96.87,72.8 96.59,73.08 UH1.BC1
  BOTTOM w0.102: JDIMM1.79 90.15,40.07 91.32,38.91 91.32,38.21 v2(91.79,37.74)
DDR_A_D31: length 49.1
  IN3 w0.076: v2(96.28,69.24) 95.5,68.46 95.5,68.27
  IN3 w0.117: v2(91.79,37.1) 92.63,37.95 92.63,43.6 92.46,43.77 92.46,44.45 92.34,44.57 92,44.57 91.89,44.68 91.89,45.03 92,45.15 92.34,45.15 92.46,45.27 92.46,45.62 92.34,45.74 92,45.74 91.89,45.85 91.89,46.2 92,46.32 92.34,46.32 92.46,46.44 92.46,46.79 92.34,46.9 92,46.9 91.89,47.02 91.89,47.37 92,47.49 92.34,47.49 92.46,47.6 92.46,47.96 92.34,48.07 92,48.07 91.89,48.19 91.89,48.54 92,48.66 92.34,48.66 92.46,48.77 92.46,49.12 92.34,49.24 92,49.24 91.89,49.36 91.89,49.71 92,49.82 92.34,49.82 92.46,49.94 92.46,58.74 95.5,61.79 95.5,68.27
  BOTTOM w0.076: UH1.BC2 96.59,74.23 96.87,73.95 96.87,73.24 97.17,72.93 97.17,70.13 v2(96.28,69.24)
  BOTTOM w0.102: JDIMM1.80 90.4,34.23 91.27,35.09 91.27,36.59 v2(91.79,37.1)
DDR_A_D32: length 48.6
  IN3 w0.117: v2(115.38,65.27) 115.22,65.12 115.22,64.58 118.13,61.68 118.13,48.43 117.47,47.77 117.47,41.6 116.96,41.1 116.96,37.36 117.54,36.78 117.54,35.44 117.66,35.32 119.06,35.32 119.18,35.44 119.18,35.92 119.06,36.04 v2(118.42,36.04)
  BOTTOM w0.076: UH1.AB1 113.47,73.72 113.47,71.46 113.62,71.31
  BOTTOM w0.102: 113.62,71.31 113.67,71.26 113.67,71.26 113.84,71.09 113.84,69.82 115.4,68.26 115.4,65.3 v2(115.38,65.27) ; v2(118.42,36.04) 118.42,35.93 116.29,33.8 116.07,33.8 115.9,33.64 JDIMM1.174
DDR_A_D33: length 48.6
  IN3 w0.117: v2(114.86,65.66) 114.86,64.5 117.8,61.55 117.8,48.55 117.15,47.9 117.15,41.73 116.63,41.22 116.63,37.24 117.22,36.65 117.22,35.54 117.1,35.42 116.75,35.42 116.64,35.54 116.64,35.84 v2(116.22,36.25)
  BOTTOM w0.076: UH1.AB2 113.3,74.38 113.18,74.26 113.18,73.62 113.31,73.49 113.31,71.19 113.4,71.1
  BOTTOM w0.102: 113.4,71.1 113.53,70.96 113.53,69.69 114.86,68.37 v2(114.86,65.66) ; JDIMM1.173 115.65,39.88 116.75,38.79 116.75,36.77 v2(116.22,36.25)
DDR_A_D34: length 47.3
  IN3 w0.117: v2(114.64,75.36) 114.19,74.91 114.19,74.3 113.52,73.64 113.52,69.9 120.23,63.19 120.23,50.25 120.35,50.14 120.73,50.14 120.85,50.02 120.85,49.67 120.73,49.55 120.35,49.55 120.23,49.44 120.23,49.08 120.35,48.97 120.73,48.97 120.85,48.85 120.85,48.5 120.73,48.38 120.37,48.38 120.25,48.27 120.25,47.92 120.37,47.8 120.73,47.8 120.85,47.68 120.85,47.33 120.73,47.22 119.91,47.22 119.8,47.1 119.8,46.75 119.91,46.63 120.73,46.63 120.85,46.51 120.85,46.15 120.73,46.03 119.9,46.03 119.78,45.92 119.78,45.57 119.9,45.45 120.27,45.45 120.44,45.29 120.44,45.02 119.78,44.36 119.78,39.66 v2(119.56,39.44)
  BOTTOM w0.076: UH1.AA4 v2(114.64,75.36)
  BOTTOM w0.102: JDIMM1.187 119.15,40.08 119.56,39.68 v2(119.56,39.44)
DDR_A_D35: length 47.9
  IN3 w0.117: v2(119.56,36.92) 119.14,37.34 119.14,39.66 119.46,39.98 119.46,47.25 119.91,47.71 119.91,63.04 113.19,69.77 113.19,73.77 113.82,74.4 113.82,75.16 v2(114.62,75.97)
  BOTTOM w0.076: UH1.AA5 v2(114.62,75.97)
  BOTTOM w0.102: v2(119.56,36.92) 119.11,36.47 119.11,34.14 118.9,33.94 JDIMM1.186
DDR_A_D36: length 48.4
  IN3 w0.117: v2(116.22,35.01) 115.96,34.75 115.66,34.75 115.47,34.94 115.47,35.25 115.78,35.55 115.78,41.27 116.47,41.97 116.47,49.76 117.14,50.42 117.14,60.71 113.35,64.49 113.35,66.83 v2(113.54,67.02)
  BOTTOM w0.076: UH1.AB5 113.05,75.93 113.05,75.67 112.85,75.47 112.85,73.42 112.92,73.35 112.92,70.68
  BOTTOM w0.102: v2(113.54,67.02) 113.11,67.44 113.11,69.26 112.89,69.47 112.89,70.65 112.92,70.68 ; JDIMM1.170 114.9,34.38 115.51,34.98 116.19,34.98 v2(116.22,35.01)
DDR_A_D37: length 48.6
  IN3 w0.117: v2(114.01,66.6) 113.79,66.6 113.67,66.48 113.67,65.8 113.79,65.68 114.29,65.68 114.41,65.56 114.41,65.21 114.29,65.09 113.79,65.09 113.67,64.98 113.67,64.63 113.9,64.4 114.07,64.4 114.2,64.53 114.37,64.53 114.61,64.29 114.61,64.12 114.48,63.98 114.48,63.82 114.73,63.57 114.89,63.57 115.03,63.71 115.19,63.71 115.44,63.46 115.44,63.29 115.3,63.16 115.3,62.99 115.55,62.74 115.72,62.74 115.85,62.88 116.02,62.88 116.27,62.63 116.27,62.47 116.13,62.33 116.13,62.17 116.38,61.92 116.54,61.92 116.68,62.05 116.85,62.05 117.09,61.81 117.09,61.64 116.96,61.5 116.96,61.34 117.47,60.83 117.47,50.3 116.79,49.63 116.79,49.41 116.91,49.29 117.31,49.29 117.42,49.17 117.42,48.78 117.31,48.66 116.91,48.66 116.79,48.55 116.79,41.83 116.11,41.15 116.11,40.48 116.31,40.27 116.31,39.89 116.11,39.68 116.11,38.84 v2(116.21,38.73)
  BOTTOM w0.076: UH1.AB4 113.01,75.24 113.01,73.51 113.09,73.44 113.09,70.98 113.18,70.88
  BOTTOM w0.102: v2(116.21,38.73) 116.05,38.73 114.65,40.13 JDIMM1.169 ; 113.18,70.88 113.23,70.83 113.23,69.57 113.72,69.08 113.72,68.94 113.56,68.78 113.56,68.64 113.77,68.42 113.92,68.42 114.07,68.58 114.22,68.58 114.46,68.33 114.46,67.05 v2(114.01,66.6)
DDR_A_D38: length 47.5
  IN3 w0.117: v2(114.64,74.13) 114.49,74.13 113.87,73.52 113.87,70.02 120.55,63.34 120.55,54.18 120.67,54.06 121.07,54.06 121.18,53.94 121.18,53.59 121.07,53.48 120.67,53.48 120.55,53.36 120.55,53.01 120.67,52.89 121.07,52.89 121.18,52.78 121.18,52.43 121.07,52.31 120.67,52.31 120.55,52.19 120.55,51.84 120.67,51.72 121.07,51.72 121.18,51.61 121.18,51.26 121.07,51.14 120.67,51.14 120.55,51.02 120.55,50.64 120.74,50.46 120.99,50.46 121.18,50.27 121.18,45.32 120.1,44.23 120.1,38.28 119.95,38.14 v2(119.57,38.14)
  BOTTOM w0.076: UH1.AA2 v2(114.64,74.13)
  BOTTOM w0.102: JDIMM1.183 118.15,39.93 118.76,39.33 118.76,38.78 119.41,38.13 119.56,38.13 v2(119.57,38.14)
DDR_A_D39: length 47.4
  IN3 w0.117: v2(114.63,73.48) 114.57,73.48 114.2,73.11 114.2,70.16 120.87,63.48 120.87,54.52 121.02,54.38 121.31,54.38 121.5,54.19 121.5,45.18 120.46,44.14 120.46,38.18 120.32,38.05 120.32,37.64 120.44,37.53 120.8,37.53 120.92,37.41 120.92,37.06 120.8,36.94 120.44,36.94 120.32,36.82 120.32,36.44 119.5,35.61 119.5,34.9 119.09,34.48 119.09,34.23 119,34.15 v2(118.41,34.15)
  BOTTOM w0.076: UH1.AA1 v2(114.63,73.48)
  BOTTOM w0.102: v2(118.41,34.15) 117.9,33.64 JDIMM1.182
DDR_A_D40: length 48.6
  IN3 w0.117: v2(122.31,37.61) 122.31,41.01 122.99,41.68 122.99,54.8 122.36,55.43 122.36,55.85 122.47,55.96 122.87,55.96 122.99,56.08 122.99,56.43 122.87,56.55 122.47,56.55 122.36,56.66 122.36,57.01 122.47,57.13 122.87,57.13 122.99,57.25 122.99,57.6 122.87,57.72 122.47,57.72 122.36,57.83 122.36,58.18 122.47,58.3 122.73,58.3 122.84,58.42 122.84,58.77 122.73,58.88 122.47,58.88 122.36,59 122.36,64.16 120.56,65.95 v2(120.56,66.2)
  BOTTOM w0.076: 115.48,71.32 115.48,72.57 115.53,72.61 115.53,73.92 115.52,73.92 115.52,74.2 115.53,74.2 115.53,75.24 UH1.V4
  BOTTOM w0.102: v2(120.56,66.2) 119.78,66.2 115.48,70.5 115.48,71.32 ; v2(122.31,37.61) 121.8,38.12 121.8,39.08 121.15,39.73 JDIMM1.195
DDR_A_D41: length 48.2
  IN3 w0.117: v2(121.08,35.04) 120.79,35.04 120.64,34.89 120.64,34.63 120.53,34.53 120.14,34.53 120.02,34.65 120.02,35.4 120.6,35.97 120.77,35.97 121.06,35.68 121.22,35.68 121.47,35.93 121.47,36.1 121.18,36.39 121.18,36.55 121.71,37.08 121.71,37.93 121.99,38.21 121.99,41.14 122.67,41.81 122.67,54.67 122.04,55.3 122.04,63.97 116.52,69.48 116.52,69.79 v2(116.82,70.09)
  BOTTOM w0.076: v2(116.82,70.09) 116.82,70.75 116.15,71.42 116.15,71.43 115.97,71.62 UH1.V1
  BOTTOM w0.102: v2(121.08,35.04) 120.67,34.62 120.67,34.06 120.9,33.83 JDIMM1.194
DDR_A_D42: length 47.8
  IN3 w0.117: v2(117.15,76.01) 116.39,75.24 116.39,72.63 116.92,72.1 116.92,71.93 116.48,71.5 116.48,71.33 116.73,71.08 116.89,71.08 117.33,71.52 117.5,71.52 117.74,71.27 117.74,71.11 117.3,70.67 117.3,70.5 117.55,70.26 117.72,70.26 118.16,70.7 118.32,70.7 124.13,64.89 124.13,64.26 124.25,64.14 124.66,64.14 124.77,64.03 124.77,63.68 124.66,63.56 124.25,63.56 124.13,63.44 124.13,63.09 124.25,62.97 124.83,62.97 124.94,62.86 124.94,62.51 124.83,62.39 124.25,62.39 124.13,62.27 124.13,60.27 124.74,59.66 124.74,40.95 124.13,40.34 124.13,39.76 v2(124.02,39.65)
  BOTTOM w0.076: UH1.U5 116.71,76.13 116.83,76.01 v2(117.15,76.01)
  BOTTOM w0.102: v2(124.02,39.65) 124.09,39.65 124.15,39.71 JDIMM1.207
DDR_A_D43: length 48.3
  IN3 w0.117: v2(117.54,72.89) 117.66,72.77 117.66,72.29 125.96,63.99 125.96,60.18 125.38,59.6 125.38,59.19 125.5,59.08 125.58,59.08 125.7,58.96 125.7,58.61 125.58,58.49 125.5,58.49 125.38,58.38 125.38,56.66 125.96,56.08 125.96,54.82 125.39,54.25 125.39,45.26 125.97,44.68 125.97,41.27 124.79,40.09 124.79,37.06 124.51,36.78 124.33,36.78 v2(123.99,37.11)
  BOTTOM w0.076: UH1.U1 116.71,73.31 117.12,72.89 v2(117.54,72.89)
  BOTTOM w0.102: JDIMM1.208 124.4,35.13 124.6,35.33 124.6,36.5 v2(123.99,37.11)
DDR_A_D44: length 48.5
  IN3 w0.117: v2(121.04,39.17) 120.98,39.22 120.98,43.92 122.03,44.97 122.03,54.41 121.4,55.04 121.4,63.7 114.78,70.32 114.78,71.34 115.9,72.46 115.9,73.98 115.75,74.13 115.41,74.13 115.26,73.98 115.26,72.77 v2(114.66,72.17)
  BOTTOM w0.076: 115.14,72.65 115.36,72.87 115.36,73.85 115.36,74.5 115.36,74.92 115.36,74.92 115.36,75.59 115.58,75.81 115.58,75.95 UH1.V5
  BOTTOM w0.102: 115.14,72.65 v2(114.66,72.17) ; JDIMM1.191 120.15,40.02 121.01,39.17 v2(121.04,39.17)
DDR_A_D45: length 48.5
  IN3 w0.117: v2(115.96,70.94) 115.64,71.26 115.3,71.26 115.11,71.07 115.11,70.44 121.72,63.83 121.72,55.17 122.35,54.54 122.35,44.83 121.65,44.14 121.65,43.33 121.53,43.21 121.42,43.21 121.3,43.09 121.3,42.74 121.42,42.62 121.72,42.62 121.83,42.51 121.83,42.16 121.72,42.04 121.42,42.04 121.3,41.92 121.3,41.57 121.42,41.46 121.53,41.46 121.65,41.34 121.65,40.99 121.53,40.87 121.42,40.87 121.3,40.76 121.3,39.79 121.47,39.62 121.47,38.34 v2(121.04,37.91)
  BOTTOM w0.076: 115.85,71.05 115.85,71.3 115.69,71.46 115.69,74.11 UH1.V2
  BOTTOM w0.102: v2(121.04,37.91) 121.04,36.19 120.25,35.4 120.25,34.33 119.9,33.98 JDIMM1.190 ; 115.85,71.05 v2(115.96,70.94)
DDR_A_D46: length 48.2
  IN3 w0.117: v2(117.15,75.36) 116.72,74.92 116.72,72.77 125.64,63.85 125.64,61.47 125.52,61.36 124.68,61.36 124.57,61.24 124.57,60.89 124.68,60.77 125.52,60.77 125.64,60.66 125.64,60.32 125.06,59.74 125.06,56.53 125.64,55.95 125.64,54.96 125.07,54.39 125.07,45.13 125.64,44.56 125.64,41.4 124.46,40.22 124.46,38.53 124.31,38.38 v2(123.99,38.38)
  BOTTOM w0.076: UH1.U4 v2(117.15,75.36)
  BOTTOM w0.102: v2(123.99,38.38) 123.67,38.38 123.15,38.9 JDIMM1.203
DDR_A_D47: length 48.1
  IN3 w0.117: v2(117.15,74.09) 118.17,73.07 118.17,72.25 126.28,64.14 126.28,58.1 126.16,57.98 126.06,57.98 125.94,57.87 125.94,57.52 126.06,57.4 126.16,57.4 126.28,57.28 126.28,54.69 125.71,54.12 125.71,45.39 126.3,44.8 126.3,41.15 125.12,39.97 125.12,38.49 125.4,38.21 125.4,37.02 124.21,35.83 v2(123.98,35.83)
  BOTTOM w0.076: UH1.U2 v2(117.15,74.09)
  BOTTOM w0.102: JDIMM1.204 123.4,35.25 v2(123.98,35.83)
DDR_A_D48: length 48
  IN3 w0.117: v2(126.04,36.3) 127.04,36.3 127.05,36.3 127.36,36.3 127.48,36.43 127.48,36.81 127.36,36.94 127.07,36.94 126.94,37.06 126.94,39.29 127.8,40.15 127.8,64.95 121.78,70.97 v2(121.78,71)
  BOTTOM w0.076: v2(121.78,71) 120.64,71 119.11,72.54 119.11,72.63 118.48,73.26 UH1.R1
  BOTTOM w0.102: v2(126.04,36.3) 126.71,35.64 126.71,33.95 126.4,33.65 JDIMM1.216
DDR_A_D49: length 48.3
  IN3 w0.076: v2(119.47,71.58) 119.49,71.6 120.21,71.6 121.63,70.18 121.63,70.06
  IN3 w0.117: 121.63,70.06 127.16,64.53 127.16,53.84 127.04,53.73 126.69,53.73 126.58,53.61 126.58,53.26 126.69,53.14 127.04,53.14 127.16,53.02 127.16,52.67 127.04,52.56 126.67,52.56 126.55,52.44 126.55,52.09 126.67,51.97 127.04,51.97 127.16,51.86 127.16,51.51 127.04,51.39 126.67,51.39 126.55,51.27 126.55,50.92 126.67,50.8 127.04,50.8 127.16,50.69 127.16,50.34 127.04,50.22 126.67,50.22 126.55,50.1 126.55,49.75 126.67,49.64 127.04,49.64 127.16,49.52 127.16,49.17 127.04,49.05 126.67,49.05 126.55,48.93 126.55,48.58 126.67,48.47 127.04,48.47 127.16,48.35 127.16,48 127.04,47.88 126.67,47.88 126.55,47.77 126.55,47.42 126.67,47.3 127.04,47.3 127.16,47.18 127.16,40.63 v2(126.15,39.63)
  BOTTOM w0.076: v2(119.47,71.58) 118.76,71.58 118.17,72.17 118.17,73.11 118.04,73.24 118.04,75.24 UH1.R4
  BOTTOM w0.102: v2(126.15,39.63) JDIMM1.215
DDR_A_D50: length 48.1
  IN3 w0.076: v2(119.66,73.36) 119.66,73.36 119.72,73.42 120.75,73.42 124.87,69.29 125.03,69.29
  IN3 w0.117: 125.03,69.29 125.98,69.29 129.62,65.65 129.62,37.35 128.47,36.2 v2(128.14,36.2)
  BOTTOM w0.076: UH1.P1 119.34,73.73 119.66,73.43 v2(119.66,73.36)
  BOTTOM w0.102: v2(128.14,36.2) 128.17,36.2 129.4,34.97 JDIMM1.228
DDR_A_D51: length 47.9
  IN3 w0.076: v2(119.67,76.67) 119.93,76.67 120.21,76.39 120.21,74.83 124.76,70.28 124.83,70.28
  IN3 w0.117: v2(130.71,39.37) 130.71,41.41 131.58,42.28 131.58,43.35 131.45,43.47 130.92,43.47 130.81,43.59 130.81,43.94 130.92,44.06 131.4,44.06 131.58,44.24 131.58,44.77 130.71,45.65 130.71,66.07 126.49,70.28 124.83,70.28
  BOTTOM w0.102: v2(119.67,76.67) 119.56,76.67 UH1.P5 ; v2(130.71,39.37) 130.16,39.37 129.65,39.88 JDIMM1.229
DDR_A_D52: length 48.1
  IN3 w0.076: 121.28,69.94 121.28,70.27 120.81,70.73 v2(120.3,70.73)
  IN3 w0.117: 121.28,69.94 126.8,64.42 126.8,54.44 126.23,53.87 126.23,46.94 126.35,46.83 126.72,46.83 126.84,46.71 126.84,46.36 126.72,46.24 126.35,46.24 126.23,46.12 126.23,45.62 126.82,45.04 126.82,40.93 125.65,39.77 125.65,38.69 125.93,38.42 v2(126.12,38.42)
  BOTTOM w0.076: UH1.R5 117.87,75.73 117.87,73.17 117.99,73.05 117.99,71.92 119.26,70.65 120.23,70.65 v2(120.3,70.73)
  BOTTOM w0.102: JDIMM1.211 125.15,39.39 v2(126.12,38.42)
DDR_A_D53: length 47.8
  IN3 w0.076: 122.05,70.11 119.59,72.56 118.75,72.56 v2(118.62,72.43)
  IN3 w0.117: 122.05,70.11 127.48,64.67 127.48,40.41 126.61,39.54 126.61,37.46 125.6,36.45 125.6,34.86 v2(126.19,34.27)
  BOTTOM w0.076: UH1.R2 118.2,74.11 118.2,73.3 118.62,72.89 v2(118.62,72.43)
  BOTTOM w0.102: JDIMM1.212 125.4,33.67 126,34.27 v2(126.19,34.27)
DDR_A_D54: length 48.2
  IN3 w0.076: v2(119.63,74.09) 120.38,74.09 124.85,69.62 125.02,69.62
  IN3 w0.117: v2(128.17,35.02) 129.95,36.81 129.95,65.77 126.1,69.62 125.02,69.62
  BOTTOM w0.076: UH1.P2 v2(119.63,74.09)
  BOTTOM w0.102: JDIMM1.224 128.4,33.82 128.49,33.9 128.49,34.7 v2(128.17,35.02)
DDR_A_D55: length 47.8
  IN3 w0.076: v2(119.67,75.97) 120.05,75.59 120.05,74.74 124.83,69.95 125.07,69.95
  IN3 w0.117: v2(130.69,38.1) 130.28,38.51 130.28,66.03 126.35,69.95 125.07,69.95
  BOTTOM w0.076: UH1.P4 v2(119.67,75.97)
  BOTTOM w0.102: JDIMM1.225 128.65,39.76 130.31,38.1 v2(130.69,38.1)
DDR_A_D56: length 53.8
  IN3 w0.076: 124.6,70.82 124.54,70.82 120.58,74.78 v2(120.58,75.33)
  IN3 w0.117: 124.6,70.82 126.71,70.82 131.23,66.3 131.23,52.99 131.35,52.88 131.99,52.88 132.11,52.76 132.11,52.41 131.99,52.29 131.35,52.29 131.23,52.18 131.23,51.82 131.35,51.71 131.99,51.71 132.11,51.59 132.11,51.24 131.99,51.12 131.35,51.12 131.23,51.01 131.23,50.66 131.35,50.54 131.99,50.54 132.11,50.42 132.11,50.07 131.99,49.96 131.35,49.96 131.23,49.84 131.23,49.49 131.35,49.37 131.99,49.37 132.11,49.25 132.11,48.9 131.99,48.79 131.35,48.79 131.23,48.67 131.23,48.32 131.35,48.2 131.99,48.2 132.11,48.09 132.11,47.74 131.99,47.62 131.35,47.62 131.23,47.5 131.23,47.15 131.35,47.03 131.9,47.03 132.02,46.92 132.02,46.57 131.9,46.45 131.35,46.45 131.23,46.33 131.23,45.86 132.11,44.99 132.11,41.34 131.99,41.22 131.5,41.22 131.38,41.1 131.38,40.75 131.5,40.64 131.99,40.64 132.11,40.52 132.11,39.99 v2(131.71,39.59)
  BOTTOM w0.076: UH1.M4 v2(120.58,75.33)
  BOTTOM w0.102: v2(131.71,39.59) 131.65,39.65 JDIMM1.237
DDR_A_D57: length 54.1
  IN3 w0.117: v2(124.33,72.08) 126.85,72.08 133.07,65.87 133.07,65.23 132.95,65.11 132.44,65.11 132.32,65 132.32,64.65 132.44,64.53 132.95,64.53 133.07,64.41 133.07,64.06 132.95,63.94 132.44,63.94 132.32,63.83 132.32,63.48 132.44,63.36 132.95,63.36 133.07,63.24 133.07,62.89 132.95,62.78 132.44,62.78 132.32,62.66 132.32,62.31 132.44,62.19 132.95,62.19 133.07,62.08 133.07,61.72 132.95,61.61 132.44,61.61 132.32,61.49 132.32,61.14 132.44,61.02 132.95,61.02 133.07,60.91 133.07,38.76 132.45,38.14 132.45,34.96 v2(131.76,34.27)
  BOTTOM w0.076: v2(124.33,72.08) 124.3,72.05 122.48,72.05 121,73.53 UH1.M1
  BOTTOM w0.102: v2(131.76,34.27) 131.4,33.91 JDIMM1.236
DDR_A_D58: length 53.7
  IN3 w0.117: v2(122.22,75.96) 122.4,75.78 124.66,75.78 125.94,74.51 127.81,74.51 135.54,66.78 135.54,58.15 135.66,58.03 135.97,58.03 136.09,57.92 136.09,57.57 135.97,57.45 135.66,57.45 135.54,57.33 135.54,56.98 135.66,56.87 135.97,56.87 136.09,56.75 136.09,56.4 135.97,56.28 135.66,56.28 135.54,56.16 135.54,55.81 135.66,55.7 135.97,55.7 136.09,55.58 136.09,55.23 135.97,55.11 135.66,55.11 135.54,55 135.54,54.65 135.66,54.53 135.97,54.53 136.09,54.41 136.09,54.06 135.97,53.94 135.66,53.94 135.54,53.83 135.54,53.48 135.66,53.36 135.97,53.36 136.09,53.24 136.09,52.89 135.97,52.78 135.66,52.78 135.54,52.66 135.54,52.31 135.66,52.19 135.97,52.19 136.09,52.08 136.09,51.72 135.97,51.61 135.66,51.61 135.54,51.49 135.54,50.54 136.09,49.99 136.09,39.16 135.74,38.81 v2(135.67,38.81)
  BOTTOM w0.076: UH1.L4 v2(122.22,75.96)
  BOTTOM w0.102: v2(135.67,38.81) 135.5,38.81 134.65,39.65 JDIMM1.249
DDR_A_D59: length 53.7
  IN3 w0.117: v2(135.7,34.94) 134.92,35.72 134.92,40.41 135.41,40.9 135.41,42.55 135.29,42.67 135.1,42.67 134.98,42.78 134.98,43.13 135.1,43.25 135.29,43.25 135.41,43.37 135.41,43.72 135.29,43.83 135.1,43.83 134.98,43.95 134.98,44.3 135.1,44.42 135.29,44.42 135.41,44.54 135.41,45.5 135.29,45.62 135.02,45.62 134.9,45.73 134.9,46.09 135.02,46.2 135.29,46.2 135.41,46.32 135.41,46.67 135.29,46.79 135.02,46.79 134.9,46.9 134.9,66.52 127.57,73.84 124.81,73.84 124.14,74.51 122.87,74.51 122.4,74.04 v2(122.2,74.04)
  BOTTOM w0.076: v2(122.2,74.04) 122.04,74.04 UH1.L1
  BOTTOM w0.102: JDIMM1.250 134.9,33.71 134.92,33.72 134.92,34.16 v2(135.7,34.94)
DDR_A_D60: length 54.2
  IN3 w0.076: 124.53,71.15 121,74.68 121,75.57 v2(120.59,75.98)
  IN3 w0.117: v2(131.71,38.36) 132.43,39.08 132.43,52.89 131.55,53.77 131.55,54.22 131.67,54.33 132.31,54.33 132.43,54.45 132.43,54.8 132.31,54.92 131.67,54.92 131.55,55.03 131.55,55.39 131.67,55.5 132.31,55.5 132.43,55.62 132.43,55.97 132.31,56.09 131.67,56.09 131.55,56.2 131.55,66.45 126.85,71.15 124.53,71.15
  BOTTOM w0.076: UH1.M5 v2(120.59,75.98)
  BOTTOM w0.102: JDIMM1.232 130.4,34.39 132.17,36.16 132.17,37.9 v2(131.71,38.36)
DDR_A_D61: length 54.1
  IN3 w0.117: v2(124.63,71.57) 126.9,71.57 131.87,66.59 131.87,60.66 131.99,60.54 132.63,60.54 132.75,60.43 132.75,60.08 132.63,59.96 131.99,59.96 131.87,59.84 131.87,59.49 131.99,59.37 132.63,59.37 132.75,59.26 132.75,58.91 132.63,58.79 131.99,58.79 131.87,58.67 131.87,58.32 131.99,58.21 132.63,58.21 132.75,58.09 132.75,57.74 132.63,57.62 131.99,57.62 131.87,57.51 131.87,57.06 132.75,56.18 132.75,38.89 132.13,38.28 132.13,37.5 v2(131.71,37.07)
  BOTTOM w0.076: UH1.M2 120.68,74.07 120.68,73.55 122.66,71.57 v2(124.63,71.57)
  BOTTOM w0.102: v2(131.71,37.07) 131.16,37.62 131.16,39.53 130.65,40.03 JDIMM1.233
DDR_A_D62: length 54.1
  IN3 w0.117: v2(122.19,76.67) 122.75,76.11 124.78,76.11 125.39,75.5 128.56,75.5 130.06,74.01 130.06,72.77 135.86,66.97 135.86,60.51 135.98,60.39 136.27,60.39 136.38,60.28 136.38,59.93 136.27,59.81 135.98,59.81 135.86,59.69 135.86,59.02 136.41,58.47 136.41,38.24 v2(135.71,37.54)
  BOTTOM w0.102: v2(135.71,37.54) 135.49,37.54 133.65,39.38 JDIMM1.245 ; v2(122.19,76.67) 122.07,76.67 UH1.L5
DDR_A_D63: length 54
  IN3 w0.117: v2(135.72,36.27) 135.72,36.27 135.25,36.74 135.25,40.21 135.73,40.69 135.73,46.87 135.22,47.38 135.22,47.87 135.34,47.99 135.58,47.99 135.7,48.11 135.7,48.46 135.58,48.57 135.34,48.57 135.22,48.69 135.22,49.04 135.34,49.16 135.58,49.16 135.7,49.27 135.7,49.63 135.58,49.74 135.34,49.74 135.22,49.86 135.22,66.65 127.69,74.18 125.8,74.18 124.8,75.17 124.39,75.17 124.11,74.89 122.79,74.89 122.54,74.65 122.19,74.65 v2(122.18,74.63)
  BOTTOM w0.076: v2(122.18,74.63) 122.16,74.63 121.92,74.38 UH1.L2
  BOTTOM w0.102: JDIMM1.246 133.9,34.52 135.66,36.27 135.72,36.27 v2(135.72,36.27)
DDR_A_DQS0: length 58.8
  IN3 w0.117: v2(72.84,38.29) 72.75,38.37 72.29,38.37 72,38.66 72,57.06 71.87,57.19 71.87,57.88 72.1,58.11 72.1,58.61 71.87,58.84 71.87,59.91 72.25,60.29 72.67,60.29 73.18,59.79 73.34,59.79 73.59,60.03 73.59,60.2 73.02,60.77 73.02,61.14 73.42,61.53 73.79,61.53 74.36,60.96 74.52,60.96 74.77,61.21 74.77,61.38 74.2,61.95 74.2,62.32 74.75,62.86 75.12,62.86 75.35,62.64 75.51,62.64 75.76,62.89 75.76,63.05 75.53,63.28 75.53,63.65 78.57,66.69 81.11,66.69 81.68,66.13 v2(81.82,66.13)
  BOTTOM w0.076: UH1.BP5 88.69,76.11 88.38,76.41 87.89,76.41 87.72,76.25 87.09,76.25 86.82,75.98 86.81,75.98 86.8,75.97
  BOTTOM w0.089: 86.8,75.97 86.63,75.8 86.33,75.8 84.55,74.03 84.55,68.09 82.22,65.76 81.87,65.76 81.82,65.81 v2(81.82,66.13) ; v2(72.84,38.29) 73.04,38.49 73.26,38.49 73.65,38.88 JDIMM1.13
DDR_A_DQS1: length 54.4
  IN3 w0.117: v2(86.83,71.81) 86.77,71.87 86.55,71.87 85.71,71.03 85.71,65.63 78.7,58.62 78.7,47.89 78.44,47.63 77.97,47.63 77.86,47.51 77.86,47.16 77.97,47.04 78.44,47.04 78.7,46.78 78.7,46.23 78.44,45.96 77.97,45.96 77.86,45.85 77.86,45.5 77.97,45.38 78.44,45.38 78.7,45.12 78.7,44.21 77.91,43.42 77.91,42.74 78.19,42.46 78.19,41.67 77.86,41.34 77.86,35.79 78.11,35.54 78.42,35.54 78.54,35.65 v2(78.54,35.97)
  BOTTOM w0.076: UH1.BK3 91.49,75.03 91.29,74.83 91.29,74.26 90.87,73.84 90.87,73.32 90.35,72.8 88.23,72.8 87.44,72.01 87.03,72.01 v2(86.83,71.81)
  BOTTOM w0.089: JDIMM1.34 78.9,33.5 78.75,33.66 78.75,33.88 79.15,34.28 79.15,35.36 78.93,35.58 78.83,35.58 78.54,35.86 v2(78.54,35.97)
DDR_A_DQS2: length 51
  IN3 w0.117: v2(83.37,37.69) 83.37,37.7 83.22,37.86 82.95,37.86 82.69,38.12 82.69,40.23 85.2,42.73 85.2,55.63 85.46,55.89 86.25,55.89 86.37,56.01 86.37,56.36 86.25,56.48 85.46,56.48 85.2,56.74 85.2,57.29 85.46,57.56 86.25,57.56 86.37,57.67 86.37,58.02 86.25,58.14 85.46,58.14 85.2,58.4 85.2,59.32 89.88,64 89.88,66.84 89.72,67 89.62,67 89.55,67 v2(89.42,66.87)
  BOTTOM w0.076: UH1.BF3 93.79,74.75 93.79,72.27 93.59,72.07 93.59,71.23 93.6,71.22 93.6,71.2
  BOTTOM w0.089: 93.6,71.2 93.6,70.67 89.92,66.99 89.54,66.99 v2(89.42,66.87) ; v2(83.37,37.69) 83.57,37.89 83.8,37.89 84,38.09 84,40.02 84.15,40.18 JDIMM1.55
DDR_A_DQS3: length 49
  IN3 w0.117: v2(96.35,71.77) 96.29,71.71 95.69,71.71 95.06,71.08 95.06,69.69 94.17,68.79 94.17,62.34 90.57,58.74 90.57,40.12 91,39.69 91,38.37 90.71,38.08 90.35,38.08 89.6,37.33 89.6,36.03 89.93,35.7 90.32,35.7 90.37,35.7 v2(90.5,35.57)
  BOTTOM w0.076: UH1.BC3 96.38,75.03 96.3,74.96 96.3,72.91 95.93,72.53 95.93,71.68 96.03,71.58 96.16,71.58 v2(96.35,71.77)
  BOTTOM w0.089: JDIMM1.76 89.4,33.58 89.19,33.79 89.19,35.06 89.98,35.85 90.32,35.85 90.5,35.67 v2(90.5,35.57)
DDR_A_DQS4: length 48.7
  IN3 w0.117: v2(118.39,37.86) 118.18,37.65 118.08,37.65 117.97,37.77 117.97,38.9 118.08,39.01 118.11,39.01 118.38,39.28 118.38,39.85 117.99,40.24 117.99,40.7 118.17,40.88 118.37,40.88 118.69,41.21 118.69,42.16 118.47,42.39 118.47,42.85 118.68,43.07 118.68,43.62 118.47,43.83 118.47,44.23 118.68,44.45 118.68,45.11 118.47,45.33 118.47,45.67 118.68,45.89 118.68,46.59 118.47,46.8 118.47,47.36 119.16,48.05 119.16,62.73 118.71,63.18 118.05,63.18 117.82,63.41 117.82,64.07 117.17,64.72 116.79,64.72 116.49,64.42 v2(116.25,64.42)
  BOTTOM w0.076: UH1.AB3 113.66,75.03 113.75,74.95 113.75,72.23 114.2,71.78 114.2,71.77 114.21,71.75
  BOTTOM w0.089: v2(118.39,37.86) 118.17,37.64 117.89,37.64 117.76,37.78 117.76,39.08 117,39.84 117,39.92 117.15,40.08 JDIMM1.179 ; 114.21,71.75 114.57,71.39 114.57,70.12 117.24,67.46 117.24,65.13 116.54,64.42 v2(116.25,64.42)
DDR_A_DQS5: length 48.6
  IN3 w0.117: v2(117.71,69.26) 117.92,69.26 118.11,69.45 118.49,69.45 123.38,64.55 123.38,59.68 123.99,59.07 123.99,41.27 123.33,40.6 123.33,36.13 122.77,35.58 122.47,35.58 v2(122.31,35.42)
  BOTTOM w0.076: UH1.V3 116.26,74.74 116.26,72.31 116.62,71.95 116.62,71.94 116.63,71.92
  BOTTOM w0.089: v2(117.71,69.26) 117.92,69.26 118.06,69.4 118.06,70.49 116.63,71.92 ; JDIMM1.200 122.4,33.61 122.19,33.82 122.19,34.09 121.86,34.42 121.86,35.47 122.04,35.65 122.22,35.65 122.31,35.56 v2(122.31,35.42)
DDR_A_DQS6: length 48.3
  IN3 w0.076: 125.2,68.49 125.18,68.49 125.14,68.53 124.96,68.53 121.23,72.27 121,72.27 120.86,72.12 120.86,71.95 v2(120.95,71.86)
  IN3 w0.117: v2(128.12,38.17) 128.12,37.9 128.21,37.81 128.42,37.81 128.62,38 128.62,38.94 128.4,39.15 128.4,39.65 128.62,39.86 128.62,65.24 125.37,68.49 125.2,68.49
  BOTTOM w0.076: v2(120.95,71.86) 120.87,71.95 120.68,71.95 120.48,71.75 120.21,71.75 119.36,72.6 119.36,72.91 118.78,73.49 118.78,74.96 118.7,75.03 UH1.R3
  BOTTOM w0.089: v2(128.12,38.17) 128.12,37.88 128.03,37.79 127.8,37.79 127.5,38.09 127.5,39.79 127.65,39.95 JDIMM1.221
DDR_A_DQS7: length 54.2
  IN3 w0.117: v2(123.59,73) 123.5,73.09 123.5,73.24 123.64,73.38 123.83,73.38 124.37,72.84 127.16,72.84 133.84,66.16 133.84,42.16 134.18,41.83 134.18,41.18 133.84,40.85 133.84,37.47 133.67,37.29 133.5,37.29 133.3,37.49 v2(133.3,37.65)
  BOTTOM w0.076: v2(123.59,73) 123.5,73.1 123.35,73.1 122.99,72.74 122.08,72.74 121.28,73.53 121.28,74.75 UH1.M3
  BOTTOM w0.089: v2(133.3,37.65) 133.63,37.33 134.11,37.33 134.36,37.08 134.36,36.1 132.78,34.52 132.78,33.71 132.9,33.58 JDIMM1.242
DDR_A_DQS#0: length 58.7
  IN3 w0.117: v2(81.28,65.64) 81.39,65.75 81.39,66.06 81.01,66.44 78.68,66.44 75.78,63.55 75.78,63.38 76.01,63.15 76.01,62.78 75.61,62.39 75.24,62.39 75.01,62.62 74.85,62.62 74.45,62.22 74.45,62.05 75.02,61.48 75.02,61.11 74.63,60.72 74.25,60.72 73.69,61.28 73.52,61.28 73.27,61.04 73.27,60.87 73.84,60.3 73.84,59.93 73.45,59.54 73.07,59.54 72.57,60.04 72.35,60.04 72.12,59.81 72.12,58.94 72.35,58.71 72.35,58 72.12,57.78 72.12,57.29 72.25,57.16 72.25,38.76 72.39,38.62 72.54,38.62 v2(72.85,38.92)
  BOTTOM w0.076: 86.93,75.84 86.94,75.85 86.94,75.86 87.16,76.08 87.79,76.08 87.96,76.25 88.32,76.25 88.63,75.93 88.63,75.82 88.55,75.73 88.39,75.73 UH1.BR5
  BOTTOM w0.089: v2(81.28,65.64) 81.44,65.8 81.57,65.8 81.8,65.57 82.29,65.57 84.73,68.01 84.73,73.95 86.4,75.62 86.71,75.62 86.93,75.84 ; v2(72.85,38.92) 72.85,38.77 72.94,38.67 73.19,38.67 73.47,38.96 73.47,39.81 73.15,40.13 JDIMM1.11
DDR_A_DQS#1: length 54.3
  IN3 w0.117: v2(78.54,35.13) 78.38,35.29 78.01,35.29 77.61,35.69 77.61,41.44 77.94,41.77 77.94,42.35 77.66,42.64 77.66,43.52 78.45,44.31 78.45,45.01 78.33,45.13 77.87,45.13 77.61,45.39 77.61,45.95 77.87,46.21 78.33,46.21 78.45,46.33 78.45,46.68 78.33,46.8 77.87,46.8 77.61,47.06 77.61,47.62 77.87,47.88 78.33,47.88 78.45,47.99 78.45,58.72 85.46,65.73 85.46,71.14 86.5,72.18 86.62,72.18 v2(86.83,72.39)
  BOTTOM w0.076: v2(86.83,72.39) 87.05,72.17 87.37,72.17 88.16,72.97 90.28,72.97 90.7,73.39 90.7,73.91 91.12,74.33 91.12,74.74 UH1.BL3
  BOTTOM w0.089: v2(78.54,35.13) 78.54,35.23 78.7,35.39 78.85,35.39 78.96,35.28 78.96,34.35 78.56,33.95 78.56,33.66 78.4,33.5 JDIMM1.32
DDR_A_DQS#2: length 50.9
  IN3 w0.117: v2(89.42,67.45) 89.62,67.25 89.82,67.25 90.13,66.94 90.13,63.9 85.45,59.22 85.45,58.51 85.57,58.39 86.36,58.39 86.62,58.13 86.62,57.57 86.36,57.31 85.57,57.31 85.45,57.19 85.45,56.84 85.57,56.72 86.36,56.72 86.62,56.46 86.62,55.9 86.36,55.64 85.57,55.64 85.45,55.53 85.45,42.63 82.94,40.12 82.94,38.23 83.06,38.11 83.29,38.11 83.37,38.2 v2(83.37,38.38)
  BOTTOM w0.076: 93.42,71.2 93.42,71.22 93.43,71.23 93.43,72.14 93.63,72.34 93.63,74.96 93.55,75.03 UH1.BG3
  BOTTOM w0.089: v2(83.37,38.38) 83.37,38.19 83.5,38.07 83.72,38.07 83.81,38.16 83.81,39.99 83.65,40.15 JDIMM1.53 ; v2(89.42,67.45) 89.7,67.17 89.85,67.17 93.42,70.74 93.42,71.2
DDR_A_DQS#3: length 49.1
  IN3 w0.117: v2(96.35,71.18) 96.06,71.47 95.79,71.47 95.31,70.98 95.31,69.58 94.42,68.69 94.42,62.24 90.81,58.64 90.81,40.22 91.25,39.79 91.25,38.27 90.81,37.83 90.45,37.83 89.85,37.23 89.85,36.13 90.03,35.95 90.33,35.95 90.51,36.13 v2(90.51,36.33)
  BOTTOM w0.076: UH1.BD3 96.06,75.03 96.14,74.96 96.14,72.98 95.76,72.6 95.76,71.61 95.96,71.42 96.06,71.42 96.3,71.18 v2(96.35,71.18)
  BOTTOM w0.089: v2(90.51,36.33) 90.51,36.23 90.3,36.03 89.9,36.03 89.01,35.14 89.01,33.77 88.9,33.67 JDIMM1.74
DDR_A_DQS#4: length 48.7
  IN3 w0.117: v2(118.39,37.28) 118.26,37.4 117.98,37.4 117.72,37.67 117.72,39 117.98,39.26 118.01,39.26 118.13,39.38 118.13,39.75 117.74,40.14 117.74,40.8 118.07,41.13 118.27,41.13 118.45,41.31 118.45,42.06 118.22,42.28 118.22,42.96 118.44,43.17 118.44,43.51 118.22,43.73 118.22,44.33 118.44,44.55 118.44,45.01 118.22,45.23 118.22,45.78 118.44,45.99 118.44,46.48 118.22,46.7 118.22,47.46 118.91,48.15 118.91,62.62 118.61,62.93 117.94,62.93 117.57,63.31 117.57,63.97 117.07,64.47 116.89,64.47 116.66,64.24 v2(116.66,64.01)
  BOTTOM w0.076: UH1.AA3 113.91,74.76 113.91,72.3 114.31,71.89 114.33,71.89 114.34,71.88
  BOTTOM w0.089: v2(118.39,37.28) 118.2,37.46 117.82,37.46 117.57,37.71 117.57,39.01 116.81,39.77 116.81,39.92 116.65,40.08 JDIMM1.177 ; v2(116.66,64.01) 116.66,64.29 117.42,65.05 117.42,67.53 114.75,70.2 114.75,71.47 114.44,71.78 114.34,71.88
DDR_A_DQS#5: length 48.5
  IN3 w0.117: v2(118.13,68.84) 118.13,69.11 118.21,69.2 118.38,69.2 123.13,64.45 123.13,59.58 123.74,58.97 123.74,41.37 123.08,40.71 123.08,36.24 122.67,35.83 122.41,35.83 122.26,35.99 122.26,36.18 v2(122.31,36.24)
  BOTTOM w0.076: UH1.U3 116.43,74.76 116.43,72.38 116.74,72.07 116.75,72.07 116.76,72.05
  BOTTOM w0.089: v2(122.31,36.24) 122.31,35.93 122.21,35.83 121.96,35.83 121.68,35.55 121.68,34.34 122.01,34.01 122.01,33.77 121.9,33.67 JDIMM1.198 ; v2(118.13,68.84) 118.13,69.21 118.25,69.33 118.25,70.57 117.48,71.34 116.76,72.05
DDR_A_DQS#6: length 48.3
  IN3 w0.076: v2(120.54,72.28) 120.78,72.28 120.94,72.43 121.29,72.43 125.03,68.7 125.14,68.7 125.18,68.74 125.2,68.74
  IN3 w0.117: 125.2,68.74 125.47,68.74 128.86,65.34 128.86,39.76 128.65,39.55 128.65,39.26 128.86,39.04 128.86,37.9 128.52,37.56 128.29,37.56 v2(128.13,37.4)
  BOTTOM w0.076: v2(120.54,72.28) 120.54,72.04 120.41,71.92 120.28,71.92 119.52,72.67 119.52,72.98 118.94,73.56 118.94,74.76 UH1.P3
  BOTTOM w0.089: JDIMM1.219 127.15,39.95 127.31,39.79 127.31,38.02 127.73,37.6 127.93,37.6 v2(128.13,37.4)
DDR_A_DQS#7: length 54.2
  IN3 w0.117: v2(123.14,73.45) 123.36,73.45 123.53,73.62 123.94,73.62 124.47,73.09 127.26,73.09 134.09,66.26 134.09,42.26 134.42,41.93 134.42,41.08 134.09,40.75 134.09,37.36 133.77,37.04 133.47,37.04 v2(133.34,36.91)
  BOTTOM w0.076: UH1.L3 121.45,74.75 121.45,73.6 122.15,72.9 122.93,72.9 123.24,73.21 123.24,73.36 v2(123.14,73.45)
  BOTTOM w0.089: v2(133.34,36.91) 133.58,37.15 134.04,37.15 134.18,37 134.18,36.17 132.6,34.59 132.6,33.72 132.4,33.53 JDIMM1.240
DDR_A_MA0: length 51.2
  IN3 w0.178: v2(107.05,68.35) 107.21,68.35 108.58,66.98 108.58,48.57 107.71,47.69 107.71,40.02 106.92,39.23 106.92,37.63 106.05,36.77 106.05,34.86 106.28,34.64 107.58,34.64 107.76,34.81 107.76,35.43 107.93,35.61 v2(108.32,35.61)
  BOTTOM w0.076: UH1.AH3 108.71,74.76 108.71,73.13 107.66,72.08 107.66,70.23 107.39,69.96 106.9,69.96 106.57,69.64
  BOTTOM w0.17: v2(107.05,68.35) 106.57,68.83 106.57,69.64 ; JDIMM1.144 106.4,35.4 106.62,35.61 v2(108.32,35.61)
DDR_A_MA1: length 46.7
  IN3 w0.178: v2(103.77,75.36) 103.77,76.67 103.59,76.85 103.01,76.85 102.83,76.67 102.83,74.24 103.04,74.03 103.87,74.03 104.51,73.39 104.51,73.17 104.63,73.04 104.63,70.24 105.15,69.73 105.15,65.88 105.6,65.43 105.6,49.98 104.59,48.97 104.59,41.48 103.62,40.51 103.62,38.31 v2(103.65,38.27)
  BOTTOM w0.076: UH1.AP4 v2(103.77,75.36)
  BOTTOM w0.17: v2(103.65,38.27) 103.97,38.58 103.97,39.89 103.65,40.21 JDIMM1.133
DDR_A_MA2: length 51.3
  IN3 w0.178: v2(102.25,63.47) 102.14,63.36 102.14,58.4 101.95,58.22 101.39,58.22 100.11,56.94 100.11,37.13 100.54,36.7 100.54,35.91 101.18,35.27 101.9,35.27 102.81,34.36 103.43,34.36 103.62,34.54 v2(103.62,34.69)
  BOTTOM w0.076: 105.17,72.51 104.62,73.06 104.62,75.2 UH1.AN4
  BOTTOM w0.17: v2(102.25,63.47) 103.87,63.47 105.41,65.01 105.41,72.27 105.17,72.51 ; JDIMM1.132 103.4,33.69 103.61,33.9 104.31,33.9 104.48,34.07 104.48,34.31 104.1,34.69 v2(103.62,34.69)
DDR_A_MA3: length 48.7
  IN3 w0.178: v2(102.19,72.67) 102.19,72.94 102.7,73.45 103.55,73.45 104.12,72.88 104.12,70.03 104.67,69.48 104.67,65.68 105.12,65.23 105.12,50.18 104.11,49.17 104.11,44.92 103.72,44.53 103.72,44.07 104.11,43.68 104.11,41.73 103.13,40.76 103.13,37.38 103.41,37.1 v2(103.64,37.1)
  BOTTOM w0.076: v2(102.19,72.67) 102.35,72.67 102.79,73.1 102.79,74.49 102.9,74.61 102.9,75.84 UH1.AP5
  BOTTOM w0.17: v2(103.64,37.1) 103.51,37.1 103.15,37.46 JDIMM1.131
DDR_A_MA4: length 50.4
  IN3 w0.178: v2(103.62,35.9) 103.38,35.9 103.01,35.52 102.63,35.52 102.24,35.91 102.24,36.79 102.63,37.17 102.63,41.1 103.17,41.64 103.17,45.52 103.59,45.94 103.59,49.34 104.63,50.38 104.63,65.03 104.19,65.48 104.19,69.25 102.99,70.45 102.99,71.04 103.57,71.62 103.57,72.64 103.29,72.92 102.99,72.92 102.71,72.64 102.71,71.99 102.22,71.49 v2(102.12,71.49)
  BOTTOM w0.076: v2(102.12,71.49) 102.58,71.49 103.12,72.03 103.12,74.11 UH1.AP2
  BOTTOM w0.17: JDIMM1.128 102.4,33.53 103.13,34.25 103.13,35.73 103.3,35.9 v2(103.62,35.9)
DDR_A_MA5: length 48.1
  IN3 w0.178: v2(101.65,36.95) 101.72,36.95 102.14,37.37 102.14,41.35 102.65,41.86 102.65,45.86 103.07,46.28 103.07,49.77 103.3,50 103.57,50 104.15,50.58 104.15,51.65 103.88,51.93 103.37,51.93 103.16,52.14 103.16,52.57 103.37,52.78 103.79,52.78 104.15,53.13 104.15,64.83 103.7,65.28 103.7,68.99 102.84,69.85 101.47,69.85 101.28,70.04 101.28,70.53 101.66,70.91 v2(102.12,70.91)
  BOTTOM w0.076: 102.57,70.91 103.4,71.73 UH1.AP1
  BOTTOM w0.17: JDIMM1.126 101.9,33.7 102.65,34.44 102.65,36.67 102.37,36.95 v2(101.65,36.95) ; 102.57,70.91 v2(102.12,70.91)
DDR_A_MA6: length 51.4
  IN3 w0.178: v2(102.12,68.17) 101.67,68.17 101.46,68.39 101.46,69.12 101.67,69.33 102.68,69.33 103.18,68.82 103.18,65.11 103.67,64.63 103.67,57.1 103.06,56.49 103.06,56.07 103.27,55.85 103.46,55.85 103.64,55.68 103.64,55.18 103.46,55 103.27,55 103.06,54.79 103.06,54.36 103.44,53.98 103.44,53.58 102.23,52.37 101.97,52.37 101.67,52.07 101.67,51.61 101.88,51.39 103.33,51.39 103.54,51.18 103.54,50.75 103.33,50.54 101.88,50.54 101.67,50.33 101.67,49.9 101.88,49.69 102.34,49.69 102.55,49.47 102.55,49.05 102.34,48.83 101.88,48.83 101.67,48.62 101.67,48.19 101.88,47.98 102.34,47.98 102.55,47.77 102.55,47.34 102.34,47.13 101.88,47.13 101.67,46.91 101.67,46.49 101.88,46.27 101.88,46.27 102.09,46.06 102.09,45.63 101.88,45.42 101.88,45.42 101.67,45.21 101.67,44.87 102.14,44.4 102.14,42.07 101.65,41.58 v2(101.65,39.29)
  BOTTOM w0.076: UH1.AP3 103.69,74.74 103.69,73.43 103.71,73.4 103.71,71.68 103.26,71.23 103.26,70.78
  BOTTOM w0.17: v2(102.12,68.17) 102.78,68.83 102.78,70.29 103.26,70.78 ; v2(101.65,39.29) 101.72,39.29 102.15,39.72 JDIMM1.127
DDR_A_MA7: length 51.9
  IN3 w0.178: v2(102.19,65.63) 101.83,65.63 101.62,65.42 101.62,59.18 99.59,57.16 99.59,36.91 100.04,36.47 100.04,35.85 99.59,35.41 99.59,33.86 99.81,33.65 100.16,33.65 100.34,33.82 100.34,34.66 100.52,34.84 100.9,34.84 101.1,34.64 101.1,34.48 101.37,34.22 v2(101.65,34.22)
  BOTTOM w0.076: UH1.AN1 104.13,72.26 104.44,71.95 104.44,71.72
  BOTTOM w0.17: 104.44,71.72 104.44,70.36 104.44,70.36 104.44,66.27 103.8,65.63 v2(102.19,65.63) ; JDIMM1.122 100.9,33.75 100.43,34.22 100.43,35.31 100.62,35.5 100.88,35.5 101.13,35.25 101.13,34.61 101.52,34.22 v2(101.65,34.22)
DDR_A_MA8: length 53.4
  IN3 w0.178: v2(101.65,38.12) 101.4,38.12 101.15,38.37 101.15,41.82 101.62,42.29 101.62,44.22 101.15,44.69 101.15,52.64 101.4,52.89 102.02,52.89 102.6,53.47 102.6,54.2 102.27,54.53 102.27,54.93 102.54,55.19 102.54,56.09 102.32,56.3 102.13,56.3 101.8,56.63 101.8,56.94 102.03,57.17 102.76,57.17 103.18,57.59 103.18,64.4 102.68,64.91 102.68,66.12 102.5,66.3 v2(102.19,66.3)
  BOTTOM w0.076: UH1.AN3 103.85,74.76 103.85,73.5 103.92,73.43 103.92,71.69 103.97,71.64 103.97,71.38
  BOTTOM w0.17: v2(102.19,66.3) 103.75,66.3 103.92,66.47 103.92,66.84 103.75,67.01 102.85,67.01 102.68,67.18 102.68,67.52 102.85,67.69 103.8,67.69 103.97,67.86 103.97,68.2 103.8,68.37 103.46,68.37 103.29,68.54 103.29,68.88 103.46,69.05 103.8,69.05 103.97,69.22 103.97,69.57 103.8,69.74 103.6,69.74 103.43,69.91 103.43,70.25 103.6,70.42 103.8,70.42 103.97,70.59 103.97,71.38 ; JDIMM1.125 101.65,39.99 99.63,37.97 99.63,37.42 99.91,37.15 100.34,37.15 101.31,38.12 v2(101.65,38.12)
DDR_A_MA9: length 47.7
  IN3 w0.178: v2(102.11,67.54) 101.68,67.54 101.1,66.97 101.1,66.67 101.33,66.44 101.33,65.95 101.1,65.72 101.1,59.4 99.07,57.37 99.07,36.08 v2(99.12,36.03)
  BOTTOM w0.076: 101.45,70.12 101.45,72.88 102.16,73.59 102.16,74.91 101.62,75.45 UH1.AT4
  BOTTOM w0.17: 101.45,70.12 101.45,68.21 v2(102.11,67.54) ; v2(99.12,36.03) 99.12,38.14 100.65,39.67 JDIMM1.121
DDR_A_MA10: length 50.2
  IN3 w0.178: v2(107.08,72.83) 107.49,72.83 107.95,73.28 108.35,73.28 108.52,73.12 108.52,71.06 109.15,70.42 109.15,68.46 110.03,67.58 110.03,56.41 110.86,55.58 110.86,48.74 109.19,47.07 109.19,34.55 109.01,34.37 v2(108.31,34.37)
  BOTTOM w0.076: UH1.AH2 108.13,74.09 108.13,73.63 107.38,72.87 107.13,72.87 v2(107.08,72.83)
  BOTTOM w0.17: JDIMM1.146 108.9,33.78 109.43,34.3 109.43,35.45 109.26,35.63 109.01,35.63 108.8,35.42 108.8,34.61 108.56,34.37 v2(108.31,34.37)
DDR_A_MA11: length 52.5
  IN3 w0.178: v2(101.64,35.75) 101.43,35.75 101.05,36.13 101.05,37.02 100.63,37.45 100.63,53.2 100.84,53.41 101.8,53.41 102.02,53.62 102.02,54.05 101.8,54.26 100.84,54.26 100.63,54.48 100.63,54.9 100.84,55.12 101.6,55.12 101.81,55.33 101.81,55.76 101.6,55.97 100.84,55.97 100.63,56.18 100.63,56.73 101.63,57.72 102.32,57.72 102.7,58.11 102.7,64.17 102.52,64.35 v2(102.23,64.35)
  BOTTOM w0.076: UH1.AN2 104.43,74.08 104.43,72.57 104.56,72.45
  BOTTOM w0.17: 104.56,72.45 104.94,72.07 104.94,65.6 103.69,64.35 v2(102.23,64.35) ; v2(101.64,35.75) 101.48,35.75 101.05,36.19 100.29,36.19 99.96,35.85 99.96,34.03 100.4,33.58 JDIMM1.120
DDR_A_MA12: length 51.3
  IN3 w0.178: v2(99.57,72.73) 99.59,72.75 99.59,73.38 99.93,73.71 100.47,73.71 100.74,73.44 100.74,71.45 100.31,71.03 100.31,67.71 100.07,67.46 100.07,59.83 98.04,57.8 98.04,41.75 97.65,41.36 97.65,40.9 98.04,40.51 98.04,40.05 97.65,39.66 97.65,39.19 98.04,38.8 98.04,37.95 98.04,37.95 98.04,37.49 98.04,37.48 98.04,36.79 97.71,36.46 v2(97.14,36.46)
  BOTTOM w0.076: UH1.AU4 100.88,75.49 100.44,75.04 100.44,73.52 99.65,72.73 v2(99.57,72.73)
  BOTTOM w0.17: v2(97.14,36.46) 98.01,36.46 98.43,36.89 98.43,38.14 100.15,39.86 JDIMM1.119
DDR_A_MA13: length 54.7
  IN3 w0.178: v2(113.46,34.07) 113.55,34.07 113.66,34.18 114.79,34.18 114.92,34.05 114.92,33.39 114.79,33.26 112.76,33.26 112.63,33.39 112.63,35.04 111.89,35.78 111.89,36.39 112.07,36.57 112.46,36.57 112.64,36.74 112.64,37.1 112.46,37.28 112.07,37.28 111.89,37.45 111.89,41.82 112.42,42.34 112.42,43.64 112.29,43.77 111.97,43.77 111.8,43.95 111.8,44.3 111.97,44.48 112.29,44.48 112.42,44.61 112.42,46.88 113.29,47.75 113.29,56.56 112.51,57.34 112.51,68.69 112.07,69.13 112.07,71.8 111.9,71.98 111.65,71.98 111.27,71.6 v2(111.27,71.11)
  BOTTOM w0.076: v2(111.27,71.11) 111.39,71.23 111.39,73.93 111.23,74.09 111.23,74.5 110.94,74.79 UH1.AE3
  BOTTOM w0.17: v2(113.46,34.07) 112.21,34.07 111.9,33.77 JDIMM1.158
DDR_A_PAR: length 53.6
  IN3 w0.178: v2(107.08,68.97) 107.28,68.97 109.06,67.18 109.06,48.34 108.19,47.47 108.19,39.82 107.4,39.03 107.4,37.43 106.54,36.57 106.54,35.5 106.72,35.32 107.1,35.32 107.27,35.5 107.27,35.98 108.19,36.9 v2(108.28,36.9)
  BOTTOM w0.076: 108.46,71.88 108.87,72.29 108.87,74.74 UH1.AG3
  BOTTOM w0.17: v2(108.28,36.9) 107.88,36.9 107.65,36.68 106.39,36.68 106.22,36.85 106.22,37.54 106.39,37.71 107.06,37.71 107.23,37.88 107.23,38.22 107.06,38.39 106.4,38.39 106.23,38.56 106.23,39.96 106.15,40.03 JDIMM1.143 ; v2(107.08,68.97) 107.86,68.97 108.11,69.22 108.11,71.53 108.46,71.88
