# Allegro board Dell Inspiron 15 Gaming 7566 Compal LA-D991P BCV00 Rev1.0 BoardView.brd (continued)
## Nets (continued)
DDR_A_D11: JDIMM1.42 UH1.BM1
DDR_A_D12: JDIMM1.24 UH1.BK4
DDR_A_D13: JDIMM1.25 UH1.BL5
DDR_A_D14: JDIMM1.38 UH1.BK1
DDR_A_D15: JDIMM1.37 UH1.BK2
DDR_A_D16: JDIMM1.50 UH1.BG5
DDR_A_D17: JDIMM1.49 UH1.BG1
DDR_A_D18: JDIMM1.62 UH1.BF2
DDR_A_D19: JDIMM1.63 UH1.BF5
DDR_A_D20: JDIMM1.46 UH1.BG4
DDR_A_D21: JDIMM1.45 UH1.BG2
DDR_A_D22: JDIMM1.58 UH1.BF1
DDR_A_D23: JDIMM1.59 UH1.BF4
DDR_A_D24: JDIMM1.70 UH1.BD2
DDR_A_D25: JDIMM1.71 UH1.BD1
DDR_A_D26: JDIMM1.83 UH1.BC4
DDR_A_D27: JDIMM1.84 UH1.BC5
DDR_A_D28: JDIMM1.66 UH1.BD5
DDR_A_D29: JDIMM1.67 UH1.BD4
DDR_A_D30: JDIMM1.79 UH1.BC1
DDR_A_D31: JDIMM1.80 UH1.BC2
DDR_A_D32: JDIMM1.174 UH1.AB1
DDR_A_D33: JDIMM1.173 UH1.AB2
DDR_A_D34: JDIMM1.187 UH1.AA4
DDR_A_D35: JDIMM1.186 UH1.AA5
DDR_A_D36: JDIMM1.170 UH1.AB5
DDR_A_D37: JDIMM1.169 UH1.AB4
DDR_A_D38: JDIMM1.183 UH1.AA2
DDR_A_D39: JDIMM1.182 UH1.AA1
DDR_A_D40: JDIMM1.195 UH1.V4
DDR_A_D41: JDIMM1.194 UH1.V1
DDR_A_D42: JDIMM1.207 UH1.U5
DDR_A_D43: JDIMM1.208 UH1.U1
DDR_A_D44: JDIMM1.191 UH1.V5
DDR_A_D45: JDIMM1.190 UH1.V2
DDR_A_D46: JDIMM1.203 UH1.U4
DDR_A_D47: JDIMM1.204 UH1.U2
DDR_A_D48: JDIMM1.216 UH1.R1
DDR_A_D49: JDIMM1.215 UH1.R4
DDR_A_D50: JDIMM1.228 UH1.P1
DDR_A_D51: JDIMM1.229 UH1.P5
DDR_A_D52: JDIMM1.211 UH1.R5
DDR_A_D53: JDIMM1.212 UH1.R2
DDR_A_D54: JDIMM1.224 UH1.P2
DDR_A_D55: JDIMM1.225 UH1.P4
DDR_A_D56: JDIMM1.237 UH1.M4
DDR_A_D57: JDIMM1.236 UH1.M1
DDR_A_D58: JDIMM1.249 UH1.L4
DDR_A_D59: JDIMM1.250 UH1.L1
DDR_A_D60: JDIMM1.232 UH1.M5
DDR_A_D61: JDIMM1.233 UH1.M2
DDR_A_D62: JDIMM1.245 UH1.L5
DDR_A_D63: JDIMM1.246 UH1.L2
DDR_A_DQS0: JDIMM1.13 UH1.BP5
DDR_A_DQS1: JDIMM1.34 UH1.BK3
DDR_A_DQS2: JDIMM1.55 UH1.BF3
DDR_A_DQS3: JDIMM1.76 UH1.BC3
DDR_A_DQS4: JDIMM1.179 UH1.AB3
DDR_A_DQS5: JDIMM1.200 UH1.V3
DDR_A_DQS6: JDIMM1.221 UH1.R3
DDR_A_DQS7: JDIMM1.242 UH1.M3
DDR_A_DQS#0: JDIMM1.11 UH1.BR5
DDR_A_DQS#1: JDIMM1.32 UH1.BL3
DDR_A_DQS#2: JDIMM1.53 UH1.BG3
DDR_A_DQS#3: JDIMM1.74 UH1.BD3
DDR_A_DQS#4: JDIMM1.177 UH1.AA3
DDR_A_DQS#5: JDIMM1.198 UH1.U3
DDR_A_DQS#6: JDIMM1.219 UH1.P3
DDR_A_DQS#7: JDIMM1.240 UH1.L3
DDR_A_MA0: JDIMM1.144 UH1.AH3
DDR_A_MA1: JDIMM1.133 UH1.AP4
DDR_A_MA2: JDIMM1.132 UH1.AN4
DDR_A_MA3: JDIMM1.131 UH1.AP5
DDR_A_MA4: JDIMM1.128 UH1.AP2
DDR_A_MA5: JDIMM1.126 UH1.AP1
DDR_A_MA6: JDIMM1.127 UH1.AP3
DDR_A_MA7: JDIMM1.122 UH1.AN1
DDR_A_MA8: JDIMM1.125 UH1.AN3
DDR_A_MA9: JDIMM1.121 UH1.AT4
DDR_A_MA10: JDIMM1.146 UH1.AH2
DDR_A_MA11: JDIMM1.120 UH1.AN2
DDR_A_MA12: JDIMM1.119 UH1.AU4
DDR_A_MA13: JDIMM1.158 UH1.AE3
DDR_A_PAR: JDIMM1.143 UH1.AG3
DDR_A_RAS#: JDIMM1.152 UH1.AH4
DDR_A_WE#: JDIMM1.151 UH1.AG4
DDR_B_ACT#: JDIMM2.114 UH1.AT9
DDR_B_ALERT#: JDIMM2.116 UH1.AR8
DDR_B_BG0: JDIMM2.115 UH1.AR9
DDR_B_BG1: JDIMM2.113 UH1.AR7
DDR_B_BS0: JDIMM2.150 UH1.AH8
DDR_B_BS1: JDIMM2.145 UH1.AH9
DDR_B_CAS#: JDIMM2.156 UH1.AF8
DDR_B_D0: JDIMM2.8 UH1.BT11
DDR_B_D1: JDIMM2.7 UH1.BR11
DDR_B_D2: JDIMM2.20 UH1.BR8
DDR_B_D3: JDIMM2.21 UH1.BP8
DDR_B_D4: JDIMM2.4 UH1.BP11
DDR_B_D5: JDIMM2.3 UH1.BN11
DDR_B_D6: JDIMM2.16 UH1.BT8
DDR_B_D7: JDIMM2.17 UH1.BN8
DDR_B_D8: JDIMM2.28 UH1.BL11
DDR_B_D9: JDIMM2.29 UH1.BL8
DDR_B_D10: JDIMM2.41 UH1.BJ8
DDR_B_D11: JDIMM2.42 UH1.BJ10
DDR_B_D12: JDIMM2.24 UH1.BL12
DDR_B_D13: JDIMM2.25 UH1.BL7
DDR_B_D14: JDIMM2.38 UH1.BJ11
DDR_B_D15: JDIMM2.37 UH1.BJ7
DDR_B_D16: JDIMM2.50 UH1.BG11
DDR_B_D17: JDIMM2.49 UH1.BG10
DDR_B_D18: JDIMM2.62 UH1.BF11
DDR_B_D19: JDIMM2.63 UH1.BF8
DDR_B_D20: JDIMM2.46 UH1.BG7
DDR_B_D21: JDIMM2.45 UH1.BG8
DDR_B_D22: JDIMM2.58 UH1.BF10
DDR_B_D23: JDIMM2.59 UH1.BF7
DDR_B_D24: JDIMM2.70 UH1.BC11
DDR_B_D25: JDIMM2.71 UH1.BC8
DDR_B_D26: JDIMM2.83 UH1.BB11
DDR_B_D27: JDIMM2.84 UH1.BB7
DDR_B_D28: JDIMM2.66 UH1.BC10
DDR_B_D29: JDIMM2.67 UH1.BC7
DDR_B_D30: JDIMM2.79 UH1.BB10
DDR_B_D31: JDIMM2.80 UH1.BB8
DDR_B_D32: JDIMM2.174 UH1.AC11
DDR_B_D33: JDIMM2.173 UH1.AC7
DDR_B_D34: JDIMM2.187 UH1.AA11
DDR_B_D35: JDIMM2.186 UH1.AA7
DDR_B_D36: JDIMM2.170 UH1.AC10
DDR_B_D37: JDIMM2.169 UH1.AC8
DDR_B_D38: JDIMM2.183 UH1.AA10
DDR_B_D39: JDIMM2.182 UH1.AA8
DDR_B_D40: JDIMM2.195 UH1.W8
DDR_B_D41: JDIMM2.194 UH1.W7
DDR_B_D42: JDIMM2.207 UH1.V10
DDR_B_D43: JDIMM2.208 UH1.V11
DDR_B_D44: JDIMM2.191 UH1.W11
DDR_B_D45: JDIMM2.190 UH1.W10
DDR_B_D46: JDIMM2.203 UH1.V8
DDR_B_D47: JDIMM2.204 UH1.V7
DDR_B_D48: JDIMM2.216 UH1.R11
DDR_B_D49: JDIMM2.215 UH1.R7
DDR_B_D50: JDIMM2.228 UH1.P7
DDR_B_D51: JDIMM2.229 UH1.P11
DDR_B_D52: JDIMM2.211 UH1.R8
DDR_B_D53: JDIMM2.212 UH1.R10
DDR_B_D54: JDIMM2.224 UH1.P8
DDR_B_D55: JDIMM2.225 UH1.P10
DDR_B_D56: JDIMM2.237 UH1.M7
DDR_B_D57: JDIMM2.236 UH1.M11
DDR_B_D58: JDIMM2.249 UH1.L11
DDR_B_D59: JDIMM2.250 UH1.L7
DDR_B_D60: JDIMM2.232 UH1.M10
DDR_B_D61: JDIMM2.233 UH1.M8
DDR_B_D62: JDIMM2.245 UH1.L10
DDR_B_D63: JDIMM2.246 UH1.L8
DDR_B_DQS0: JDIMM2.13 UH1.BR9
DDR_B_DQS1: JDIMM2.34 UH1.BJ9
DDR_B_DQS2: JDIMM2.55 UH1.BF9
DDR_B_DQS3: JDIMM2.76 UH1.BB9
DDR_B_DQS4: JDIMM2.179 UH1.AA9
DDR_B_DQS5: JDIMM2.200 UH1.V9
DDR_B_DQS6: JDIMM2.221 UH1.P9
DDR_B_DQS7: JDIMM2.242 UH1.L9
DDR_B_DQS#0: JDIMM2.11 UH1.BP9
DDR_B_DQS#1: JDIMM2.32 UH1.BL9
DDR_B_DQS#2: JDIMM2.53 UH1.BG9
DDR_B_DQS#3: JDIMM2.74 UH1.BC9
DDR_B_DQS#4: JDIMM2.177 UH1.AC9
DDR_B_DQS#5: JDIMM2.198 UH1.W9
DDR_B_DQS#6: JDIMM2.219 UH1.R9
DDR_B_DQS#7: JDIMM2.240 UH1.M9
DDR_B_MA0: JDIMM2.144 UH1.AJ9
DDR_B_MA1: JDIMM2.133 UH1.AK6
DDR_B_MA2: JDIMM2.132 UH1.AK5
DDR_B_MA3: JDIMM2.131 UH1.AL5
DDR_B_MA4: JDIMM2.128 UH1.AL6
DDR_B_MA5: JDIMM2.126 UH1.AM6
DDR_B_MA6: JDIMM2.127 UH1.AN7
DDR_B_MA7: JDIMM2.122 UH1.AN10
DDR_B_MA8: JDIMM2.125 UH1.AN8
DDR_B_MA9: JDIMM2.121 UH1.AR11
DDR_B_MA10: JDIMM2.146 UH1.AH7
DDR_B_MA11: JDIMM2.120 UH1.AN11
DDR_B_MA12: JDIMM2.119 UH1.AR10
DDR_B_MA13: JDIMM2.158 UH1.AF9
DDR_B_PAR: JDIMM2.143 UH1.AJ7
DDR_B_RAS#: JDIMM2.152 UH1.AH10
DDR_B_WE#: JDIMM2.151 UH1.AH11
DDR_CKE0_DIMMA: JDIMM1.109 UH1.AT1
DDR_CKE1_DIMMA: JDIMM1.110 UH1.AT2
DDR_CKE2_DIMMB: JDIMM2.109 UH1.AT8
DDR_CKE3_DIMMB: JDIMM2.110 UH1.AT10
DDR_CS0_DIMMA#: JDIMM1.149 UH1.AD5
DDR_CS1_DIMMA#: JDIMM1.157 UH1.AE2
DDR_CS2_DIMMB#: JDIMM2.149 UH1.AF11
DDR_CS3_DIMMB#: JDIMM2.157 UH1.AE7
DDR_VTT_PG_CTRL: UC1.2 UH1.BT13
DGPU_HOLD_RST#: RV58.2 UH2.AL36 UV14.1
DGPU_PEX_RST#: QV88.2 RV39.2 RV40.1 RV208.2 RV571.1 RV573.1 UV18.4
DGPU_PEX_RST#_R: RV40.2 UV1.AJ12
DGPU_PWR_EN: QV3.2 RH127.1 RH129.1 UH2.AJ39
DGPU_PWR_EN#: QV3.6 RV534.2 RV578.1
DGPU_PWR_EN#_R: CV603.1 QV85.2 QZ7.2 QZ7.5 QZ8.2 RV578.2
DGPU_PWRGD_EC: RH500.1 UE1.24 UH2.BD24
DGPU_PWROK: PR1026.2 RH86.2 UH2.AJ38
DH_CHG: PQ304.4 PU300.26
DISPOFF#: JEDP1.17 RV536.1 RV566.2 UZ23.1
DL_CHG: PQ305.4 PU300.23
DMI_CRX_PTX_N0: UH1.E8 UH2.C27
DMI_CRX_PTX_N1: UH1.F6 UH2.B28
DMI_CRX_PTX_N2: UH1.E5 UH2.B29
DMI_CRX_PTX_N3: UH1.J9 UH2.B30
DMI_CRX_PTX_P0: UH1.D8 UH2.B27
DMI_CRX_PTX_P1: UH1.E6 UH2.A28
DMI_CRX_PTX_P2: UH1.D5 UH2.C29
DMI_CRX_PTX_P3: UH1.J8 UH2.A30
DMI_CTX_PRX_N0: UH1.A8 UH2.L27
DMI_CTX_PRX_N1: UH1.B6 UH2.E24
DMI_CTX_PRX_N2: UH1.A5 UH2.G27
DMI_CTX_PRX_N3: UH1.B4 UH2.L29
DMI_CTX_PRX_P0: UH1.B8 UH2.N27
DMI_CTX_PRX_P1: UH1.C6 UH2.G24
DMI_CTX_PRX_P2: UH1.B5 UH2.E26
DMI_CTX_PRX_P3: UH1.D4 UH2.K29
DMIC_CLK: CA30.1 DA1.2 EC5206.1 RA28.1 RA37.2 RZ41.2
DMIC_CLK_CAM: JCAM1.3 RZ41.1
DMIC_CLK_R: HDA1.3 RA28.2
DMIC_DAT: DA1.3 EC5205.1 RA27.1 RA36.2 RZ42.2
DMIC_DATA_CAM: JCAM1.4 RZ42.1
DMIC_DATA_R: CA62.1 HDA1.2 RA27.2
DTH_CSCL: RM14.2 RM18.1 T4936.1(TP-1) UM1.E6
DTH_CSDA: RM16.2 RM17.1 T4937.1(TP-1) UM1.F6
DTH_PDB: RM5.1 RM27.2 UM1.C3
DTH_RST#: CM41.1 RM6.2 UM1.B8
DTH_SPI_CK_OUT: RM9.1 UM1.D2 UM2.6
DTH_SPI_CS: RM7.1 UM1.C1 UM2.1
DTH_SPI_D_IN: UM1.C2 UM2.2
DTH_SPI_D_OUT: UM1.D1 UM2.5
DTH_SPI_WR_PROT: RM8.1 UM1.E2 UM2.3
DTH_VDD12: CM9.1 CM10.1 CM11.1 CM12.1 CM13.1 LM2.2 UM1.D6 UM1.F5
DTH_VDD12_ON: RM21.2 UM1.G8 UZ22.3
DTH_VDD33: CM2.1 CM3.1 CM4.1 CM5.1 LM1.2 UM1.B2 UM1.G2 UM1.G4
DTH_VDDA12: CM23.1 CM24.1 CM25.1 LM3.2 UM1.F4
DTH_VDDRX12: CM27.1 CM28.1 CM29.1 CM30.1 CM31.1 CM32.1 CM33.1 LM4.2 UM1.B4 UM1.B5 UM1.B7
DTH_VDDTX12: CM34.1 CM35.1 CM36.1 CM38.1 CM39.1 LM5.2 UM1.G5 UM1.G7
DTH_XTLI: CM43.1 UM1.E8 YM1.1
DTH_XTLO: CM44.1 UM1.F8 YM1.3
E51_TX1: JNGFF1.36 RN3.2
E51_TX2: JNGFF1.30 RN4.1 RN5.2
EAPD#: D2.3 HDA1.4 RA70.1
EC_AGND: CE81.2 CE87.2 CE98.2 CE104.2 RE14.1 RE67.2 RE124.1 UE1.112
EC_MUTE#: D2.2 HDA1.47 RA23.2 RE58.2
EC_MUTE#_R: RE58.1 UE1.119
EC_SPI_CLK: RE40.2 UE1.32
EC_SPI_CLK_R: RE40.1 RE126.1 RH507.2
EC_SPI_CS#: RE59.2 UE1.27
EC_SPI_CS#_R: RE59.1 RH101.2 UH8.1
EC_SPI_SI: RE41.2 UE1.28
EC_SPI_SI_R: RE41.1 RE128.1 RH509.2
EC_SPI_SO: RE42.2 UE1.29
EC_SPI_SO_R: RE42.1 RE127.1 RH508.2
EC_WAKE#: RH11.2 UE1.35
EDP_AUXN: CV591.1 UH1.B26
EDP_AUXN_C: CV591.2 RV552.1
EDP_AUXN_R: JEDP1.26 RV552.2
EDP_AUXP: CV592.1 UH1.C26
EDP_AUXP_C: CV592.2 RV549.1
EDP_AUXP_R: JEDP1.25 RV549.2
EDP_COMP: RH30.1 UH1.D37
EDP_DISP_UTIL: RH20.1 UH1.A33
EDP_HPD: JEDP1.18 RV551.1 UH2.BD7
EDP_TXN0: CV581.1 UH1.E29
EDP_TXN0_C: CV581.2 RV539.1
EDP_TXN0_R: JEDP1.29 RV539.2
EDP_TXN1: CV586.1 UH1.E28
EDP_TXN1_C: CV586.2 RV541.1
EDP_TXN1_R: JEDP1.32 RV541.2
EDP_TXN2: CV588.1 UH1.B29
EDP_TXN2_C: CV588.2 RV543.1
EDP_TXN2_R: JEDP1.35 RV543.2
EDP_TXN3: CV590.1 UH1.B28
EDP_TXN3_C: CV590.2 RV546.1
EDP_TXN3_R: JEDP1.38 RV546.2
EDP_TXP0: CV580.1 UH1.D29
EDP_TXP0_C: CV580.2 RV540.1
EDP_TXP0_R: JEDP1.28 RV540.2
EDP_TXP1: CV585.1 UH1.F28
EDP_TXP1_C: CV585.2 RV542.1
EDP_TXP1_R: JEDP1.31 RV542.2
EDP_TXP2: CV587.1 UH1.A29
EDP_TXP2_C: CV587.2 RV544.1
EDP_TXP2_R: JEDP1.34 RV544.2
EDP_TXP3: CV589.1 UH1.C28
EDP_TXP3_C: CV589.2 RV548.1
EDP_TXP3_R: JEDP1.37 RV548.2
EDPVDD: PJP35.1 UZ8.1
EN_0.6V: PC518.1 PR509.2 PR510.1 PR511.2 PU500.2
EN_1.2V: PC517.1 PR507.2 PR508.1 PU500.1
EN_1VALWP: PC612.1 PR603.2 PR604.1 PU600.11
EN_+0.95VSP: PC711.1 PR702.2 PR704.1 PU700.11
EN_+1.05VSP: PC812.1 PR804.2 PR806.2 PR807.1 PU800.11
EN_+1.35VS_VGAP: PC906.1 PR903.2 PU900.3
ENVDD: DV3.1 RZ40.1 UZ8.4
ENVDD_PCH: DV3.3 UH2.W42
FAN1_PWM: Q12.3 RE121.2 UE1.47
FAN1_TACH: CE99.1 DE7.2 RE81.2 UE1.40
FAN2_PWM: Q13.3 RE122.2 UE1.34
FAN2_TACH: CE100.1 DE9.2 RE83.2 UE1.41
FB_1VALWP: PC606.2 PR602.2 PR605.1 PU600.14
FB_3V: PC401.2 PR401.2 PR403.2 PU400.4
FB_5V: PC402.1 PR402.1 PR404.1 PU400.2
FB_+0.95VSP: PC712.2 PR706.2 PR708.1 PU700.14
FB_+1.05VSP: PC806.2 PR805.2 PR808.1 PU800.14
FB_+1.35VS_VGAP: PR906.1 PR907.1 PU900.4
FBA_ABI#_H: UV1.Y29 UV7.J4
FBA_ABI#_L: UV1.V28 UV6.J4
FBA_CAS#_H: UV1.V31 UV7.G3
FBA_CAS#_L: UV1.Y32 UV6.L3
FBA_CKE_H: RV98.2 UV1.Y33 UV7.J3
FBA_CKE_L: RV95.2 UV1.V33 UV6.J3
FBA_CLK0: RV123.2 UV1.R30 UV6.J12
FBA_CLK0#: RV123.1 UV1.R31 UV6.J11
FBA_CLK1: RV175.2 UV1.AB31 UV7.J12
FBA_CLK1#: RV175.1 UV1.AC31 UV7.J11
FBA_CS#_H: UV1.AA31 UV7.L12
FBA_CS#_L: UV1.U30 UV6.G12
FBA_D0: UV1.L28 UV6.A4
FBA_D1: UV1.M29 UV6.A2
FBA_D2: UV1.L29 UV6.B4
FBA_D3: UV1.M28 UV6.B2
FBA_D4: UV1.N31 UV6.E4
FBA_D5: UV1.P29 UV6.E2
FBA_D6: UV1.R29 UV6.F4
FBA_D7: UV1.P28 UV6.F2
FBA_D8: UV1.J28 UV6.A11
FBA_D9: UV1.H29 UV6.A13
FBA_D10: UV1.J29 UV6.B11
FBA_D11: UV1.H28 UV6.B13
FBA_D12: UV1.G29 UV6.E11
FBA_D13: UV1.E31 UV6.E13
FBA_D14: UV1.E32 UV6.F11
FBA_D15: UV1.F30 UV6.F13
FBA_D16: UV1.C34 UV6.U11
FBA_D17: UV1.D32 UV6.U13
FBA_D18: UV1.B33 UV6.T11
FBA_D19: UV1.C33 UV6.T13
FBA_D20: UV1.F33 UV6.N11
FBA_D21: UV1.F32 UV6.N13
FBA_D22: UV1.H33 UV6.M11
FBA_D23: UV1.H32 UV6.M13
FBA_D24: UV1.P34 UV6.U4
FBA_D25: UV1.P32 UV6.U2
FBA_D26: UV1.P31 UV6.T4
FBA_D27: UV1.P33 UV6.T2
FBA_D28: UV1.L31 UV6.N4
FBA_D29: UV1.L34 UV6.N2
FBA_D30: UV1.L32 UV6.M4
FBA_D31: UV1.L33 UV6.M2
FBA_D32: UV1.AG28 UV7.U4
FBA_D33: UV1.AF29 UV7.U2
FBA_D34: UV1.AG29 UV7.T4
FBA_D35: UV1.AF28 UV7.T2
FBA_D36: UV1.AD30 UV7.N4
FBA_D37: UV1.AD29 UV7.N2
FBA_D38: UV1.AC29 UV7.M4
FBA_D39: UV1.AD28 UV7.M2
FBA_D40: UV1.AJ29 UV7.U11
FBA_D41: UV1.AK29 UV7.U13
FBA_D42: UV1.AJ30 UV7.T11
FBA_D43: UV1.AK28 UV7.T13
FBA_D44: UV1.AM29 UV7.N11
FBA_D45: UV1.AM31 UV7.N13
FBA_D46: UV1.AN29 UV7.M11
FBA_D47: UV1.AM30 UV7.M13
FBA_D48: UV1.AN31 UV7.A11
FBA_D49: UV1.AN32 UV7.A13
FBA_D50: UV1.AP30 UV7.B11
FBA_D51: UV1.AP32 UV7.B13
FBA_D52: UV1.AM33 UV7.E11
FBA_D53: UV1.AL31 UV7.E13
FBA_D54: UV1.AK33 UV7.F11
FBA_D55: UV1.AK32 UV7.F13
FBA_D56: UV1.AD34 UV7.A4
FBA_D57: UV1.AD32 UV7.A2
FBA_D58: UV1.AC30 UV7.B4
FBA_D59: UV1.AD33 UV7.B2
FBA_D60: UV1.AF31 UV7.E4
FBA_D61: UV1.AG34 UV7.E2
FBA_D62: UV1.AG32 UV7.F4
FBA_D63: UV1.AG33 UV7.F2
FBA_DBI0#: UV1.P30 UV6.D2
FBA_DBI1#: UV1.F31 UV6.D13
FBA_DBI2#: UV1.F34 UV6.P13
FBA_DBI3#: UV1.M32 UV6.P2
FBA_DBI4#: UV1.AD31 UV7.P2
FBA_DBI5#: UV1.AL29 UV7.P13
FBA_DBI6#: UV1.AM32 UV7.D13
FBA_DBI7#: UV1.AF34 UV7.D2
FBA_EDC0: UV1.M31 UV6.C2
FBA_EDC1: UV1.G31 UV6.C13
FBA_EDC2: UV1.E33 UV6.R13
FBA_EDC3: UV1.M33 UV6.R2
FBA_EDC4: UV1.AE31 UV7.R2
FBA_EDC5: UV1.AK30 UV7.R13
FBA_EDC6: UV1.AN33 UV7.C13
FBA_EDC7: UV1.AF33 UV7.C2
FBA_MA0_MA10_H: UV1.Y30 UV7.K4
FBA_MA0_MA10_L: UV1.V30 UV6.H4
FBA_MA1_MA9_H: UV1.AA34 UV7.K5
FBA_MA1_MA9_L: UV1.U34 UV6.H5
FBA_MA2_BA0_H: UV1.AA28 UV7.K11
FBA_MA2_BA0_L: UV1.U29 UV6.H11
FBA_MA3_BA3_H: UV1.AA29 UV7.K10
FBA_MA3_BA3_L: UV1.T31 UV6.H10
FBA_MA4_BA2_H: UV1.AC34 UV7.H11
FBA_MA4_BA2_L: UV1.R34 UV6.K11
FBA_MA5_BA1_H: UV1.AC33 UV7.H10
FBA_MA5_BA1_L: UV1.R33 UV6.K10
FBA_MA6_MA11_H: UV1.Y28 UV7.H5
FBA_MA6_MA11_L: UV1.U28 UV6.K5
FBA_MA7_MA8_H: UV1.AA33 UV7.H4
FBA_MA7_MA8_L: UV1.U33 UV6.K4
FBA_MA12_RFU_H: UV1.W31 UV7.J5
FBA_MA12_RFU_L: UV1.V29 UV6.J5
FBA_RAS#_H: UV1.Y31 UV7.L3
FBA_RAS#_L: UV1.U31 UV6.G3
FBA_RST#_H: RV107.1 UV1.Y34 UV7.J2
FBA_RST#_L: RV108.1 UV1.V34 UV6.J2
FBA_WCK0: UV1.K31 UV6.D4
FBA_WCK0_N: UV1.L30 UV6.D5
FBA_WCK1: UV1.H34 UV6.P4
FBA_WCK1_N: UV1.J34 UV6.P5
FBA_WCK2: UV1.AG30 UV7.P4
FBA_WCK2_N: UV1.AG31 UV7.P5
FBA_WCK3: UV1.AJ34 UV7.D4
FBA_WCK3_N: UV1.AK34 UV7.D5
FBA_WE#_H: UV1.AA32 UV7.G12
FBA_WE#_L: UV1.U32 UV6.L12
FBC_ABI#_H: UV1.G17 UV9.J4
FBC_ABI#_L: UV1.F15 UV8.J4
FBC_CAS#_H: UV1.E17 UV9.G3
FBC_CAS#_L: UV1.C17 UV8.L3
FBC_CKE_H: RV99.2 UV1.B17 UV9.J3
FBC_CKE_L: RV96.2 UV1.B15 UV8.J3
FBC_CLK0: RV178.2 UV1.D12 UV8.J12
FBC_CLK0#: RV178.1 UV1.E12 UV8.J11
FBC_CLK1: RV138.2 UV1.E20 UV9.J12
FBC_CLK1#: RV138.1 UV1.F20 UV9.J11
FBC_CS#_H: UV1.D18 UV9.L12
FBC_CS#_L: UV1.D13 UV8.G12
FBC_D0: UV1.G9 UV8.A4
FBC_D1: UV1.E9 UV8.A2
FBC_D2: UV1.G8 UV8.B4
FBC_D3: UV1.F9 UV8.B2
FBC_D4: UV1.F11 UV8.E4
FBC_D5: UV1.G11 UV8.E2
FBC_D6: UV1.F12 UV8.F4
FBC_D7: UV1.G12 UV8.F2
FBC_D8: UV1.G6 UV8.A11
FBC_D9: UV1.F5 UV8.A13
FBC_D10: UV1.E6 UV8.B11
FBC_D11: UV1.F6 UV8.B13
FBC_D12: UV1.F4 UV8.E11
FBC_D13: UV1.G4 UV8.E13
FBC_D14: UV1.E2 UV8.F11
FBC_D15: UV1.F3 UV8.F13
FBC_D16: UV1.C2 UV8.U11
FBC_D17: UV1.D4 UV8.U13
FBC_D18: UV1.D3 UV8.T11
FBC_D19: UV1.C1 UV8.T13
FBC_D20: UV1.B3 UV8.N11
FBC_D21: UV1.C4 UV8.N13
FBC_D22: UV1.B5 UV8.M11
FBC_D23: UV1.C5 UV8.M13
FBC_D24: UV1.A11 UV8.U4
FBC_D25: UV1.C11 UV8.U2
FBC_D26: UV1.D11 UV8.T4
FBC_D27: UV1.B11 UV8.T2
FBC_D28: UV1.D8 UV8.N4
FBC_D29: UV1.A8 UV8.N2
FBC_D30: UV1.C8 UV8.M4
FBC_D31: UV1.B8 UV8.M2
FBC_D32: UV1.F24 UV9.U4
FBC_D33: UV1.G23 UV9.U2
FBC_D34: UV1.E24 UV9.T4
FBC_D35: UV1.G24 UV9.T2
FBC_D36: UV1.D21 UV9.N4
FBC_D37: UV1.E21 UV9.N2
FBC_D38: UV1.G21 UV9.M4
FBC_D39: UV1.F21 UV9.M2
FBC_D40: UV1.G27 UV9.U11
FBC_D41: UV1.D27 UV9.U13
FBC_D42: UV1.G26 UV9.T11
FBC_D43: UV1.E27 UV9.T13
FBC_D44: UV1.E29 UV9.N11
FBC_D45: UV1.F29 UV9.N13
FBC_D46: UV1.E30 UV9.M11
FBC_D47: UV1.D30 UV9.M13
FBC_D48: UV1.A32 UV9.A11
FBC_D49: UV1.C31 UV9.A13
FBC_D50: UV1.C32 UV9.B11
FBC_D51: UV1.B32 UV9.B13
FBC_D52: UV1.D29 UV9.E11
FBC_D53: UV1.A29 UV9.E13
FBC_D54: UV1.C29 UV9.F11
FBC_D55: UV1.B29 UV9.F13
FBC_D56: UV1.B21 UV9.A4
FBC_D57: UV1.C23 UV9.A2
FBC_D58: UV1.A21 UV9.B4
FBC_D59: UV1.C21 UV9.B2
FBC_D60: UV1.B24 UV9.E4
FBC_D61: UV1.C24 UV9.E2
FBC_D62: UV1.B26 UV9.F4
FBC_D63: UV1.C26 UV9.F2
FBC_DBI0#: UV1.E11 UV8.D2
FBC_DBI1#: UV1.E3 UV8.D13
FBC_DBI2#: UV1.A3 UV8.P13
FBC_DBI3#: UV1.C9 UV8.P2
FBC_DBI4#: UV1.F23 UV9.P2
FBC_DBI5#: UV1.F27 UV9.P13
FBC_DBI6#: UV1.C30 UV9.D13
FBC_DBI7#: UV1.A24 UV9.D2
FBC_EDC0: UV1.D10 UV8.C2
FBC_EDC1: UV1.D5 UV8.C13
FBC_EDC2: UV1.C3 UV8.R13
FBC_EDC3: UV1.B9 UV8.R2
FBC_EDC4: UV1.E23 UV9.R2
FBC_EDC5: UV1.E28 UV9.R13
FBC_EDC6: UV1.B30 UV9.C13
FBC_EDC7: UV1.A23 UV9.C2
FBC_MA0_MA10_H: UV1.D16 UV9.K4
FBC_MA0_MA10_L: UV1.D15 UV8.H4
FBC_MA1_MA9_H: UV1.A18 UV9.K5
FBC_MA1_MA9_L: UV1.A14 UV8.H5
FBC_MA2_BA0_H: UV1.F18 UV9.K11
FBC_MA2_BA0_L: UV1.F14 UV8.H11
FBC_MA3_BA3_H: UV1.E18 UV9.K10
FBC_MA3_BA3_L: UV1.E14 UV8.H10
FBC_MA4_BA2_H: UV1.A20 UV9.H11
FBC_MA4_BA2_L: UV1.A12 UV8.K11
FBC_MA5_BA1_H: UV1.B20 UV9.H10
FBC_MA5_BA1_L: UV1.B12 UV8.K10
FBC_MA6_MA11_H: UV1.G18 UV9.H5
FBC_MA6_MA11_L: UV1.G15 UV8.K5
FBC_MA7_MA8_H: UV1.B18 UV9.H4
FBC_MA7_MA8_L: UV1.B14 UV8.K4
FBC_MA12_RFU_H: UV1.F17 UV9.J5
FBC_MA12_RFU_L: UV1.E15 UV8.J5
FBC_RAS#_H: UV1.D17 UV9.L3
FBC_RAS#_L: UV1.D14 UV8.G3
FBC_RST#_H: RV110.1 UV1.A17 UV9.J2
FBC_RST#_L: RV111.1 UV1.A15 UV8.J2
FBC_WCK0: UV1.F8 UV8.D4
FBC_WCK0_N: UV1.E8 UV8.D5
FBC_WCK1: UV1.A5 UV8.P4
FBC_WCK1_N: UV1.A6 UV8.P5
FBC_WCK2: UV1.D24 UV9.P4
FBC_WCK2_N: UV1.D25 UV9.P5
FBC_WCK3: UV1.B27 UV9.D4
FBC_WCK3_N: UV1.C27 UV9.D5
FBC_WE#_H: UV1.C18 UV9.G12
FBC_WE#_L: UV1.C14 UV8.L12
FBVDD_EN: DV13.1 PR903.1 QZ6.5 RV209.1
FCCM_GT: PR1503.1 PR1515.1 PU1100.11
FCCM_SA: PR1530.1 PU1100.34
FCCM_VCORE: PR1404.1 PR1417.1 PR1431.1 PU1100.24
GC6_EVENT#_D: DV9.2 RV42.1 UV1.M7
GPIO0: RM13.2 UM1.C4
GPIO2: RM12.2 UM1.E3
GPIO4: RM11.2 RM20.2 UM1.E7
GPU_EN: PC1020.1 PR1007.1 PR1008.1 PR1029.1 PU1000.3
GPU_EVENT#: DV9.1 UH2.AR24
GPU_FB: PC1032.2 PR1017.2 PR1019.2 PU1000.11
GPU_FBRTN: PC1032.1 PR1012.2 PR1013.2 PU1000.10
GPU_GC6_FB_EN: DV13.3 RV37.1 UH2.AW27 UV1.P6
GPU_JTAG_TCK: T98.1(TP-1) UV1.AM10
GPU_JTAG_TDI: T99.1(TP-1) UV1.AM11
GPU_JTAG_TDO: T100.1(TP-1) UV1.AP12
GPU_JTAG_TMS: T101.1(TP-1) UV1.AP11
GPU_JTAG_TRST#: RV63.1 UV1.AN11
GPU_LEVEL: DV11.2 RV60.2 UV1.N3
GPU_PEX_RST_HOLD#: RV41.1 UV1.P1 UV18.2
GPU_PGOOD: PR1026.1 PU1000.16
GPU_PSI: PR1001.2 PU1000.4 UV1.M4
GPU_PVCC: PC1046.1 PR1016.1 PU1000.21
GPU_PWR_LEVEL: DV11.1 UE1.21
GPU_REFADJ: PR1005.2 PU1000.6
GPU_REFIN: PC1008.1 PR1004.1 PR1006.1 PR1021.1 PU1000.7
GPU_THM_SMBCLK: QH5.6 QT2.3 QV1.6 RE46.1 RT7.2 UE1.12
GPU_THM_SMBDAT: QH5.3 QT2.6 QV1.3 RE45.1 RT6.2 UE1.11
GPU_TON: PR1011.2 PU1000.9
GPU_VID: PR1000.2 PU1000.5
GPU_VREF: PC1000.1 PR1002.1 PU1000.8
GVDD: CD93.1 RA60.1 RA61.1 RA63.1 RA65.1 UA2.1 UA2.2
H_CATERR#: RH144.2 UH1.BM30
H_CPUPWRGD: UH1.BT31 UH2.AM3
H_DRAMRST#: CD69.1 RD31.2 RD35.2 UH2.BC14
H_PM_DOWN: RH155.1 UH2.AH2
H_PM_DOWN_R: RH155.2 UH1.BP31
H_PM_SYNC_R: RH189.2 UH1.BM34
H_PROCHOT#: CE86.1 PR215.2 PR216.2 PR217.2 PR326.2 PR1109.1 RH158.1 RH165.2 UE6.4
H_PROCHOT#_R: RH158.2 UH1.BR30
H_PROCHOT_EC: RE27.2 UE1.83 UE6.2
H_THERMTRIP#: RH191.1 UH2.AJ3
H_THERMTRIP#_R: RH163.2 RH191.2 UH1.J31
H_VCCST_PWRGD: RH154.1 RH164.2 UC16.4
HDA_BITCLK: CH50.2 RP15.7 UH2.BA9
HDA_BITCLK_AUDIO: CA32.1 RA31.1 RA35.2 RP15.2
HDA_CODEC_SDIN0: HDA1.8 RA32.2
HDA_SDIN0: RH96.2 UH2.BE7
HDA_SDIN0_AUDIO: RA32.1 RH96.1
HDA_SDOUT: CH51.2 RH18.2 RP15.8 UH2.BB7
HDA_SDOUT_AUDIO: CA31.1 RA29.1 RP15.1
HDA_SYNC: RP15.6 UH2.BD9
HDA_SYNC_AUDIO: HDA1.10 RP15.3
HDD_DEVSLP: RD62.1 UH2.AG43
HDD_DEVSLP_R: JHDD1.5 RD62.2
HDMI_CEC: CV601.2 JHDMI1.13 RM19.2
HDMI_HPLUG: CV599.2 JHDMI1.19 RM27.1 RV561.1 UM1.G1
HDMI_ID: RM23.2 RM24.1 UM1.D8
HDMI_RESERVED: CV600.2 JHDMI1.14
HOST_DEBUG_TX: JDEG1.8 RE64.2 RN3.1 RN5.1 UE1.81
I2C0_SCK: RH14.2 UH2.AR38
I2C0_SDA: RH15.2 UH2.AT42
I2C1_SCK_TP: QE19.4 RH119.2 UH2.AR41
I2C1_SCK_TP_C: CT79.1 DE4.3 JTP.6 QE19.3 RE9.1
I2C1_SDA_TP: QE19.1 RH120.2 UH2.AR44
I2C1_SDA_TP_C: CE80.1 DE4.1 JTP.7 QE19.6 RE7.1
I2CB_SCL: RV512.1 UV1.R7
I2CB_SDA: RV513.1 UV1.R6
I_ADP: PR200.1 PR319.1 RE36.2
I_ADP_R: CE87.1 RE36.1 UE1.110
ICSP_CLK: RE109.2 UE1.101
ICSP_CLR: RE110.2 UE1.87
ICSP_DAT: RE112.2 UE1.102
ILIM_HI1: RI45.1 US1.16
ILIM_LO1: RI49.1 US1.15
ILIM_SEL_R: RI30.2 US1.4
ILMT_1VALWP: PR606.2 PR607.1 PU600.13
ILMT_+0.95VSP: PR707.2 PR709.1 PU700.13
ILMT_+1.05VSP: PR809.2 PR810.1 PU800.13
ILMT_DDR: PR504.2 PR506.1 PU500.17
IMVP_VR_ON: CE82.1 RE23.1 RH499.2 UE1.73 UZ21.1
IMVP_VR_PG: PR1117.1 RH102.1 UH14.1
INTRUDER#: RH143.1 UH2.BE11
INV_PWM: DV2.1 JEDP1.16 RV537.1
IR_CAM_DET#: JCAM1.9 RZ96.1 UH2.AL44
IRQ_SERIRQ: RH111.1 UE1.55 UH2.BA17
ISEN1_GT: PC1129.2 PR1510.2 PR1526.2 PU1100.9
ISEN1_VCORE: PC1128.1 PR1409.2 PR1426.2 PR1440.2 PU1100.21
ISEN2_GT: PC1126.2 PR1522.2 PR1525.2 PU1100.10
ISEN2_VCORE: PC1127.1 PR1412.2 PR1423.2 PR1441.2 PU1100.22
ISEN3_VCORE: PC1125.1 PR1413.2 PR1427.2 PR1437.2 PU1100.23
ISOLATEB: RL1.2 RL30.1 RL33.2 UL1.20
ISUMN_GT: PC1117.2 PC1118.2 PC1124.1 PC1126.1 PC1129.1 PH1102.2 PR1131.2 PR1132.1 PR1136.1 PR1511.2 PR1523.2
ISUMN_SA: PC1111.1 PC1112.1 PC1113.1 PH1101.1 PR1121.2 PR1124.2 PR1126.1 PR1529.2
ISUMN_VCORE: PC1125.2 PC1127.2 PC1128.2 PC1130.1 PC1131.1 PC1132.1 PH1103.1 PR1137.2 PR1138.1 PR1139.2 PR1411.2 PR1425.2 PR1439.2
ISUMP_GT: PC1117.1 PC1118.1 PR1130.1 PR1131.1 PR1509.2 PR1521.2 PU1100.7
ISUMP_SA: PC1112.2 PC1113.2 PR1125.2 PR1126.2 PR1528.2 PU1100.32
ISUMP_VCORE: PC1131.2 PC1132.2 PR1138.2 PR1140.2 PR1410.2 PR1424.2 PR1438.2 PU1100.19
JACK_PLUG: DA5.2 JHP1.6 RA56.1
JTAG_CLK: JDEG1.4 RE111.1
JTAG_TDI: JDEG1.2 RE109.1
JTAG_TDO: JDEG1.5 RE112.1
JTAG_TMS: JDEG1.3 RE110.1
KB_BL_DET: RE3.1 RE4.2 UH2.T45
KB_DET#: JKB1.30 RH128.1 UH2.BD22
KB_LED_PWM: QE5.2 UE1.44
KB_LED_PWM#: JBL1.4 QE5.1
KSI0: JKB1.22 RPE2.4 UE1.98
KSI1: JKB1.24 RPE2.3 UE1.99
KSI2: JKB1.26 RPE2.2 UE1.6
KSI3: JKB1.23 RPE2.1 UE1.7
KSI4: JKB1.27 RPE3.4 UE1.104
KSI5: JKB1.25 RPE3.3 UE1.105
KSI6: JKB1.28 RPE3.2 UE1.107
KSI7: JKB1.29 RPE3.1 UE1.108
KSO0: JKB1.13 RPE4.8 UE1.2
KSO1: JKB1.15 RPE4.7 UE1.14
KSO2: JKB1.14 RPE4.6 UE1.15
KSO3: JKB1.16 RPE4.5 UE1.16
KSO4: JKB1.20 RPE5.8 UE1.37
KSO5: JKB1.21 RPE5.7 UE1.38
KSO6: JKB1.18 RPE5.6 UE1.39
KSO7: JKB1.19 RPE5.5 UE1.50
KSO8: JKB1.17 RPE7.8 UE1.46
KSO9: JKB1.7 RE30.1 UE1.68
KSO10: JKB1.5 RPE6.8 UE1.72
KSO11: JKB1.6 RPE6.7 UE1.74
KSO12: JKB1.12 RPE6.6 UE1.75
KSO13: JKB1.9 RPE6.5 UE1.76
KSO14: JKB1.8 RPE7.6 UE1.77
KSO15: JKB1.10 RPE7.7 UE1.86
KSO16: JKB1.11 RPE7.5 UE1.92
L_BKLT_EN_EC: RE114.2 UE1.91 UH2.W35
LAN_CLKREQ#: RP3.5 UH2.AT24 UL1.12
LAN_DISABLE#_R: RL1.1 RL43.1 UH2.AL27
LAN_EN: RL27.2 UE1.3 UL2.4
LAN_WAKE#: RH11.1 RH181.1 UH2.BD11
LAN_WAKE#_R: RL2.2 RL42.2 UL1.21
LCD_TST: DV2.3 RV538.1 UE1.26 UZ23.2
LCD_TST_R: JEDP1.5 RV538.2 RV567.1 UZ23.4
LCD_VCC_TEST_EN: DV3.2 UE1.113
LDO2_CAP: CA22.2 HDA1.39
LDO_1VALWP: PC611.1 PU600.16 PU600.17
LDO_+0.95VSP: PC710.1 PU700.16 PU700.17
LDO_+1.05VSP: PC811.1 PU800.16 PU800.17
LED1: JLED.3 QE20.6 QE21.3
LED2: JLED.2 QE23.3
LG_3V: PC416.1 PQ402.4 PU400.11
LG_5V: PC417.1 PQ401.6 PU400.15
LG_+1.35VS_VGAP: PQ901.4 PU900.6
LID_CL_SIO#: JIO1.25 RE68.1
LID_CLOSE#: CE8.1 RE25.2 RE68.2 UE1.96
LINE1-L_C: CA64.2 RA48.1
LINE1-L_R: CA65.2 RA51.1
LINE1_L: CA64.1 HDA1.22
LINE1_R: CA65.1 HDA1.21
LINE1_VREFO_L: HDA1.31 RA46.1
LINE1_VREFO_R: HDA1.30 RA53.1
LINE2_L: CD91.2 RA71.1 RA72.2
LPC_LAD0: JLPDE1.3 JNGFF1.18 UE1.59 UH2.AT22
LPC_LAD1: JLPDE1.4 JNGFF1.20 UE1.60 UH2.AV22
LPC_LAD2: JLPDE1.5 JNGFF1.16 UE1.61 UH2.AT19
LPC_LAD3: JLPDE1.6 JNGFF1.19 UE1.62 UH2.BD16
LPC_LFRAME#: JLPDE1.7 JNGFF1.17 UE1.58 UH2.BE16
LX_1VALWP: PC605.2 PL601.1 PR600.1 PU600.6 PU600.19 PU600.20
LX_3V: PC411.1 PL402.2 PQ400.1 PQ400.2 PQ400.3 PQ402.5 PR414.1 PU400.8
LX_5V: PC412.2 PL403.1 PQ401.7 PR415.1 PU400.18
LX_+0.95VSP: PC701.2 PL701.1 PR700.1 PU700.6 PU700.19 PU700.20
LX_+1.05VSP: PC803.2 PL801.1 PR802.1 PU800.6 PU800.19 PU800.20
LX_CHG: PC304.1 PL302.1 PQ304.1 PQ304.2 PQ304.3 PQ305.5 PR315.1 PU300.27
LX_DDR: PC505.2 PL501.1 PR502.1 PU500.11
M_CLK_DDR0: JDIMM1.137 UH1.AG1
M_CLK_DDR1: JDIMM1.138 UH1.AK2
M_CLK_DDR2: JDIMM2.137 UH1.AM9
M_CLK_DDR3: JDIMM2.138 UH1.AM7
M_CLK_DDR#0: JDIMM1.139 UH1.AG2
M_CLK_DDR#1: JDIMM1.140 UH1.AK1
M_CLK_DDR#2: JDIMM2.139 UH1.AN9
M_CLK_DDR#3: JDIMM2.140 UH1.AM8
M_ODT0: JDIMM1.155 UH1.AD3
M_ODT1: JDIMM1.161 UH1.AE4
M_ODT2: JDIMM2.155 UH1.AF7
M_ODT3: JDIMM2.161 UH1.AE8
MAINPWON: RT3.2 UT1.7
MCARD_PCIE#_SATA: RD58.1 RH68.1 UH2.AG36
MCT0: RL19.1 TL2.24
MCT1: RL20.1 TL2.21
MCT2: RL39.1 TL2.18
MCT3: RL40.1 TL2.15
MDI0+: TL2.12 UL1.1
MDI0-: TL2.11 UL1.2
MDI1+: TL2.9 UL1.4
MDI1-: TL2.8 UL1.5
MDI2+: TL2.6 UL1.6
MDI2-: TL2.5 UL1.7
MDI3+: TL2.3 UL1.9
MDI3-: TL2.2 UL1.10
MDO0+: JLAN.1 TL2.13
MDO0-: JLAN.2 TL2.14
MDO1+: JLAN.3 TL2.16
MDO1-: JLAN.6 TL2.17
MDO2+: JLAN.4 TL2.19
MDO2-: JLAN.5 TL2.20
MDO3+: JLAN.7 TL2.22
MDO3-: JLAN.8 TL2.23
ME_EN: RH18.1 RH47.1
ME_FWP_EC: RE21.1 RH47.2 UE1.80
ME_SUS_PWR_ACK: RH67.1 UE1.42 UH2.BD19
MEC_XTAL1: CE102.1 RE66.2 Y1.1
MEC_XTAL1_R: RE66.1 UE1.123
MEC_XTAL2: CE101.1 RE106.2 UE1.125 Y1.2
MEM_VREF: QV20.2 QV21.2 RV27.2 UV1.L1
MIC2_VREFO: HDA1.29 RA42.1 RA43.1
MSATA_DEVSLP: RD59.2 UH2.AG42
MSCLK: JDEG1.6 RE63.2
MSDATA: JDEG1.7 RE65.2
NRB_BIT: RH92.2 UH2.BD28
NVVDD PWM_VID: PR1000.1 UV1.M5
P_SYS: PC1100.2 PR329.1 PR1100.2 PU300.9 PU1100.1
PANEL_BKEN_EC: RV566.1 UE1.117
PBAT_CHG_SMBCLK: PD101.2 PR108.2 PR328.2 RE44.1 UE1.9
PBAT_CHG_SMBDAT: PD101.3 PR109.2 PR327.2 RE43.1 UE1.8
PBAT_PRES#: CE76.1 PC203.1 PD102.2 PD102.3 PR111.2 PR112.1 PR208.2 PR321.2 UE1.97
PCH_BATLOW#: RH81.1 UH2.BD13
PCH_CPU_BCLK_N: UH1.A32 UH2.H2
PCH_CPU_BCLK_P: UH1.B31 UH2.G2
PCH_CPU_PCIBCLK_N: UH1.C36 UH2.J1
PCH_CPU_PCIBCLK_P: UH1.D35 UH2.J2
PCH_DPWROK: RH9.2 RH13.2 UH2.AV11
PCH_JTAG_TCK: RH95.2 UH2.AN3
PCH_JTAG_TDI: RH100.2 RH118.1 UH2.AP2
PCH_JTAG_TDO: RH97.2 RH115.1 UH2.AP1
PCH_JTAG_TMS: RH98.2 RH492.1 UH2.AR2
PCH_JTAGX: RH38.1 UH2.AR3
PCH_PCIE_WAKE#: RH17.1 RH114.1 UH2.BC13
PCH_PLTRST#: RH1.1 UH2.BB27 UH7.1 UH7.2
PCH_PLTRST#_EC: CE72.1 JLPDE1.8 JNGFF1.44 JNGFF2.50 RH1.2 RH77.1 UE1.56 UH7.4 UL1.19 UV14.2
PCH_PWROK: RH94.1 RH102.2 UH2.AW11 UH14.4
PCH_RSMRST#: RH9.1 RH503.1 UE1.88
PCH_RSMRST#_R: RH88.2 RH503.2 UH2.BA11
PCH_RTCRST#: CH53.1 CLRP1.1 JAPS.9 RH84.2 UH2.BC10
PCH_RTCX1: CH45.1 RH70.1 UH2.BC9 YH1.1
PCH_RTCX2: CH46.1 RH70.2 UH2.BD10 YH1.2
PCH_SATA_LED#: QE21.2 RH80.1 RH502.1 UH2.AD44
PCH_SMBCLK: JDIMM1.253 JDIMM2.253 QH4.1 RH27.2
PCH_SMBDATA: JDIMM1.254 JDIMM2.254 QH4.4 RH26.2
PCH_SPI_CLK: RH507.1 UH2.BC31
PCH_SPI_CLK_R: RE126.2 UH8.6
PCH_SPI_CS#: RH74.2 RH101.1 UH2.BD31
PCH_SPI_HOLD#: RH104.1 UH2.BD30
PCH_SPI_HOLD#_R: RE71.2 UH8.7
PCH_SPI_SI: RH509.1 UH2.BB29
PCH_SPI_SI_R: RE128.2 UH8.5
PCH_SPI_SO: RH508.1 UH2.BE30
PCH_SPI_SO_R: RE127.2 UH8.2
PCH_SPI_WP#: RH510.1 UH2.BC29
PCH_SPI_WP#_R: RE129.2 UH8.3
PCH_SRTCRST#: CH52.1 RH83.2 UH2.BB10
PCH_TRIGGER: RH167.1 UH2.AL2
PCH_TRIGGER_R: RH167.2 UH1.H23
PCIE_PRX_LANTX_N3_C: CL31.2 UL1.18
PCIE_PRX_LANTX_N5: CL31.1 UH2.K19
PCIE_PRX_LANTX_P3_C: CL30.2 UL1.17
PCIE_PRX_LANTX_P5: CL30.1 UH2.L19
PCIE_PRX_SSDTX_N10: JNGFF2.29 UH2.G29
PCIE_PRX_SSDTX_N11: JNGFF2.17 UH2.L31
PCIE_PRX_SSDTX_N12: JNGFF2.5 UH2.G33
PCIE_PRX_SSDTX_P10: JNGFF2.31 UH2.E29
PCIE_PRX_SSDTX_P11: JNGFF2.19 UH2.K31
PCIE_PRX_SSDTX_P12: JNGFF2.7 UH2.H33
PCIE_PRX_WLANTX_N6: JNGFF1.35 UH2.G22
PCIE_PRX_WLANTX_P6: JNGFF1.33 UH2.E22
PCIE_PTX_LANRX_N5: CL48.1 UH2.D22
PCIE_PTX_LANRX_N5_C: CL48.2 UL1.14
PCIE_PTX_LANRX_P5: CL47.1 UH2.C22
PCIE_PTX_LANRX_P5_C: CL47.2 UL1.13
PCIE_PTX_SSDRX_N10: CD45.1 UH2.C32
PCIE_PTX_SSDRX_N10_C: CD45.2 JNGFF2.35
PCIE_PTX_SSDRX_N11: CD43.1 UH2.C33
PCIE_PTX_SSDRX_N11_C: CD43.2 JNGFF2.23
PCIE_PTX_SSDRX_N12: CD37.1 UH2.B35
PCIE_PTX_SSDRX_N12_C: CD37.2 JNGFF2.11
PCIE_PTX_SSDRX_P10: CD46.1 UH2.B32
PCIE_PTX_SSDRX_P10_C: CD46.2 JNGFF2.37
PCIE_PTX_SSDRX_P11: CD44.1 UH2.B33
PCIE_PTX_SSDRX_P11_C: CD44.2 JNGFF2.25
PCIE_PTX_SSDRX_P12: CD42.1 UH2.A35
PCIE_PTX_SSDRX_P12_C: CD42.2 JNGFF2.13
PCIE_PTX_WLANRX_N6: CN20.1 UH2.B22
PCIE_PTX_WLANRX_P6: CN21.1 UH2.A23
PCIE_PTX_WLANRX_RE_N6: CN20.2 JNGFF1.29
PCIE_PTX_WLANRX_RE_P6: CN21.2 JNGFF1.27
PCIE_RCOMPN: RH108.1 UH2.B18
PCIE_RCOMPP: RH108.2 UH2.C17
PCIE_WAKE#: JNGFF1.47 RH114.2 RL2.1 UE1.4
PECI: RH138.1 UH2.AL3
PECI_EC: DE8.1 RE17.2 RH138.2 RH190.1
PECI_EC_R: RH190.2 UH1.BT34
PECI_MEC1404: RE17.1 UE1.94
PEG_GTX_C_HRX_N0: CV532.2 UH1.E10
PEG_GTX_C_HRX_N1: CV534.2 UH1.E11
PEG_GTX_C_HRX_N2: CV536.2 UH1.E12
PEG_GTX_C_HRX_N3: CV538.2 UH1.E13
PEG_GTX_C_HRX_N4: CV540.2 UH1.E14
PEG_GTX_C_HRX_N5: CV542.2 UH1.E15
PEG_GTX_C_HRX_N6: CV544.2 UH1.E16
PEG_GTX_C_HRX_N7: CV546.2 UH1.E17
PEG_GTX_C_HRX_N8: CV548.2 UH1.F18
PEG_GTX_C_HRX_N9: CV551.2 UH1.D19
PEG_GTX_C_HRX_N10: CV557.2 UH1.F20
PEG_GTX_C_HRX_N11: CV559.2 UH1.D21
PEG_GTX_C_HRX_N12: CV561.2 UH1.F22
PEG_GTX_C_HRX_N13: CV563.2 UH1.D23
PEG_GTX_C_HRX_N14: CV565.2 UH1.F24
PEG_GTX_C_HRX_N15: CV567.2 UH1.D25
PEG_GTX_C_HRX_P0: CV531.2 UH1.F10
PEG_GTX_C_HRX_P1: CV533.2 UH1.D11
PEG_GTX_C_HRX_P2: CV535.2 UH1.F12
PEG_GTX_C_HRX_P3: CV537.2 UH1.D13
PEG_GTX_C_HRX_P4: CV539.2 UH1.F14
PEG_GTX_C_HRX_P5: CV541.2 UH1.D15
PEG_GTX_C_HRX_P6: CV543.2 UH1.F16
PEG_GTX_C_HRX_P7: CV545.2 UH1.D17
PEG_GTX_C_HRX_P8: CV547.2 UH1.E18
PEG_GTX_C_HRX_P9: CV550.2 UH1.E19
PEG_GTX_C_HRX_P10: CV552.2 UH1.E20
PEG_GTX_C_HRX_P11: CV558.2 UH1.E21
PEG_GTX_C_HRX_P12: CV560.2 UH1.E22
PEG_GTX_C_HRX_P13: CV562.2 UH1.E23
PEG_GTX_C_HRX_P14: CV564.2 UH1.E24
PEG_GTX_C_HRX_P15: CV566.2 UH1.E25
PEG_GTX_HRX_N0: CV532.1 UV1.AJ14
PEG_GTX_HRX_N1: CV534.1 UV1.AG14
PEG_GTX_HRX_N2: CV536.1 UV1.AJ15
PEG_GTX_HRX_N3: CV538.1 UV1.AK16
PEG_GTX_HRX_N4: CV540.1 UV1.AJ17
PEG_GTX_HRX_N5: CV542.1 UV1.AG17
PEG_GTX_HRX_N6: CV544.1 UV1.AJ18
PEG_GTX_HRX_N7: CV546.1 UV1.AK19
PEG_GTX_HRX_N8: CV548.1 UV1.AJ20
PEG_GTX_HRX_N9: CV551.1 UV1.AG20
PEG_GTX_HRX_N10: CV557.1 UV1.AJ21
PEG_GTX_HRX_N11: CV559.1 UV1.AK22
PEG_GTX_HRX_N12: CV561.1 UV1.AJ23
PEG_GTX_HRX_N13: CV563.1 UV1.AG23
PEG_GTX_HRX_N14: CV565.1 UV1.AJ24
PEG_GTX_HRX_N15: CV567.1 UV1.AK25
PEG_GTX_HRX_P0: CV531.1 UV1.AK14
PEG_GTX_HRX_P1: CV533.1 UV1.AH14
PEG_GTX_HRX_P2: CV535.1 UV1.AK15
PEG_GTX_HRX_P3: CV537.1 UV1.AL16
PEG_GTX_HRX_P4: CV539.1 UV1.AK17
PEG_GTX_HRX_P5: CV541.1 UV1.AH17
PEG_GTX_HRX_P6: CV543.1 UV1.AK18
PEG_GTX_HRX_P7: CV545.1 UV1.AL19
PEG_GTX_HRX_P8: CV547.1 UV1.AK20
PEG_GTX_HRX_P9: CV550.1 UV1.AH20
PEG_GTX_HRX_P10: CV552.1 UV1.AK21
PEG_GTX_HRX_P11: CV558.1 UV1.AL22
PEG_GTX_HRX_P12: CV560.1 UV1.AK23
PEG_GTX_HRX_P13: CV562.1 UV1.AH23
PEG_GTX_HRX_P14: CV564.1 UV1.AK24
PEG_GTX_HRX_P15: CV566.1 UV1.AL25
PEG_HTX_C_GRX_N0: CH36.2 UV1.AM12
PEG_HTX_C_GRX_N1: CH34.2 UV1.AM14
PEG_HTX_C_GRX_N2: CH32.2 UV1.AP15
PEG_HTX_C_GRX_N3: CH30.2 UV1.AM15
PEG_HTX_C_GRX_N4: CH28.2 UV1.AM17
PEG_HTX_C_GRX_N5: CH26.2 UV1.AP18
PEG_HTX_C_GRX_N6: CH24.2 UV1.AM18
PEG_HTX_C_GRX_N7: CH22.2 UV1.AM20
PEG_HTX_C_GRX_N8: CH20.2 UV1.AP21
PEG_HTX_C_GRX_N9: CH18.2 UV1.AM21
PEG_HTX_C_GRX_N10: CH16.2 UV1.AM23
PEG_HTX_C_GRX_N11: CH14.2 UV1.AP24
PEG_HTX_C_GRX_N12: CH12.2 UV1.AM24
PEG_HTX_C_GRX_N13: CH10.2 UV1.AM26
PEG_HTX_C_GRX_N14: CH8.2 UV1.AP27
PEG_HTX_C_GRX_N15: CH6.2 UV1.AM27
PEG_HTX_C_GRX_P0: CH35.2 UV1.AN12
PEG_HTX_C_GRX_P1: CH33.2 UV1.AN14
PEG_HTX_C_GRX_P2: CH31.2 UV1.AP14
PEG_HTX_C_GRX_P3: CH29.2 UV1.AN15
PEG_HTX_C_GRX_P4: CH27.2 UV1.AN17
PEG_HTX_C_GRX_P5: CH25.2 UV1.AP17
PEG_HTX_C_GRX_P6: CH23.2 UV1.AN18
PEG_HTX_C_GRX_P7: CH21.2 UV1.AN20
PEG_HTX_C_GRX_P8: CH19.2 UV1.AP20
PEG_HTX_C_GRX_P9: CH17.2 UV1.AN21
PEG_HTX_C_GRX_P10: CH15.2 UV1.AN23
PEG_HTX_C_GRX_P11: CH13.2 UV1.AP23
PEG_HTX_C_GRX_P12: CH11.2 UV1.AN24
PEG_HTX_C_GRX_P13: CH9.2 UV1.AN26
PEG_HTX_C_GRX_P14: CH7.2 UV1.AP26
PEG_HTX_C_GRX_P15: CH5.2 UV1.AN27
PEG_HTX_GRX_N0: CH36.1 UH1.B10
PEG_HTX_GRX_N1: CH34.1 UH1.B11
PEG_HTX_GRX_N2: CH32.1 UH1.B12
PEG_HTX_GRX_N3: CH30.1 UH1.B13
PEG_HTX_GRX_N4: CH28.1 UH1.B14
PEG_HTX_GRX_N5: CH26.1 UH1.B15
PEG_HTX_GRX_N6: CH24.1 UH1.B16
PEG_HTX_GRX_N7: CH22.1 UH1.B17
PEG_HTX_GRX_N8: CH20.1 UH1.C18
PEG_HTX_GRX_N9: CH18.1 UH1.A19
PEG_HTX_GRX_N10: CH16.1 UH1.C20
PEG_HTX_GRX_N11: CH14.1 UH1.A21
PEG_HTX_GRX_N12: CH12.1 UH1.C22
PEG_HTX_GRX_N13: CH10.1 UH1.A23
PEG_HTX_GRX_N14: CH8.1 UH1.C24
PEG_HTX_GRX_N15: CH6.1 UH1.A25
PEG_HTX_GRX_P0: CH35.1 UH1.C10
PEG_HTX_GRX_P1: CH33.1 UH1.A11
PEG_HTX_GRX_P2: CH31.1 UH1.C12
PEG_HTX_GRX_P3: CH29.1 UH1.A13
PEG_HTX_GRX_P4: CH27.1 UH1.C14
PEG_HTX_GRX_P5: CH25.1 UH1.A15
PEG_HTX_GRX_P6: CH23.1 UH1.C16
PEG_HTX_GRX_P7: CH21.1 UH1.A17
PEG_HTX_GRX_P8: CH19.1 UH1.B18
PEG_HTX_GRX_P9: CH17.1 UH1.B19
PEG_HTX_GRX_P10: CH15.1 UH1.B20
PEG_HTX_GRX_P11: CH13.1 UH1.B21
PEG_HTX_GRX_P12: CH11.1 UH1.B22
PEG_HTX_GRX_P13: CH9.1 UH1.B23
PEG_HTX_GRX_P14: CH7.1 UH1.B24
PEG_HTX_GRX_P15: CH5.1 UH1.B25
PEG_RCOMP: RH24.2 UH1.G2
PEX_TERMP: RV50.2 UV1.AP29
PEX_TSTCLK_OUT: RV47.2 UV1.AJ26
PEX_TSTCLK_OUT#: RV47.1 UV1.AK26
PG_+1.05VSP: PR800.1 PR801.1 PU800.9
PIRQA#: RH90.1 UH2.AW17
PLTRST_CPU#: UH1.BP35 UH2.AK2
POWER_SW#_MB: JAPS.11 JPW.3 RE47.2 SW5.1
POWER_SW_IN#: CE12.1 RE31.2 RE47.1 UE1.127
PQ703_S: PC302.2 PL302.2 PQ303.1 PQ303.2 PQ303.3 PR307.1 PR314.1
PROC_DETECT#: RH89.1 UH2.Y44
PS_ID: PR101.2 PR102.2 UE1.36
PSID: JADP10.4 PR114.1
PSID-1: PQ101.2 PR103.2 PR105.1
PSID-2: PQ100.2 PQ101.1 PR104.1
PTP_DIS#: JTP.3 RE57.2 RE123.2
PTP_DIS#_R: RE57.1 UE1.90
PTP_INT#: DH1.1 QE13.1 RE61.1
PTP_INT#_EC: RE53.1 RE61.2 UE1.33
PTP_INT#_R: JTP.4 QE13.3 RE87.2
PWM1_GT: PR1501.1 PU1100.12
PWM1_VCORE: PR1401.1 PU1100.25
PWM2_GT: PR1513.1 PU1100.13
PWM2_VCORE: PR1415.1 PU1100.26
PWM3_VCORE: PR1429.1 PU1100.27
PWM_SA: PR1532.2 PU1100.35
REGN_CHG: PC312.2 PR205.1 PR316.1 PU300.24
REMOTE1+: CT82.1 CT83.1 QT1.1 QT1.2 UT1.2
REMOTE1-: CT82.2 CT83.2 QT1.3 UT1.3
REMOTE2+: CT84.1 CT85.1 QT3.1 QT3.2 UT1.4
REMOTE2-: CT84.2 CT85.2 QT3.3 UT1.5
RF_+1.35VS_VGAP: PR905.1 PU900.5
RING2: HDA1.17 LA19.1 RA43.2
RING2_R: CA43.1 CA61.1 DA4.2 JHP1.3 LA19.2
ROM_CS: T97.1(TP-1) UV1.H6
ROM_SCLK: RV159.1 RV162.2 UV1.H4
ROM_SI: RV157.1 RV160.2 UV1.H5
ROM_SO: RV158.1 RV161.2 UV1.H7
RUNPWROK: RE62.2 UE1.48
SATA_LED_EN: QE21.5 QE21.6 RE108.2 UE1.30
SATA_PRX_DTX_N1B: CS25.1 UH2.D39
SATA_PRX_DTX_N1B_RC: CS25.2 JHDD1.8
SATA_PRX_DTX_P1B: CS26.1 UH2.E37
SATA_PRX_DTX_P1B_RC: CS26.2 JHDD1.7
SATA_PRX_SSDTX_N0A: JNGFF2.43 UH2.G31
SATA_PRX_SSDTX_P0A: JNGFF2.41 UH2.H31
SATA_PTX_DRX_N1B: CS27.1 UH2.B38
SATA_PTX_DRX_N1B_RC: CS27.2 JHDD1.10
SATA_PTX_DRX_P1B: CS28.1 UH2.C38
SATA_PTX_DRX_P1B_RC: CS28.2 JHDD1.11
SATA_PTX_SSDRX_N0A: CD53.1 UH2.C31
SATA_PTX_SSDRX_N0A_C: CD53.2 JNGFF2.47
SATA_PTX_SSDRX_P0A: CD51.1 UH2.B31
SATA_PTX_SSDRX_P0A_C: CD51.2 JNGFF2.49
SDZ_MUTE#: D2.1 RA74.2 UA2.29
SIO_EXT_SCI#: RH10.2 UE1.66 UH2.AV29
SIO_EXT_SMI#: RH110.1 UE1.10 UH2.AF41
SIO_EXT_WAKE#: RH91.2 UE1.116 UH2.AN44
SIO_PWRBTN#: UE1.52 UH2.AT13
SIO_RCIN#: RH87.1 UE1.53 UH2.AT17
SIO_SLP_A#: JAPS.6 UH2.BC15
SIO_SLP_S0#: JAPS.15 UH2.BC26
SIO_SLP_S3#: CE74.1 JAPS.2 PR511.1 PR702.1 QA1.2 QV2.2 UE1.23 UH2.AW15 UZ1.3 UZ1.5 UZ9.4 UZ16.3 UZ21.2
SIO_SLP_S4#: JAPS.5 PR1801.1 RZ102.1 UE1.67 UH2.BD15 UZ15.4
SIO_SLP_S5#: JAPS.4 UH2.BA13
SIO_SLP_WLAN#: T4934.1(TP-1) UH2.AV13
SKU_ID: CE104.1 RE124.2 RE125.2 UE1.114
SLEEVE: HDA1.18 LA22.1 RA42.2
SLEEVE_R: CA42.1 CA60.1 DA6.2 JHP1.4 LA22.2
SM_PG_CTRL: PR509.1 RH93.2 UC1.4
SMBALERT#: RH66.2 UH2.BB41
SMBCLK: QH4.6 RH21.2 UH2.AW44
SMBDATA: QH4.3 RH22.2 UH2.BB43
SML0_SMBCLK: RH62.2 UH2.AY44
SML0_SMBDATA: RH63.2 UH2.BB39
SML0ALERT#: RH64.2 UH2.BA40
SML1_SMBCLK: QH5.1 RH23.2 UH2.AW42
SML1_SMBDAT: QH5.4 RH25.2 UH2.AW45
SML1ALERT#: RH65.2 UH2.AT27
SNUB_1VALWP: PC600.1 PR600.2
SNUB_3V: PC418.1 PR414.2
SNUB_5V: PC419.1 PR415.2
SNUB_+0.95VSP: PC700.1 PR700.2
SNUB_+1.05VSP: PC800.1 PR802.2
SNUB_CHG: PC315.1 PR315.2
SPKR: D1.3 RH82.2 UH2.BD26
SRCCLKREQ1#: RP2.8 UH2.AW24
SRCCLKREQ4#: RP2.7 UH2.BB24
SRCCLKREQ5#: RP2.5 UH2.BE25
SRCCLKREQ7#: RP3.6 UH2.AR31
SRCCLKREQ8#: RP22.7 UH2.BD32
SRCCLKREQ9#: RP22.6 UH2.BC32
SRCCLKREQ10#: RP22.8 UH2.BB31
SRCCLKREQ11#: RP23.8 UH2.BC33
SRCCLKREQ13#: RP23.6 UH2.AW33
SRCCLKREQ14#: RP23.7 UH2.BB33
SRCCLKREQ15#: RP22.5 UH2.BD33
SSD_CLK_REQ#: JNGFF2.52 RP3.8 UH2.AT33
SSD_LED#: JNGFF2.10 RH502.2
SSD_PCIE_WAKE#: JNGFF2.54 RD8.1
STRAP0: RV146.1 RV152.2 UV1.J2
STRAP1: RV147.1 RV153.2 UV1.J7
STRAP2: RV148.1 RV154.2 UV1.J6
STRAP3: RV149.1 RV155.2 UV1.J5
STRAP4: RV150.1 RV156.2 UV1.J3
SUSCLK: RD9.2 RE106.1 RN1.2 UH2.AN15
SUSCLK_R: JNGFF1.42 RN1.1
SW_+1.35VS_VGAP: PC904.2 PL901.1 PQ900.1 PQ900.2 PQ900.3 PQ901.5 PR904.1 PU900.8
SWF_BSNL: CA45.1 JSPK1.6 LA2.1
SWF_BSNR: CA44.2 JSPK1.5 LA1.1
SYS_PEX_RST_MON#: RV187.1 RV208.1 RV532.1 UV1.L3 UV14.4 UV18.1
SYS_PWROK: UE1.89 UH2.AY1
SYS_RESET#: JAPS.13 RH193.1 UH2.AW1
TB_STAT#_CHG: PR320.1 PU300.16
TESTMODE: RV62.1 UV1.AK11
THERMAL_ALERT#: RV526.1 UV1.M2
THERMATRIP_GPU#: QV88.3 RV34.1 UV1.M1
THM_SML1_CLK: QT2.4 RT4.2 RT7.1 UT1.10
THM_SML1_DATA: QT2.1 RT5.2 RT6.1 UT1.9
TMDS_T_TX0N: DV5.2 DV5.8 JHDMI1.9 LV25.1 LV25.2 RV557.1 UM1.H3
TMDS_T_TX0P: DV5.1 DV5.9 JHDMI1.7 LV25.3 LV25.4 RV557.2 UM1.H4
TMDS_T_TX1N: DV4.1 DV4.9 JHDMI1.6 LV26.1 LV26.2 RV562.1 UM1.H5
TMDS_T_TX1P: DV4.2 DV4.8 JHDMI1.4 LV26.3 LV26.4 RV562.2 UM1.H6
TMDS_T_TX2N: DV4.4 DV4.7 JHDMI1.3 LV27.1 LV27.2 RV565.1 UM1.H7
TMDS_T_TX2P: DV4.5 DV4.6 JHDMI1.1 LV27.3 LV27.4 RV565.2 UM1.H8
TMDS_T_TXCN: DV5.5 DV5.6 JHDMI1.12 LV24.1 LV24.2 RV554.2 UM1.H1
TMDS_T_TXCP: DV5.4 DV5.7 JHDMI1.10 LV24.3 LV24.4 RV554.1 UM1.H2
TOUCH_SCREEN_PD#: DI1.1 RH69.1 UH2.AE44
TOUCHPAD_INTR#: DH1.2 RH179.1 UH2.BC23
TP_PW_EN#: RZ32.1 UE1.49 UE4.4
TRIP_+1.35VS_VGAP: PR902.2 PU900.2
U2_BOOT1: PR1003.1 PU1000.1
U2_BOOT2: PR1015.1 PU1000.18
U2_BOOT3: PR1031.1 PU1001.4
U2_LGATE1: PQ1000.6 PQ1004.6 PR1014.2 PU1000.23
U2_LGATE2: PQ1001.6 PQ1005.6 PU1000.20
U2_LGATE3: PQ1002.6 PQ1006.6 PU1001.7
U2_PHASE1: PC1001.2 PL1002.1 PQ1000.7 PQ1004.7 PR1009.1 PR1027.1 PU1000.24
U2_PHASE2: PC1033.2 PL1003.1 PQ1001.7 PQ1005.7 PR1022.1 PR1024.1 PU1000.19
U2_PHASE3: PC1076.2 PL1004.1 PQ1002.7 PQ1006.7 PR1023.1 PR1032.1 PU1001.2
U2_PWM3: PU1000.22 PU1001.5
U2_UGATE1: PQ1000.1 PQ1004.1 PU1000.2
U2_UGATE2: PQ1001.1 PQ1005.1 PU1000.17
U2_UGATE3: PQ1002.1 PQ1006.1 PU1001.3
UART2_RXD: JUART.3 RH160.2 UH2.AR45
UART2_TXD: JUART.2 RH159.2 UH2.AR39
UG_3V: PQ400.4 PU400.10
UG_5V: PQ401.1 PU400.16
UG_+1.35VS_VGAP: PQ900.4 PU900.9
USB2_COMP: RH109.1 UH2.AG3
USB2_ID: RH113.1 UH2.AG2
USB2_VBUSSENSE: RH112.1 UH2.AD10
USB3RN1: RI40.1 UH2.B7
USB3RN1_D-: DI9.1 DI9.9 JUSB1.5 RI40.2
USB3RN2: RI44.1 UH2.C8
USB3RN2_D-: DI7.1 DI7.9 JUSB2.5 RI44.2
USB3RN3: JIO1.20 UH2.B10
USB3RP1: RI39.1 UH2.A7
USB3RP1_D+: DI9.2 DI9.8 JUSB1.6 RI39.2
USB3RP2: RI43.1 UH2.B8
USB3RP2_D+: DI7.2 DI7.8 JUSB2.6 RI43.2
USB3RP3: JIO1.19 UH2.A9
USB3T_N1: CI16.2 RI38.1
USB3T_N2: CI9.2 RI42.1
USB3T_P1: CI20.2 RI37.1
USB3T_P2: CI10.2 RI41.1
USB3TN1: CI16.1 UH2.C11
USB3TN1_D-: DI9.4 DI9.7 JUSB1.8 RI38.2
USB3TN2: CI9.1 UH2.B12
USB3TN2_D-: DI7.4 DI7.7 JUSB2.8 RI42.2
USB3TN3: JIO1.16 UH2.C13
USB3TP1: CI20.1 UH2.B11
USB3TP1_D+: DI9.5 DI9.6 JUSB1.9 RI37.2
USB3TP2: CI10.1 UH2.A12
USB3TP2_D+: DI7.5 DI7.6 JUSB2.9 RI41.2
USB3TP3: JIO1.15 UH2.D13
USB20_N1: LI2.1 UH2.AF5
USB20_N2: UH2.AD5 US1.2
USB20_N3: JIO1.12 UH2.AG8
USB20_N4: LN1.1 UH2.AE1
USB20_N4_R: JNGFF1.5 LN1.2
USB20_N7: JIO1.9 UH2.AB3
USB20_N9: LI1.1 UH2.AA1
USB20_N9_R: DI3.2 JEDP1.10 LI1.2
USB20_N12: LV22.1 UH2.AD3
USB20_N12_R: DV12.3 JCAM1.6 LV22.2
USB20_P1: LI2.4 UH2.AG7
USB20_P2: UH2.AD7 US1.3
USB20_P3: JIO1.11 UH2.AG10
USB20_P4: LN1.4 UH2.AE2
USB20_P4_R: JNGFF1.3 LN1.3
USB20_P7: JIO1.8 UH2.AB2
USB20_P9: LI1.4 UH2.AA2
USB20_P9_R: DI3.3 JEDP1.9 LI1.3
USB20_P12: LV22.4 UH2.AD2
USB20_P12_R: DV12.2 JCAM1.7 LV22.3
USB_EN#: JIO1.23 RE29.1 UE1.13 US2.4
USB_OC0#: RH131.1 UH2.AD43 US2.3
USB_OC1#: RH132.1 UH2.AD42 US1.13
USB_OC2#: JIO1.24 RH135.1 UH2.AD39
USB_OC3#: RH134.1 UH2.AC44
USB_OC4#: RP8.3 UH2.Y43
USB_OC5#: RP8.4 UH2.Y41
USB_OC6#: RP8.2 UH2.W44
USB_OC7#: RP8.1 UH2.W43
USB_POWERSHARE_VBUS_EN: RI51.2 UE1.71 US1.5
USB_PWR_SHR_EN_R#: RI10.2 UE1.109 US1.6
USB_R_CTL: RI9.2 US1.7 US1.8
USBCHG_DET#: RE52.1 UE1.126
USBP1_R_D+: DI10.2 JUSB1.3 LI2.3
USBP1_R_D-: DI10.3 JUSB1.2 LI2.2
USBP2_D+: LI5.4 US1.10
USBP2_D-: LI5.1 US1.11
USBP2_R_D+: DI8.2 JUSB2.3 LI5.3
USBP2_R_D-: DI8.3 JUSB2.2 LI5.2
VCIN0_PH: CT80.1 HT1.1 RE73.2 RT1.2
VCORE_B+: PC1404.1 PC1405.1 PC1406.1 PC1407.1 PC1408.1 PC1413.1 PC1414.1 PC1415.1 PC1416.1 PC1421.1 PC1422.1 PC1423.1 PC1424.1 PJP1400.2 PL1400.2 PL1401.2 PR1102.1 PU1400.8 PU1400.9 PU1401.8 PU1401.9 PU1402.8 PU1402.9
VCREF0: CE91.1 RE34.2 RE35.1 UE1.25
VGA_CLK_REQ#: QV3.3 RP23.5 UH2.BA33
VGA_CRT_CLK: RV510.1 UV1.R4
VGA_CRT_DATA: RV511.1 UV1.R5
VGA_EDID_CLK: RV514.1 UV1.R2
VGA_EDID_DATA: RV515.1 UV1.R3
VGA_SMB_CK2: QV1.1 RV191.1 UV1.T4
VGA_SMB_DA2: QV1.4 RV192.1 UV1.T3
VR_CAP: CE103.1 T4931.1(TP-1) UE1.18
VR_ON: PR1120.1 RZ71.1 UC16.2 UZ21.4
VR_SVID_ALERT#: PR1107.1 RH152.2 RH153.1
VR_SVID_ALERT#_C: PR1107.2 PU1100.44
VR_SVID_ALERT#_R: RH153.2 UH1.BH31
VR_SVID_CLK: PR1103.2 PR1108.1 UH1.BH32
VR_SVID_CLK_C: PR1108.2 PU1100.45
VR_SVID_DATA: PR1104.2 PR1106.1 RH151.2 UH1.BH29
VR_SVID_DATA_C: PR1106.2 PU1100.43
VREF_CPU: CE77.1 RE116.1 UE1.95
VSB_N_001: PC113.2 PQ102.4 PR106.2 PR107.1
VSB_N_002: PQ103.2 PQ103.3 PR110.2
VSB_N_003: PQ103.6 PR107.2
WLAN_CLK_REQ#: JNGFF1.45 RP3.7 UH2.BD25
WLAN_WIGIG60GHZ_DIS#: DN1.1 UH2.BC27
WLAN_WIGIG60GHZ_DIS#_R: DN1.2 JNGFF1.48
XDP_PRDY#: UH1.BP27 UH2.AT4
XDP_PREQ#: RH156.2 UH1.BL30 UH2.AT3
XTAL24_IN: CH47.1 RH72.1 UH2.A6 YH2.1
XTAL24_OUT: CH48.1 RH72.2 UH2.A5 YH2.3
XTAL_OUT: CV71.2 RV52.2 UV1.H2 YV1.3
XTALIN: CV70.2 RV52.1 UV1.H3 YV1.1
XTALOUT: RV51.1 UV1.J4
XTALSSIN: RV49.1 UV1.H1
XTLI: CL36.1 UL1.29 YL2.1
XTLO: CL37.1 UL1.28 YL2.3
N48197: PC1104.2 PR1105.2 PU1100.2
N48329: PC1106.2 PR1118.2 PU1100.4
N48371: PC1107.2 PR1118.1
N48789: PC1120.1 PR1135.1 PU1100.28
N48933: PC1123.1 PR1133.2
N48941: PC1121.1 PR1133.1 PU1100.29
N48965: PC1122.1 PR1134.2
N48979: PR1128.1 PR1129.1 PR1134.1 PU1100.30
N49205: PC1119.2 PR1136.2 PU1100.8
N49217: PC1119.1 PR1132.2
N49289: PC1105.2 PR1111.2 PU1100.3
N49471: PC1110.2 PR1124.1
N49551: PC1110.1 PR1121.1 PU1100.33
N49667: PR1109.2 PU1100.46
N49815: PR1123.1 PU1100.36
N50153: PC1102.1 PR1101.2 PU1100.42
N50385: PC1136.1 PR1143.1 PU1100.14
N50425: PH1104.1 PR1141.1 PR1144.1
N50433: PR1141.2 PU1100.15
N50477: PR1116.1 PU1100.40
N50505: PR1115.1 PU1100.39
N50517: PR1114.1 PU1100.38
N50567: PR1113.1 PU1100.37
N50631: PC1139.1 PR1147.2
N50639: PC1137.1 PR1147.1 PU1100.16
N50651: PC1138.1 PR1145.2
N50739: PR1142.1 PR1145.1 PR1146.1 PU1100.17
N51003: PC1133.1 PR1137.1 PU1100.20
N51011: PC1133.2 PR1139.1
N57527: PR1435.2 PR1437.1 PR1438.1
N3514407: PR405.2 PU400.5
N3514423: PC400.1 PR400.2 PU400.3
N3514453: PC421.1 PU400.13
N13347359: PR1112.2 PR1117.2 PU1100.47
N13351923: PC1103.1 PR1102.2 PU1100.41
N13352071: PR1120.2 PU1100.48
N13353452: PR1119.2 PR1122.2 PR1127.2 PU1100.5
N17034077: PR406.1 PU400.1
N17034092: PC420.1 PR416.2 PU400.12
N18094620: CL33.1 RL19.2 RL20.2 RL39.2 RL40.2
N18094850: RL31.2 UL1.31
N18095026: T944.1(TP-1) UL1.27
N18095028: T95.1(TP-1) UL1.25
N19473413: PC1802.2 PR1803.2 PR1804.1 PU1800.7
N19473597: PR1800.2 PU1800.1
N19473637: PC1802.1 PC1803.1 PR1803.1 PR1805.1 PU1800.6
N19901660: CE78.2 RE10.1
N20173493: RE20.1 RE22.1 UE1.120
N20180024: PC1031.1 PR1010.2 PR1011.1
N20194225: PC1009.1 PR1002.2 PR1004.2 PR1005.1
N20335974: RL41.1 UL2.3
N20440449: CE71.1 RE15.2 UE1.54
N21876819: QV21.1 RV141.1 RV144.1
N21997699: QV20.1 RV126.1 RV129.1
N26964858: RV66.1 UV1.J1
N32834652: HDA1.16 RA19.1
N34662854: HDA1.20 RA17.1 RA18.1
N35924928: RV77.2 UV1.J27
N35928308: RV78.2 UV1.H27
N35950826: RV79.2 UV1.H25
N38952253: RV104.2 UV1.E1
N48676721: JBL1.2 RE3.2
N48680518: CE1.1 QE3.1 QE4.2 RE1.1
N48680573: QE4.1 RE2.1
N52997531: PD100.1 PL106.1 PR114.2
N52999984: PQ100.3 PR100.2 PR102.1
N52999986: PL106.2 PQ100.1 PR100.1 PR103.1
N101473516: RV116.1 UV6.J1
N101473793: RV120.1 UV6.J13
N101474312: RV118.1 UV6.J10
N101484120: RV117.1 UV7.J1
N101484397: RV121.1 UV7.J13
N101484914: RV119.1 UV7.J10
N101908901: RV131.1 UV9.J1
N101909174: RV135.1 UV9.J13
N101909529: RV133.1 UV9.J10
N101910032: RV132.1 UV8.J1
N101910312: RV136.1 UV8.J13
N101910826: RV134.1 UV8.J10
N108873638: PR409.1 PU400.20
N109801960: QZ6.2 QZ6.3 RZ12.2
N109970739: PR411.1 PU400.19
N110936976: PC1076.1 PR1031.2
N111036757: PR1021.2 PR1023.2 PU1000.13
N111036762: PR1024.2 PU1000.14
N111036767: PR1027.2 PR1028.1 PU1000.15
N111798152: CZ4.1 UZ1.12
N111798158: CZ6.1 UZ1.10
N120139517: RH71.2 UH2.E1
N120174690: T20.1(TP-1) UH2.AV15
N120176772: T2.1(TP-1) UH2.V44
N120176782: T4.1(TP-1) UH2.L43
N120176822: T8.1(TP-1) UH2.BD36
N120177456: T17.1(TP-1) UH2.BD17
N120361004: JNGFF2.38 RD7.2 RD59.1
N120361079: JNGFF2.68 RD9.1
N120970730: PC1409.1 PR1406.2
N120976432: PL1404.1 PR1434.1 PR1435.1 PU1402.11 PU1402.12 PU1402.13 PU1402.14 PU1402.15 PU1402.16 PU1402.17 PU1402.18 PU1402.19 PU1402.20 PU1402.21
N121033408: PR408.2 PR410.2 PU400.7
N121163993: RH150.2 UH1.J2
N121163994: RH149.2 UH1.H1
N121163995: RH148.2 UH1.G1
N121388945: RH189.1 UH2.AJ4
N121479122: RH28.1 RH29.1 UH1.AG38
N121480352: RH31.1 RH41.1 UH1.M37
N121480355: RH201.1 RH202.1 UH1.M38
N121480375: RH34.2 UH1.Y12
N121507165: RH57.2 UH1.BR25
N121507167: RH58.2 UH1.BP25
N121507169: RH166.2 UH1.BT29
N121616289: RZ33.2 UE4.3
N121673930: PC1109.2 PR1122.1
N121674134: PC1134.1 PR1142.2
N121674335: PC1115.1 PR1128.2
N121710332: RH197.2 RH198.1 UH1.AG37
N121712022: RH203.2 RH204.1 UH1.AH38
N121795600: PL1402.1 PR1406.1 PR1407.1 PU1400.11 PU1400.12 PU1400.13 PU1400.14 PU1400.15 PU1400.16 PU1400.17 PU1400.18 PU1400.19 PU1400.20 PU1400.21
N121981266: PH1100.2 PR1110.2 PR1111.1
N121981305: PH1102.1 PR1130.2
N121981509: PH1101.2 PR1125.1
N121981539: PH1103.2 PR1140.1
N121983108: PR1029.2 PU1001.1
N122017994: PL1403.1 PR1420.1 PR1421.1 PU1401.11 PU1401.12 PU1401.13 PU1401.14 PU1401.15 PU1401.16 PU1401.17 PU1401.18 PU1401.19 PU1401.20 PU1401.21
N122314333: RH32.1 RH33.1 UH1.AH37
N122397475: RH145.1 UH1.G29
N122449909: RH514.1 RH515.1 UH1.H14
N122449918: RH513.1 RH516.1 UH1.J14
N122476680: PR1407.2 PR1409.1 PR1410.1
N122477585: PR1421.2 PR1423.1 PR1424.1
N122563835: RH89.2 UH1.BR33
N122712620: JNGFF2.69 RD10.2 RD58.2
N122754354: CZ57.1 UZ16.6
N122763041: CZ95.1 UZ17.6
N123052806: RH106.2 UH14.2
N123983992: PL1503.1 PR1518.1 PR1519.1 PU1501.11 PU1501.12 PU1501.13 PU1501.14 PU1501.15 PU1501.16 PU1501.17 PU1501.18 PU1501.19 PU1501.20 PU1501.21
N123984002: PR1519.2 PR1521.1 PR1522.1
N123984081: PR1506.2 PR1509.1 PR1510.1
N123984213: PR1520.2 PR1523.1 PR1526.1
N123984271: PL1505.1 PR1524.1 PU1503.8
N123984459: PC1507.1 PR1508.2
N123984461: PL1502.1 PR1506.1 PR1508.1 PU1500.11 PU1500.12 PU1500.13 PU1500.14 PU1500.15 PU1500.16 PU1500.17 PU1500.18 PU1500.19 PU1500.20 PU1500.21
N123985122: PR1507.2 PR1511.1 PR1525.1
N124752685: CH101.2 RH211.1
N124753277: CH100.2 RH212.1
N125233563: PC1108.2 PR1119.1
N125374216: QZ8.1 RZ9.2
N125749803: QZ6.6 RZ8.2
N125750578: QZ7.6 RZ10.2
N125750624: QZ7.3 RZ11.2
N128659288: PQ203.6 PR210.2
N128659290: PQ203.2 PQ203.3 PR209.2 PR214.1
N128659296: PC204.1 PQ203.5 PR212.2
N128706078: PQ201.1 PR215.1
N128706262: PC202.1 PQ201.2 PR206.2
N128723044: PC203.2 PQ202.2 PR211.1
N128723211: PQ202.1 PR217.1
N128731318: QZ9.1 RZ37.1
N128782144: PR703.2 PR705.1 PR706.1
N128782226: PR708.2 PR710.1 PR711.1
N128802462: PC504.1 PR502.2
N128802488: PC508.2 PR503.2 PR505.1 PU500.16
N128802974: PC505.1 PU500.12
N128803011: PC500.1 PC501.1 PC502.1 PC503.1 PL500.2 PU500.10
N128803052: PC507.1 PU500.14
N128803144: PC514.1 PU500.3
N128828208: PC1417.1 PR1420.2
N128828374: PC1425.1 PR1434.2
N128835022: PC1515.1 PR1518.2
N128835130: PC1521.1 PR1524.2
N128845288: PQ200.6 PR216.1
N128845311: PQ200.5 PR203.2 PR213.1
N128845336: PC200.2 PQ200.2 PR204.2
N128845350: PC200.1 PQ200.3 PR202.2
N128884081: PC301.2 PC303.2 PC324.2 PQ300.1 PQ302.4 PR303.2 PR308.1 PR325.2
N128884094: PQ301.1 PQ301.2 PQ301.3 PQ302.1 PQ302.2 PQ302.3 PQ306.1 PQ306.2 PQ306.3 PR309.1
N128884102: PQ300.2 PR300.2 PR301.1
N128884116: PC301.1 PQ300.3 PR300.1
N128884118: PQ302.5 PR302.1
N128884914: PR321.1 PU300.15
N128884971: PC302.1 PQ303.4 PR306.1
N128884983: PR322.1 PU300.20
N128884987: PR324.1 PU300.19
N128884993: PR312.2 PR313.1 PU300.21
N128885024: PC313.2 PR310.2 PU300.28
N128885041: PD300.1 PR310.1
N128885051: PR326.1 PU300.10
N128885101: PC304.2 PR311.1
N128885126: PC321.1 PR319.2 PU300.7
N128885130: PC322.2 PU300.8
N128889202: PC904.1 PR901.2
N128889244: PC909.1 PR904.2
N128889297: PR900.2 PR908.2 PU900.1
N128983344: PC1078.1 PR1030.2 PU1001.8
N129020146: CA29.1 RA30.2 RA33.1
N129088154: RA65.2 RA67.1 UA2.3
N129088268: CD94.1 UA2.5
N129088271: CD95.1 UA2.6
N129088477: RA63.2 RA66.1 UA2.8
N129088540: RA61.2 RA64.1 UA2.9
N129088559: RA60.2 RA62.1 UA2.10
N129089294: CD92.1 UA2.32
N129089311: CD91.1 UA2.31
N129089914: CA48.1 UA2.26
N129089927: CA46.2 CA48.2 CA49.1 LA1.2 UA2.23 UA2.25
N129090458: CA49.2 UA2.22
N129090491: CA50.1 UA2.19
N129090627: CA47.1 CA50.2 CA51.1 LA2.2 UA2.16 UA2.18
N129090703: CA51.2 UA2.15
N129091037: CA47.2 RA58.1
N129091040: CA46.1 RA57.2
N129091624: CA21.1 HDA1.24
N129161519: DI1.2 JEDP1.12
N129169183: CA10.2 RA2.2 UA1.3
N129172883: JDEG1.9 RE118.2
N129203755: CA33.1 RA35.1
N129347215: RH103.2 RH105.1 RH180.2 RH499.1
N129476748: CM20.2 CM45.1 RM25.2
N129476750: CM21.2 CM46.1 RM26.2
N129484386: RM4.1 UM1.C6
N129506546: RM10.2 UM2.7
N129510341: CZ98.1 UZ22.6
N129677522: PQ403.3 PR419.2
N129680759: RE129.1 RH510.2
N129681032: RE71.1 RH104.2
N129707905: PR1403.2 PU1400.26
N129708017: PR1405.2 PU1400.7
N129708019: PC1402.1 PR1405.1
N129708021: PC1402.2 PU1400.5
N129708031: PR1401.2 PU1400.1
N129708035: PR1404.2 PU1400.2
N129708047: PC1400.1 PR1400.2 PU1400.24
N129708951: PC1401.2 PR1402.2 PU1400.3
N129713259: PR1418.2 PU1401.26
N129713349: PR1419.2 PU1401.7
N129713351: PC1412.1 PR1419.1
N129713353: PC1412.2 PU1401.5
N129713363: PR1415.2 PU1401.1
N129713367: PR1417.2 PU1401.2
N129713379: PC1410.1 PR1414.2 PU1401.24
N129714262: PC1411.2 PR1416.2 PU1401.3
N129715037: PR1432.2 PU1402.26
N129715137: PR1433.2 PU1402.7
N129715139: PC1419.1 PR1433.1
N129715141: PC1419.2 PU1402.5
N129715151: PR1429.2 PU1402.1
N129715155: PR1431.2 PU1402.2
N129715167: PC1418.1 PR1428.2 PU1402.24
N129715635: PC1420.2 PR1430.2 PU1402.3
N129716454: PR1504.2 PU1500.26
N129716544: PR1505.2 PU1500.7
N129716546: PC1502.1 PR1505.1
N129716548: PC1502.2 PU1500.5
N129716558: PR1501.2 PU1500.1
N129716562: PR1503.2 PU1500.2
N129716574: PC1500.1 PR1500.2 PU1500.24
N129717674: PC1501.2 PR1502.2 PU1500.3
N129718561: PR1516.2 PU1501.26
N129718659: PR1517.2 PU1501.7
N129718661: PC1510.1 PR1517.1
N129718663: PC1510.2 PU1501.5
N129718673: PR1513.2 PU1501.1
N129718677: PR1515.2 PU1501.2
N129718689: PC1508.1 PR1512.2 PU1501.24
N129719256: PC1509.2 PR1514.2 PU1501.3
N129830333: PR407.2 PU400.6
N129937820: PL1505.3 PR1529.1
N129937845: PL1505.2 PR1528.1
N130402506: JFAN2.1 Q13.1 RE101.2
N130402546: DE7.1 JFAN1.3 RE82.2
N130402633: DE9.1 JFAN2.3 RE84.2
N130433988: PC1001.1 PR1003.2
N130434002: PC1030.1 PR1009.2
N130435744: PC1033.1 PR1015.2
N130435872: PC1056.1 PR1022.2
N130438051: PC1082.1 PR1032.2
N130584913: T92.1(TP-1) UH2.AR17
N130791078: QV1.2 QV1.5 RV571.2 RV572.2
N130949507: T1.1(TP-1) UH2.BC18
N130955932: CA21.2 RA72.1
N130956130: CD92.2 RA73.1
N130959682: JDEG1.1 RE60.1
N130960109: RE111.2 T3.1(TP-1)
N130982801: RL43.2 UL1.26
N131144481: RM19.1 UM1.F2
N131307421: CV578.2 QV11.3 RV535.2 RV570.1
