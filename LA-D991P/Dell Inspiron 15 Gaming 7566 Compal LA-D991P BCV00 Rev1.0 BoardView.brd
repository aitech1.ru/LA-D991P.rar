# Allegro board Dell Inspiron 15 Gaming 7566 Compal LA-D991P BCV00 Rev1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DMIC_DATA_CAM: length 7.6
  BOTTOM w0.102: RZ42.1 241.06,38.93 241.06,39.25 240.94,39.37 v4(239.18,39.37) 238.91,39.37 238.44,39.84 238.44,42.59 238.02,43.01 JCAM1.4
DMIC_DATA_R: length 5.9
  TOP w0.102: RA27.2 274.28,26.09 274.85,26.09 CA62.1 v1(276.46,26.66) 276.79,26.66 276.9,26.55 HDA1.2
DTH_CSCL: length 9.7
  TOP w0.102: T4936.1 270.7,40.73 RM14.2 RM18.1 270.01,40.48 268.49,38.95 267.5,38.95 267.34,38.8 267.34,37.58 267.22,37.46 266.58,37.46 266.46,37.33 266.46,36.69 266.09,36.33 UM1.E6
DTH_CSDA: length 7.1
  TOP w0.102: v2(269.33,39.16) 268.56,38.39 268.54,38.39 268.06,37.91 268.06,37.58 267.93,37.46 267.54,37.46 267.29,37.21 267.29,36.72 266.89,36.32 UM1.F6
  BOTTOM w0.102: RM16.2 RM17.1 270.01,40 T4937.1 269.88,39.72 v2(269.33,39.16)
DTH_PDB: length 7.2
  TOP w0.102: UM1.C3 264.49,33.79 264.14,33.44 264.14,32.88 263.92,32.65 263.46,32.65 263.33,32.53 263.33,31.79 262.14,30.6 RM5.1 RM27.2 261.03,31 v1(260.8,31.23)
DTH_RST#: length 5.5
  TOP w0.102: v2(263.08,38.38) 263.08,38.36 263.6,37.84 UM1.B8
  BOTTOM w0.102: CM41.1 v1(264.86,39.03) ; CM41.1 263.28,39.54 263.28,40.63 263.53,40.88 RM6.2 ; CM41.1 263.79,38.85 263.31,38.38 v2(263.08,38.38)
DTH_SPI_CK_OUT: length 10.8
  TOP w0.102: UM1.D2 265.29,32.91 264.88,32.5 264.88,30.34 RM9.1 266.01,29.21 v1(266.01,29.01) 266.01,28.76 265.31,28.06 265.31,26.53 266.66,25.19 UM2.6
DTH_SPI_CS: length 6.3
  TOP w0.102: UM2.1 264.22,27.73 264.55,28.06 264.55,29.66 RM7.1 264.49,30.62 UM1.C1
DTH_SPI_D_IN: length 9.7
  TOP w0.102: UM2.2 261.93,26.46 261.66,26.74 261.66,27.37 261.4,27.63 v1(261.4,27.74) 261.53,27.87 261.75,27.87 262.29,28.41 263.08,28.41 263.53,28.87 263.53,30.88 264.07,31.41 264.07,32.32 264.49,32.75 UM1.C2
DTH_SPI_D_OUT: length 13.1
  TOP w0.102: UM1.D1 265.29,31.16 v1(266.05,30.4) 266.39,30.06 266.39,28.81 265.6,28.02 265.6,27.01 266.85,25.76 269.14,25.76 269.35,25.54 269.35,24.48 269.22,24.35 269.22,24.04 269.1,23.92 UM2.5
DTH_SPI_WR_PROT: length 14.6
  TOP w0.102: v2(261.66,26.03) 261.33,25.69 RM8.1 261.4,25.19 UM2.3 ; v2(266.07,27.17) 267.24,28.34 v1(267.24,29.56) 267.24,30.06 265.72,31.59 265.72,32.53 266.09,32.9 UM1.E2
  BOTTOM w0.102: v2(261.66,26.03) 261.68,26.05 261.73,26.05 262.85,27.17 v2(266.07,27.17)
DTH_VDD12: length 2.8
  TOP w0.254: v2(267.32,35.85) 266.91,35.44 UM1.F5 ; UM1.D6 v2(265.67,36.62)
  BOTTOM w0.508: v2(267.32,35.85) 267.24,35.93 CM11.1 ; CM12.1 265.14,37.15 v2(265.67,36.62)
  vias: v1(267.07,37.23) v2(271.08,38.42)
DTH_VDD12_ON: length 20.1
  TOP w0.254: UZ22.3 v2(257.19,31.24) 257.19,34.34 v2(256.48,35.05) ; UM1.G8 267.69,38.24 v2(267.85,38.39)
  IN2 w0.254: v2(256.48,35.05) 257.07,34.46 261.93,34.46 265.86,38.39 v2(267.85,38.39)
  BOTTOM w0.102: v2(257.19,31.24) v1(257.19,31.77)
  BOTTOM w0.254: v2(257.19,31.24) 257.18,31.24 RM21.2
DTH_VDD33: length 5.3
  TOP w0.254: v2(267.32,34.25) 267.69,34.63 UM1.G4 ; v2(263.31,33.42) 263.32,33.42 UM1.B2 ; UM1.G2 268.08,33.43 v2(268.08,33.47)
  BOTTOM w0.127: v1(264.2,32.91) 263.81,32.91 v2(263.31,33.42)
  BOTTOM w0.254: v2(267.32,34.25) 267.42,34.36 CM4.1 ; CM5.1 268.54,33.01 v2(268.08,33.47) ; v2(263.31,33.42) 262.77,32.88 CM3.1
DTH_VDDA12: length 0.6
  TOP w0.254: v2(266.48,34.25) 266.87,34.64 UM1.F4
  vias: v1(266.61,32.4)
DTH_VDDRX12: length 1.9
  TOP w0.254: UM1.B5 263.69,35.42 v2(263.3,35.03) 263.3,35.05 263.69,34.65 UM1.B4 ; v2(263.29,36.62) 263.29,36.57 263.69,36.97 UM1.B7
  vias: v1(263.38,36.01)
DTH_VDDTX12: length 1.2
  TOP w0.254: UM1.G7 267.76,37.04 268.11,36.69 v2(268.11,36.67) ; UM1.G5 267.71,35.44 v2(268.11,35.04)
  vias: v1(270.52,35.88)
DTH_XTLI: length 3.9
  TOP w0.102: UM1.E8 266.53,38.28 CM43.1 266.53,41.02 YM1.1
DTH_XTLO: length 6.1
  TOP w0.102: UM1.F8 266.89,39.37 CM44.1 267.52,40.2 267.22,40.5 267.22,42.03 YM1.3
E51_TX1: length 7
  TOP w0.102: v1(196.83,27.75) 195.92,28.67 RN3.2 196.48,29.25 196.48,31.18 v2(196.28,31.38)
  BOTTOM w0.102: JNGFF1.36 195.06,30.19 195.63,30.76 195.63,31.04 195.74,31.16 196.05,31.16 v2(196.28,31.38)
E51_TX2: length 5.3
  TOP w0.102: RN5.2 194.95,29.53 RN4.1 195.01,30.16 194.97,30.2 v1(194.97,30.53) 195.01,30.57 195.01,30.77 v2(195.21,30.98)
  BOTTOM w0.102: JNGFF1.30 193.56,30.35 193.94,30.72 194.95,30.72 v2(195.21,30.98)
EAPD#: length 5.5
  TOP w0.102: HDA1.4 277.44,25.76 v2(277.4,25.8)
  BOTTOM w0.102: RA70.1 v1(277.56,26.96) ; RA70.1 275.98,27.47 D2.3 ; RA70.1 276.49,26.8 277.4,25.88 v2(277.4,25.8)
EC_AGND: length 17.5
  TOP w0.203: UE1.112 228.25,33.01 v2(228.28,33.04)
  BOTTOM w0.508: CE104.2 RE124.1 228.75,34.74 229.02,34.47 229.02,33.41 228.79,33.19 228.78,33.19 228.63,33.04 v2(228.28,33.04) 228.46,32.86 v1(228.46,31.74) 228,31.28 227.72,31.28 227.97,31.03 227.97,29.25 228.48,28.74 CE98.2 RE14.1 229.69,28.53 229.37,28.21 229.37,28.01 CE81.2 ; CE81.2 227.86,27.5 RE67.2 ; CE81.2 229.14,27.22 229.58,27.22 230.57,26.23 231.3,26.23 CE87.2
EC_MUTE#: length 77.2
  TOP w0.102: HDA1.47 279.51,28.16 279.11,28.57 276.54,28.57 RA23.2 276.77,29.05 276.77,29.89 276.64,30.01 v2(276.51,30.01) 276.16,30.01 275.3,30.88 v3(275.3,32.15) 274.84,32.6 274.84,36.19 v2(275.73,37.07)
  IN2 w0.127: v2(275.73,37.07) 273.47,37.07 268.13,31.74 260.86,31.74 259.69,30.57 258.82,30.57 258.39,31 258.39,31.42 258.07,31.74 250.45,31.74 247.89,29.19 247.78,29.19 247.77,29.19 240.95,29.19 239.19,27.42 236.26,27.42 235.11,26.28 229.96,26.28 229.49,25.81 229.49,24.81 229.36,24.68 226.73,24.68 v2(226.37,24.32)
  BOTTOM w0.102: v2(276.51,30.01) 275.68,30.01 275.07,29.4 D2.2 ; v2(226.37,24.32) 226.49,24.44 226.49,26.72 225.49,27.73 225.39,27.73 225.16,27.96 225.16,28.72 RE58.2
EC_MUTE#_R: length 3.9
  TOP w0.102: UE1.119 225.45,30.43 v2(225.49,30.39)
  BOTTOM w0.102: RE58.1 225.18,29.71 225.49,30.02 225.49,30.39 v2(225.49,30.39) 225.49,31.71 v1(225.23,31.97)
EC_SPI_CLK: length 3.9
  TOP w0.102: RE40.2 217.74,16.73 v1(218.66,16.73) 219.28,17.35 219.28,17.64 219.39,17.74 UE1.32
EC_SPI_CLK_R: length 74.7
  TOP w0.102: v2(214.46,16.45) 214.46,16.4 214.74,16.12 RE40.1
  TOP w0.114: v2(172.6,9.26) 172.55,9.21 172.55,8.17 172.91,7.81 174.1,7.81 174.25,7.97 174.25,8.35 174.1,8.5 173.77,8.5 173.36,8.91 173.36,9.13 172.82,9.68 172.54,9.68 169.75,12.46 169.53,12.46 v3(168.54,13.45) 167.64,14.35 165.56,14.35 164.2,15.72 164.2,16.01 164.09,16.12 163.84,16.12 163.71,16.25 163.71,16.63 163.84,16.75 164.09,16.75 164.22,16.88 164.22,17.19 164.02,17.39 163.71,17.39 163.27,17.83 161.43,17.83 161.3,17.71 161.3,17.26 161.43,17.14 162.42,17.14 v2(162.47,17.08)
  IN1 w0.114: v2(172.6,9.26) 174.56,11.22 180.54,11.22 182.92,13.6 185.33,13.6 186.15,14.43 188.16,14.43 189.57,15.83 199.01,15.83 200.24,17.06 200.27,17.06 200.39,17.17 205,17.17 205.51,16.66 207.47,16.66 208.47,17.65 210.39,17.65 211.52,17.65 212.72,16.45 v2(214.46,16.45)
  BOTTOM w0.102: RE126.1 172.15,9.26 v2(172.6,9.26) ; v2(162.47,17.08) 162.32,17.24 RH507.2
EC_SPI_CS#: length 5.3
  TOP w0.102: RE59.2 217.48,19.68 217.61,19.55 217.61,19.36 217.73,19.24 217.92,19.24 218.02,19.34 218.02,19.75 218.1,19.83 218.31,19.83 218.4,19.74 218.4,19.31 218.48,19.23 218.73,19.23 218.83,19.33 218.83,19.62 218.73,19.73 v1(218.73,19.93) 218.77,19.97 219.02,19.97 219.25,19.74 UE1.27
EC_SPI_CS#_R: length 68
  TOP w0.102: RE59.1 214.45,19.68 213.86,19.09 213.53,19.09 213.52,19.09 212.81,19.09 v3(212.43,19.47) 212.28,19.47 212.15,19.34 v2(212.15,18.61)
  TOP w0.114: v2(162.56,15.55) 164.93,13.17 166.92,13.17 167.43,12.66 168.44,11.65 168.44,11.65 168.55,11.54 168.62,11.47 168.67,11.42 169.02,11.09 169.87,10.23 169.88,10.23 170.43,9.69 171.65,9.69 171.76,9.58 171.76,8.05 172.76,7.05 178.34,7.05 182.23,10.94 v2(183.07,10.94)
  IN3 w0.127: v2(183.07,10.94) 182.64,11.37 182.64,12.54 183.21,13.11 184.85,13.11 186.94,15.2 187.48,15.2 189.23,16.96 198.43,16.96 199.68,18.2 205.99,18.2 206.45,18.66 212.1,18.66 v2(212.15,18.61)
  BOTTOM w0.102: v2(183.07,10.94) 182.46,11.55 UH8.1 ; v2(162.56,15.55) 162.77,15.33 RH101.2
EC_SPI_SI: length 3.3
  TOP w0.102: UE1.28 219.38,19.34 218.81,18.77 v1(218.03,18.77) 217.15,18.77 RE41.2
EC_SPI_SI_R: length 74.9
  TOP w0.102: v2(215.3,18.05) 216.04,18.79 RE41.1
  IN1 w0.114: v2(178.04,10.73) 178.52,10.25 180.5,10.25 183.04,12.79 185.4,12.79 186.41,13.81 188.75,13.81 189.57,12.99 195.4,12.99 197.13,14.72 198.82,14.72 200.64,16.55 204.73,16.55 205.25,16.04 207.73,16.04 208.68,16.98 210.97,16.98 211.18,16.77 211.52,16.77 212.48,15.81 214.51,15.81 214.94,16.25 214.94,17.52 215.3,17.87 v2(215.3,18.05)
  BOTTOM w0.102: RH509.2 164.98,17.45 164.58,17.05 v1(164.58,14.85) 164.58,13.89 164.9,13.57 165.52,12.94 166.9,12.94 167.94,11.9 168.18,11.75 168.59,11.75 169.1,12.26 169.45,12.26 169.58,12.13 169.58,11.83 169.07,11.32 169.07,11.14 169.27,10.94 169.45,10.94 170.33,11.81 170.5,11.81 170.71,11.6 170.71,11.43 170.06,10.79 170.06,9.86 170.19,9.74 171.18,9.74 171.33,9.59 171.33,9.36 171.1,9.13 170.7,9.13 170.57,9.01 170.57,7.87 170.63,7.81 170.63,7.45 170.72,7.36 RE128.1 171.28,7.36 171.79,6.85 175.78,6.85 176.36,7.43 176.36,9.06 v2(178.04,10.73)
EC_SPI_SO: length 3.5
  TOP w0.102: RE42.2 217.56,18.32 218.75,18.32 219.36,18.94 UE1.29
EC_SPI_SO_R: length 72.1
  TOP w0.102: v2(214.64,17.9) 214.92,17.62 215.06,17.62 v1(215.09,17.59) 215.47,17.59 215.78,17.9 RE42.1
  IN3 w0.127: v2(183.27,12.18) 183.49,12.4 184.74,12.4 187.01,14.67 187.56,14.67 189.41,16.53 198.61,16.53 199.85,17.77 206.32,17.77 206.77,18.21 210.07,18.21 210.26,18.02 212.25,18.02 212.42,18.19 212.48,18.28 212.64,18.44 212.73,18.5 212.97,18.75 213.77,18.75 214.61,17.9 v2(214.64,17.9)
  BOTTOM w0.102: v2(183.27,12.18) 184.15,12.18 184.45,11.88 185,11.88 185.23,11.65 RE127.1 185.23,9.31 184.74,8.83 184.74,8.3 182.88,6.43 170.94,6.43 170.21,7.16 170.21,7.64 170.06,7.79 170.06,8.85 169.64,9.27 169.64,9.96 169.35,10.25 168.56,11.04 168.51,11.04 167.9,11.43 167.68,11.58 167.11,11.94 166.54,12.51 165.36,12.51 164.13,13.74 164.13,17.97 RH508.2
EC_WAKE#: length 59.1
  TOP w0.102: UE1.35 222.65,18.85 v2(222.54,18.96)
  IN3 w0.127: v2(176.2,12.58) 176.69,13.07 178.03,13.07 178.06,13.09 178.72,13.09 180.5,14.87 180.5,15.53 182.79,17.82 186.87,17.82 188.57,19.52 194.04,19.52 194.45,19.93 198.18,19.93 199.9,21.64 206.63,21.64 207.58,22.6 212.98,22.6 215.13,20.45 216.23,20.45 217.21,19.47 221.8,19.47 222.13,19.14 222.36,19.14 v2(222.54,18.96)
  BOTTOM w0.102: v2(176.2,12.58) 176.16,12.61 176.16,12.66 174.71,14.11 RH11.2 ; v2(222.54,18.96) 222.95,18.96 223.5,19.52 v1(223.91,19.52)
EDP_AUXN: length 150.4
  IN3 w0.127: v2(128.56,92.62) 128.56,92.93 128.74,93.1 129.27,93.1 129.76,93.59 129.76,95.77 129.09,96.44 128.61,96.44 127.36,97.68 126.23,97.68 125.38,98.52 125.38,99.2 125.61,99.43 125.61,100.9 126.43,101.72 126.43,103.14 123.61,105.96 105.85,105.96 105.14,105.25 87.31,105.25 80.07,98.01 80.07,93.16 77.63,90.72 77.63,87.27 73.54,83.18 71.92,83.18 71.25,82.51 71.25,81.6 68.33,78.68 68.33,75.7 66.31,73.68 65,73.68 62.04,70.72 62.04,69.49 60.33,67.78 60.33,56.15 59.06,54.88 59.06,48.98 53.46,43.37 51.44,43.37 50.25,42.18 50.25,38.37 51.01,37.61 51.01,35.18 51.35,34.84 51.79,34.84 51.94,34.99 51.94,35.21 v2(51.64,35.51)
  BOTTOM w0.076: UH1.B26 127.44,92.35 127.3,92.35 127.2,92.24 127.2,92.01 127.3,91.91 128.37,91.91 128.8,92.34 128.8,92.51 128.69,92.62 v2(128.56,92.62)
  BOTTOM w0.102: CV591.1 52.54,35.12 52.2,35.12 52.09,35.01 51.74,35.01 51.64,35.11 v2(51.64,35.51)
EDP_AUXN_C: length 1.7
  BOTTOM w0.102: RV552.1 54.9,35.13 54.15,35.13 CV591.2
EDP_AUXN_R: length 7.3
  BOTTOM w0.102: JEDP1.26 61.98,36.51 61.83,36.36 61.05,36.36 59.81,35.13 56.5,35.13 RV552.2
EDP_AUXP: length 150.4
  IN3 w0.127: v2(129.14,92.62) 130.01,93.49 130.01,95.88 129.19,96.69 128.71,96.69 127.47,97.93 126.33,97.93 125.64,98.63 125.64,99.1 125.86,99.33 125.86,100.8 126.68,101.62 126.68,103.24 123.71,106.21 105.75,106.21 105.04,105.5 87.21,105.5 79.82,98.11 79.82,93.26 77.38,90.82 77.38,87.38 73.43,83.43 71.82,83.43 71,82.62 71,81.7 68.08,78.78 68.08,75.81 66.2,73.93 64.9,73.93 61.79,70.82 61.79,69.6 60.08,67.89 60.08,56.25 58.81,54.98 58.81,49.08 53.35,43.62 51.34,43.62 50,42.28 50,38.27 50.75,37.51 50.75,35.08 51.25,34.58 51.53,34.58 51.64,34.47 v2(51.64,34.29)
  BOTTOM w0.076: UH1.C26 127.03,92.11 127.03,91.94 127.23,91.75 128.44,91.75 128.97,92.27 128.97,92.45 v2(129.14,92.62)
  BOTTOM w0.102: CV592.1 52.56,34.92 52.29,34.92 52.17,34.8 51.74,34.8 51.64,34.7 v2(51.64,34.29)
EDP_AUXP_C: length 1.7
  BOTTOM w0.102: CV592.2 54.15,34.92 54.9,34.92 RV549.1
EDP_AUXP_R: length 7.3
  BOTTOM w0.102: RV549.2 56.5,34.92 59.9,34.92 61.13,36.16 61.83,36.16 61.97,36.01 JEDP1.25
EDP_COMP: length 2.5
  TOP w0.127: RH30.1 v1(128.25,99.99)
  TOP w0.508: v2(126.36,99.88) 126.76,99.88 126.87,99.99 RH30.1
  BOTTOM w0.305: v2(126.36,99.88) 126.23,99.75 UH1.D37
EDP_DISP_UTIL: length 89.5
  TOP w0.102: v2(145.87,36.25) 146.34,36.72 v1(154.67,36.72) 155.67,35.72 RH20.1
  IN2 w0.127: v2(128.91,97.12) 128.91,96.23 129.57,95.57 129.57,94.74 130.46,93.84 132.72,93.84 135.14,91.43 135.14,79.24 137.42,76.95 137.42,74.03 136.15,72.76 136.15,69.53 138.57,67.12 138.57,44.41 139.77,43.2 139.77,41.51 139.27,41.01 139.27,38.73 141.81,36.19 145.81,36.19 v2(145.87,36.25)
  BOTTOM w0.102: v2(128.91,97.12) 128.48,97.12 UH1.A33
EDP_HPD: length 137.2
  TOP w0.102: v2(64.86,32.1) 64.58,32.38 63.26,32.38 62.8,31.92 RV551.1
  IN1 w0.114: v2(64.86,32.1) 65.74,31.21 65.74,26.46 66.56,25.64 66.56,20.95 67.95,19.56 70.75,19.56 71.05,19.26 79.56,19.26 79.89,18.93 v2(79.89,18.66)
  IN3 w0.127: v2(176.54,21.53) 176.4,21.67 174.94,21.67 174.26,22.34 170.97,22.34 170.77,22.55 163.38,22.55 162.78,21.95 161,21.95 160.02,20.97 159.09,20.97 158.75,21.31 156.87,21.31 155.58,22.6 155.01,22.6 154.39,23.22 154.39,24.77 151.81,27.35 148.12,27.35 141.46,20.69 138.23,20.69 136.78,19.24 80.48,19.24 v2(79.89,18.66)
  BOTTOM w0.089: v2(176.54,21.53) 176.45,21.53 176.2,21.78 176.2,22.06 175.94,22.32 UH2.BD7
  BOTTOM w0.102: JEDP1.18 64.29,32.51 64.7,32.1 v2(64.86,32.1)
EDP_TXN0: length 130.2
  IN3 w0.076: 123.66,95.57 123.68,95.57 123.73,95.52 124.4,95.52 124.81,95.11 124.81,94.87 124.94,94.74 125.14,94.74 125.27,94.87 v2(125.27,94.97)
  IN3 w0.127: v2(51.96,37.1) 51.96,37.1 51.96,37.34 52.1,37.47 52.28,37.47 52.41,37.34 52.41,37.02 52.5,36.93 53.06,36.93 53.74,37.62 53.74,38.97 62.49,47.72 62.49,54.47 63,54.98 63,66.94 64.53,68.46 64.53,69.69 66.01,71.17 67.31,71.17 70.82,74.68 70.82,76.81 72.78,78.78 75.24,78.78 77.41,80.95 77.41,82.73 85,90.32 85,98.98 88.68,102.65 118.69,102.65 120.61,100.74 120.61,95.13 120.84,94.91 122.26,94.91 122.92,95.57 123.66,95.57
  BOTTOM w0.076: v2(125.27,94.97) 125.27,94.92 125.61,94.59 UH1.E29
  BOTTOM w0.102: v2(51.96,37.1) 52.15,36.91 52.55,36.91 CV581.1
EDP_TXN0_C: length 1.7
  BOTTOM w0.102: RV539.1 54.9,36.91 54.15,36.91 CV581.2
EDP_TXN0_R: length 7.1
  BOTTOM w0.102: RV539.2 56.5,36.91 59.96,36.91 60.92,37.86 61.83,37.86 61.98,38.01 JEDP1.29
EDP_TXN1: length 130
  IN3 w0.076: v2(125.95,93.39) 125.95,93.53 126.04,93.63 126.22,93.63 126.48,93.88 126.48,94.5 126.2,94.78 126.2,94.85 126.18,94.86
  IN3 w0.127: v2(51.45,38.87) 51.62,38.71 52.32,38.71 61.73,48.12 61.73,54.85 62.24,55.36 62.24,67.14 63.84,68.75 63.84,69.97 65.72,71.85 67.02,71.85 70.13,74.96 70.13,77.1 72.55,79.52 74.1,79.52 76.73,82.15 76.73,83.06 84.16,90.49 84.16,99.28 88.22,103.34 121.63,103.34 122.84,102.12 123.43,101.54 123.43,99.13 123.58,98.98 123.58,97.76 126.05,95.28 126.05,94.99 126.18,94.86
  BOTTOM w0.076: UH1.E28 125.61,93.72 v2(125.95,93.39)
  BOTTOM w0.102: CV586.1 52.55,38.68 51.64,38.68 v2(51.45,38.87)
EDP_TXN1_C: length 1.7
  BOTTOM w0.102: RV541.1 54.9,38.68 54.15,38.68 CV586.2
EDP_TXN1_R: length 7.9
  BOTTOM w0.102: RV541.2 56.5,38.68 56.95,38.68 57.42,38.21 57.42,38.1 57.82,37.71 59.7,37.71 61.35,39.36 61.83,39.36 61.98,39.51 JEDP1.32
EDP_TXN2: length 130.8
  IN3 w0.127: v2(51.6,40.73) 51.89,40.44 52.78,40.44 60.33,48 60.33,54.47 61.48,55.62 61.48,67.35 63.16,69.03 63.16,70.25 65.44,72.54 66.74,72.54 69.45,75.24 69.45,77.68 72.78,81.02 74.43,81.02 75.32,81.91 75.32,83.25 77.76,85.69 78.34,85.69 80.76,88.11 80.76,91.08 82.79,93.11 82.79,98.95 87.87,104.03 123.53,104.03 124.11,103.44 124.11,99.43 124.27,99.28 124.27,98.08 124.27,98.08 124.27,98.06 126.38,95.95 126.63,95.95 127.35,95.23 127.35,94.99 127.59,94.75 127.73,94.75 127.92,94.95 v2(127.92,94.99)
  BOTTOM w0.076: v2(127.92,94.99) 127.92,94.95 UH1.B29
  BOTTOM w0.102: v2(51.6,40.73) 51.88,40.45 52.54,40.45 CV588.1
EDP_TXN2_C: length 1.7
  BOTTOM w0.102: RV543.1 54.9,40.46 54.15,40.46 CV588.2
EDP_TXN2_R: length 7.8
  BOTTOM w0.102: JEDP1.35 61.98,41.01 61.83,40.86 61.5,40.86 60.84,41.52 57.54,41.52 57.22,41.2 57.22,40.57 57.12,40.46 56.5,40.46 RV543.2
EDP_TXN3: length 136.1
  IN3 w0.076: v2(127.9,93.41) 127.9,93.48 128.05,93.64 128.79,93.64 129.02,93.87 129.08,93.87 129.09,93.88
  IN3 w0.127: 129.09,93.88 129.32,94.11 129.32,95.52 128.91,95.93 128.41,95.93 127.09,97.25 126.08,97.25 126.08,97.25 126.05,97.25 124.95,98.34 124.95,100.9 125.46,101.41 125.46,103.42 123.43,105.45 106.66,105.45 105.92,104.71 87.41,104.71 82.08,99.38 82.08,93.59 81.29,92.8 80.42,92.8 78.75,91.13 78.75,87.78 74.56,83.59 74.56,82.14 74.2,81.78 72.45,81.78 68.77,78.09 68.77,75.53 66.46,73.22 65.16,73.22 62.48,70.54 62.48,69.31 60.76,67.6 60.76,55.97 59.57,54.78 59.57,48.25 53.74,42.42 51.84,42.42 v2(51.6,42.66)
  BOTTOM w0.102: UH1.B28 127.56,93.75 v2(127.9,93.41) ; CV590.1 52.89,42.66 52.59,42.36 51.9,42.36 v2(51.6,42.66)
EDP_TXN3_C: length 1.7
  BOTTOM w0.102: CV590.2 54.15,42.37 54.9,42.37 RV546.1
EDP_TXN3_R: length 6.7
  BOTTOM w0.102: RV546.2 56.5,42.37 60.97,42.37 60.97,42.36 61.83,42.36 61.98,42.51 JEDP1.38
EDP_TXP0: length 130.2
  IN3 w0.076: v2(125.93,94.21) 125.56,94.58 124.88,94.58 124.65,94.81 124.65,95.05 124.33,95.36 123.73,95.36 123.68,95.32 123.66,95.32
  IN3 w0.127: 123.66,95.32 123.02,95.32 122.36,94.66 120.73,94.66 120.36,95.03 120.36,100.63 118.59,102.4 88.78,102.4 85.25,98.87 85.25,90.21 77.67,82.62 77.67,80.85 75.35,78.53 72.89,78.53 71.07,76.71 71.07,74.57 67.41,70.92 66.11,70.92 64.78,69.58 64.78,68.36 63.25,66.84 63.25,54.88 62.75,54.37 62.75,47.61 53.99,38.86 53.99,37.51 53.16,36.68 52.12,36.68 v2(51.96,36.51)
  BOTTOM w0.076: UH1.D29 126.26,94.58 125.93,94.25 v2(125.93,94.21)
  BOTTOM w0.102: v2(51.96,36.51) 52.15,36.7 52.55,36.7 CV580.1
EDP_TXP0_C: length 1.7
  BOTTOM w0.102: RV540.1 54.9,36.7 54.15,36.7 CV580.2
EDP_TXP0_R: length 7.1
  BOTTOM w0.102: RV540.2 56.5,36.7 60.05,36.7 61.01,37.66 61.83,37.66 61.98,37.51 JEDP1.28
EDP_TXP1: length 130
  IN3 w0.076: v2(125.3,93.39) 125.41,93.39 125.82,93.79 126.15,93.79 126.31,93.95 126.31,94.43 126.08,94.67 126.02,94.67 126,94.68
  IN3 w0.127: 126,94.68 125.8,94.88 125.8,95.18 123.33,97.65 123.33,98.87 123.18,99.02 123.18,101.43 121.52,103.09 88.33,103.09 84.41,99.18 84.41,90.39 76.98,82.96 76.98,82.04 74.21,79.27 72.66,79.27 70.38,76.99 70.38,74.85 67.13,71.6 65.83,71.6 64.09,69.87 64.09,68.64 62.49,67.04 62.49,55.26 61.98,54.75 61.98,48.02 52.42,38.46 51.62,38.46 v2(51.45,38.29)
  BOTTOM w0.076: UH1.F28 124.96,93.73 v2(125.3,93.39)
  BOTTOM w0.102: CV585.1 52.55,38.48 51.64,38.48 v2(51.45,38.29)
EDP_TXP1_C: length 1.7
  BOTTOM w0.102: CV585.2 54.15,38.48 54.9,38.48 RV542.1
EDP_TXP1_R: length 7.9
  BOTTOM w0.102: RV542.2 56.5,38.48 56.86,38.48 57.22,38.12 57.22,38.02 57.74,37.51 59.78,37.51 61.44,39.16 61.83,39.16 61.97,39.01 JEDP1.31
EDP_TXP2: length 130.9
  IN3 w0.127: v2(127.9,94.2) 127.9,94.38 127.77,94.5 127.48,94.5 127.1,94.89 127.1,95.13 126.52,95.7 126.27,95.7 124.02,97.95 124.02,97.98 124.02,97.98 124.02,99.17 123.86,99.33 123.86,103.34 123.43,103.77 87.97,103.77 83.04,98.85 83.04,93 81.01,90.97 81.01,88 78.45,85.44 77.87,85.44 75.57,83.14 75.57,81.8 74.54,80.76 72.89,80.76 69.7,77.58 69.7,75.14 66.85,72.28 65.54,72.28 63.41,70.15 63.41,68.93 61.73,67.24 61.73,55.51 60.59,54.37 60.59,47.89 52.88,40.19 51.81,40.19 v2(51.6,39.97)
  BOTTOM w0.076: UH1.A29 128.21,94.48 127.93,94.2 v2(127.9,94.2)
  BOTTOM w0.102: CV587.1 52.56,40.25 51.88,40.25 v2(51.6,39.97)
EDP_TXP2_C: length 1.7
  BOTTOM w0.102: RV544.1 54.9,40.26 54.15,40.26 CV587.2
EDP_TXP2_R: length 7.8
  BOTTOM w0.102: RV544.2 56.5,40.26 57.2,40.26 57.43,40.48 57.43,41.12 57.63,41.32 60.76,41.32 61.41,40.66 61.83,40.66 61.98,40.51 JEDP1.34
EDP_TXP3: length 136.1
  IN3 w0.076: 128.92,94.06 128.9,94.05 128.9,93.98 128.72,93.8 127.56,93.8 127.26,93.5 v2(127.26,93.41)
  IN3 w0.127: 128.92,94.06 129.07,94.21 129.07,95.42 128.81,95.67 128.3,95.67 126.98,97 125.98,97 125.98,97 125.94,97 124.7,98.24 124.7,101.01 125.21,101.51 125.21,103.32 123.33,105.2 106.77,105.2 106.03,104.46 87.51,104.46 82.33,99.28 82.33,93.49 81.39,92.55 80.53,92.55 79,91.02 79,87.68 74.81,83.49 74.81,82.03 74.31,81.53 72.55,81.53 69.02,77.99 69.02,75.42 66.56,72.97 65.26,72.97 62.73,70.43 62.73,69.21 61.02,67.5 61.02,55.86 59.82,54.67 59.82,48.15 53.85,42.17 51.78,42.17 51.6,41.98 v2(51.6,41.9)
  BOTTOM w0.102: v2(51.6,41.9) 51.85,42.15 52.59,42.15 52.89,41.85 CV589.1 ; v2(127.26,93.41) 126.91,93.77 UH1.C28
EDP_TXP3_C: length 1.7
  BOTTOM w0.102: RV548.1 54.9,42.16 54.15,42.16 CV589.2
EDP_TXP3_R: length 6.7
  BOTTOM w0.102: JEDP1.37 61.97,42.01 61.83,42.16 60.89,42.16 60.88,42.16 56.5,42.16 RV548.2
EDPVDD: length 0.9
  TOP w0.102: 67.85,40.71 68.13,40.71 v3(68.56,41.14)
EN_0.6V: length 6.9
  BOTTOM w0.254: PR511.2 PR509.2 98.71,16.54 98.14,15.97 v2(98.14,15.87) 98.14,14.96 97.52,14.34 PR510.1 97.52,14.32 PC518.1 98.79,14.32 99.35,13.76 99.45,13.76 99.8,13.4 PU500.2
EN_1.2V: length 6.2
  BOTTOM w0.102: PR507.2 v1(93.69,13.93)
  BOTTOM w0.254: PU500.1 99.35,13.08 98.81,13.62 97.28,13.62 96.96,13.93 PC517.1 PR508.1 PR507.2
EN_1VALWP: length 5.3
  BOTTOM w0.102: PR604.1 253.37,13.25 v1(253.1,13.53)
  BOTTOM w0.254: PU600.11 251.35,13.67 251.77,13.25 252.26,13.25 252.49,13.02 PC612.1 PR604.1 253.63,12.26 PR603.2
EN_+0.95VSP: length 6.1
  TOP w0.102: v1(61.83,63.72) 62.07,63.95 62.07,63.98 62.29,64.2 PR702.2
  TOP w0.254: PU700.11 66.6,65.65 66.34,65.4 65.29,65.4 64.53,64.63 PC711.1 PR704.1 PR702.2
EN_+1.05VSP: length 8.2
  BOTTOM w0.203: PU800.11 224.06,41.62 224.27,41.42 225.38,41.42 225.6,41.2 225.6,40.38 225.37,40.14 v1(225.37,39.53) 226.04,38.85 PC812.1 PR807.1 PR804.2 226.37,36.95 PR806.2
EN_+1.35VS_VGAP: length 4.7
  BOTTOM w0.102: v1(142.45,107.89) 142.22,108.12 141.75,108.12 141.03,108.84 PR903.2
  BOTTOM w0.254: PR903.2 PC906.1 140.68,110.45 PU900.3
ENVDD: length 4.4
  TOP w0.102: UZ8.4 65.61,36.23 RZ40.1 65.97,35.61 v1(65.16,35.61) 65.16,34.09 DV3.1
ENVDD_PCH: length 106
  TOP w0.102: DV3.3 68.24,34.55 v1(68.62,34.18) 68.62,33.49 68.36,33.24 68.36,32.45 68.21,32.3 v2(68.21,30.15)
  IN2 w0.127: v2(68.21,30.15) 68.34,30.28 81.79,30.28 83.3,31.79 85.33,31.79 86.24,30.88 97.01,30.88 97.52,30.37 99.98,30.37 100.29,30.67 106.72,30.67 109.41,27.99 111.97,27.99 112.25,27.71 116.93,27.71 117.15,27.93 140.83,27.93 141.91,29.01 148,29.01 148.93,29.94 149.67,29.94 150.63,30.9 152.23,30.9 155.13,33.8 155.13,35.55 156.36,36.77 157.26,36.77 158.26,35.77 v2(158.26,34.05)
  BOTTOM w0.089: UH2.W42 158.6,34.38 v2(158.26,34.05)
FAN1_PWM: length 194.7
  TOP w0.102: UE1.47 v2(227.45,17.41) ; v2(61.1,26.84) 61.02,26.84 60.16,27.7 RE121.2 59.95,28.08 60.08,28.21 60.08,28.54 59.9,28.72 Q12.3
  IN2 w0.127: v2(61.1,26.84) 58.78,24.52 58.78,23.63 63.07,19.34 68.28,19.34 68.74,19.8 93.16,19.8 93.34,19.62 93.75,19.21 93.75,18.35 93.98,18.12 103.28,18.12 103.74,17.66 109.52,17.66 111,16.18 115.08,16.18 116.64,17.74 136.58,17.74 137.66,18.82 147.74,18.82 149.44,17.12 150.52,17.12 154.92,12.72 157.52,12.72 158.76,13.96 166.23,13.96 167.5,13.96 167.5,13.96 167.57,13.96 170.27,11.27 172.45,11.27 174.29,9.43 179.93,9.43 180.6,10.1 180.6,11.45 182.92,13.76 183.73,13.76 185.05,15.08 187.81,15.08 189.54,16.8 192.28,16.8 192.76,17.29 197.8,17.29 199.74,19.23 205.69,19.23 206,19.55 209.05,19.55 209.56,19.04 215.3,19.04 215.87,18.47 220.85,18.47 221.5,17.82 224.16,17.82 225.17,16.81 226.85,16.81 v2(227.45,17.41)
  BOTTOM w0.102: v2(227.45,17.41) v1(227.45,18.14)
FAN1_TACH: length 193.6
  TOP w0.203: v2(224.8,18.15) 224.65,18 UE1.40
  TOP w0.254: v2(58.56,25.64) 58.56,26.38 58.25,26.69 v3(58.02,26.69) 56.27,26.69 53.98,28.97 DE7.2 53.62,31.03 CE99.1 RE81.2
  IN1 w0.254: v2(58.56,25.64) 59.06,25.14 59.06,22.95 60.56,21.45 60.82,21.45 66.3,15.97 71.38,15.97 72.22,16.8 99.37,16.8 100,16.18 102.89,16.18 104,17.29 110.11,17.29 111.59,15.81 114.69,15.81 115.88,16.99 122.22,16.99 122.69,17.47 135.07,17.47 136.21,16.33 142.37,16.33 142.96,15.74 145.3,15.74 146.31,14.72 153.43,14.72 154.19,15.48 159.59,15.48 159.97,15.1 161.35,15.1 162.37,16.12 163.2,16.12 164.07,15.26 168.95,15.26 169.24,15.55 170.31,15.55 171.06,14.8 171.06,14.26 171.73,13.59 179.25,13.59 181.42,15.76 187.64,15.76 189.02,17.15 196.92,17.15 198.12,17.15 199.46,18.49 205.61,18.49 205.85,18.25 206.7,18.25 207.41,18.96 211.57,18.96 212.05,19.45 216.87,19.45 217.73,18.58 220.3,18.58 221.54,17.34 223.81,17.34 224.62,18.15 v2(224.8,18.15)
FAN2_PWM: length 35.4
  TOP w0.102: v2(244.38,22.67) 244.38,23.06 243.72,23.72 243.72,26.76 v1(243.95,26.99) 244.69,27.73 RE122.2 244.69,29.3 Q13.3 ; UE1.34 222.25,15.14 222.67,14.72 v2(222.92,14.72)
  IN1 w0.114: v2(222.92,14.72) 222.92,14.75 223.61,15.43 224.81,15.43 225.15,15.78 227.75,15.78 228.71,16.74 230.54,16.74 231.72,17.91 231.72,18.93 233.13,20.34 238.02,20.34 238.6,20.92 242.2,20.92 243.95,22.67 v2(244.38,22.67)
FAN2_TACH: length 237.7
  TOP w0.203: UE1.41 225.05,17.67 225.38,18 v2(225.38,18.15)
  TOP w0.254: DE9.2 CE100.1 241.82,37.63 241.82,36.64 242.22,36.24 242.22,34.53 243.11,33.65 243.29,33.65 243.66,33.27 243.66,32.87 243.48,32.69 243.48,31.47 243.98,30.98 245.61,30.98 246.09,30.51 246.09,29.17 246.69,28.57 246.69,26.36 246.6,26.26 v2(246.6,26.22) ; RE83.2 51.19,30.47 51.7,29.96 52.46,29.96 v3(52.98,29.44) 56.27,26.15 57.93,26.15 v2(58.05,26.03)
  IN1 w0.254: v2(58.05,26.03) 58.17,26.15 58.86,26.15 60.06,24.96 60.06,24.17 59.62,23.74 59.62,22.95 60.44,22.14 60.67,22.14 66.46,16.35 71.22,16.35 72.06,17.19 99.53,17.19 100.15,16.56 102.73,16.56 103.85,17.67 110.27,17.67 111.75,16.19 114.54,16.19 115.72,17.37 122.06,17.37 122.53,17.85 135.23,17.85 136.37,16.71 142.6,16.71 143.19,16.12 145.5,16.12 146.52,15.1 153.24,15.1 154,15.87 159.78,15.87 160.16,15.48 161.15,15.48 162.16,16.5 163.41,16.5 164.27,15.64 168.79,15.64 169.08,15.93 170.47,15.93 171.44,14.96 171.44,14.42 171.89,13.97 179.09,13.97 181.27,16.14 187.48,16.14 188.86,17.53 197.08,17.53 197.96,17.53 199.3,18.87 205.77,18.87 206,18.63 206.54,18.63 207.3,19.4 211.36,19.4 211.8,19.83 217.03,19.83 217.89,18.96 220.46,18.96 221.7,17.72 223.56,17.72 224.5,18.66 225.03,18.66 225.38,18.3 v2(225.38,18.15)
  IN2 w0.254: v2(225.38,18.15) 226.96,19.73 226.96,20.36 228,21.4 230.34,21.4 230.56,21.61 232.08,21.61 233.24,22.77 235.09,22.77 235.32,22.55 238.52,22.55 239.43,23.46 240.32,23.46 241.15,24.28 241.15,25.69 242.37,26.91 246.09,26.91 246.6,26.4 v2(246.6,26.22)
FB_1VALWP: length 4.6
  TOP w0.254: v2(250,13.17) 249.91,13.08 v1(249.91,12.35) 249.91,12.31 250.09,12.13 PC606.2 PR602.2
  BOTTOM w0.254: PU600.14 250,13.13 250,13.12 ; v2(250,13.17) 250,13.12 ; 250,13.12 249.69,12.82 PR605.1
FB_3V: length 6.1
  BOTTOM w0.102: v1(59.26,19.48) 58.73,20.01 PR403.2
  BOTTOM w0.203: PC401.2 55.51,20.01 54.36,21.16 PU400.4
  BOTTOM w0.254: PC401.2 PR401.2 PR403.2
FB_5V: length 4.4
  BOTTOM w0.203: PU400.2 54.35,21.95 54.89,22.49
  BOTTOM w0.254: PR402.1 PC402.1 PR404.1 55.37,23.36 54.89,22.88 v2(54.89,22.68) 54.89,22.49
FB_+0.95VSP: length 7
  TOP w0.254: PR708.1 PR706.2 PC712.2 68.67,64.43 v2(68.3,64.8) 67.95,65.15 PU700.14
  BOTTOM w0.102: v3(65.76,63.41) 66.91,63.41 v2(68.3,64.8)
FB_+1.05VSP: length 4
  BOTTOM w0.203: PU800.14 222.71,41.01
  BOTTOM w0.254: PC806.2 221.24,39.89 PR805.2 PR808.1 222.64,40.33 222.71,40.39 222.71,41.01
FB_+1.35VS_VGAP: length 4.9
  BOTTOM w0.102: PR906.1 140.17,109.06 139.74,108.63 138.26,108.63 v1(138.06,108.42)
  BOTTOM w0.254: PR906.1 PR907.1 140.17,111.55 PU900.4
FBA_ABI#_H: length 28.1
  IN1 w0.102: v2(166.75,99.88) 167.07,100.2 167.07,100.91 166.95,101.04 166.95,103.63 165.66,104.92 165.17,104.92 164.83,105.25 164.83,106.72 164.48,107.07
  IN1 w0.147: v2(164.7,124.89) 164.86,124.73 164.86,123.68 165.09,123.45 165.09,117.77 164.48,117.16 164.48,107.07
  BOTTOM w0.102: v2(166.75,99.88) 166.33,99.46 UV1.Y29 ; UV7.J4 v2(164.7,124.89)
FBA_ABI#_L: length 35.4
  IN1 w0.102: v2(167.61,99.02) 167.61,99.47 167.96,99.82 167.96,100.45 168.17,100.66 168.17,104.27 167.47,104.97 167.47,105.74 167.43,105.78 167.43,106.97 167.64,107.18 167.64,107.36
  IN1 w0.147: 167.64,107.36 167.64,115.85 169.78,117.99 169.78,121.1 174.58,125.9 174.82,125.9 175.09,126.18 176.06,126.18 176.41,125.83 176.41,125.53 176.64,125.3 177.21,125.3 v2(177.6,125.69)
  BOTTOM w0.102: UV6.J4 v2(177.6,125.69) ; v2(167.61,99.02) 167.99,98.64 UV1.V28
FBA_CAS#_H: length 29.9
  IN1 w0.102: 164.93,106.98 165.07,106.83 165.07,105.3 165.25,105.12 165.81,105.12 167.15,103.78 167.15,101.95 v2(167.59,101.52)
  IN1 w0.147: 164.93,106.98 164.93,116.98 167.07,119.12 167.07,122.46 166.66,122.88 166.08,122.88 165.9,123.06 165.9,123.44 165.66,123.68 165.35,123.68 165.11,123.93 165.11,126.08 v2(164.7,126.49)
  BOTTOM w0.102: v2(167.59,101.52) 167.99,101.11 UV1.V31 ; UV7.G3 v2(164.7,126.49)
FBA_CAS#_L: length 34.6
  IN1 w0.102: 166.74,107.57 166.74,106.28 166.82,106.2 v2(166.82,106.12)
  IN1 w0.147: 166.74,107.57 166.74,116.23 168.88,118.37 168.88,121.48 174.7,127.29 175.3,127.29 175.83,126.76 176.57,126.76 v2(176.82,126.51)
  BOTTOM w0.102: UV6.L3 v2(176.82,126.51) ; UV1.Y32 165.89,102.31 165.89,104.11 165.09,104.91 165.09,106.17 165.66,106.74 166.33,106.74 166.72,106.36 166.72,106.22 v2(166.82,106.12)
FBA_CKE_H: length 28.5
  TOP w0.13: RV98.2 165.57,104.75 166.28,105.47 v2(166.28,105.64)
  IN1 w0.102: v2(166.28,105.64) 166.43,105.79 166.43,107.09
  IN1 w0.147: v2(165.5,125.69) 165.9,125.29 166.53,125.29 168.43,123.39 168.43,118.56 166.29,116.41 166.29,107.24 166.43,107.09
  BOTTOM w0.102: UV1.Y33 166.29,102.9 166.68,103.29 166.68,103.83 166.54,103.97 166.54,104.04 166.02,104.56 166.02,105.07 166.28,105.33 166.28,105.64 v2(166.28,105.64) ; UV7.J3 v2(165.5,125.69)
FBA_CKE_L: length 34
  TOP w0.13: RV95.2 163.7,106.95 164.8,106.95 164.92,106.83 167.4,106.83 v2(167.86,106.38)
  IN1 w0.102: 168.1,107.1 167.86,106.86 v2(167.86,106.38)
  IN1 w0.147: 168.1,107.1 168.1,115.67 170.24,117.81 170.24,120.92 174.6,125.28 176.22,125.28 176.61,124.89 v2(176.8,124.89)
  BOTTOM w0.102: v2(167.86,106.38) 167.86,106.32 167.41,105.87 167.41,105.06 167.74,104.73 167.74,103.88 167.61,103.75 167.61,103.09 UV1.V33 ; UV6.J3 v2(176.8,124.89)
FBA_CLK0: length 38
  TOP w0.102: RV123.2 185.89,125.69 v2(184.8,125.69)
  IN1 w0.13: v2(184.8,125.69) 184.91,125.69 185.07,125.52 185.93,125.52 187.16,124.29 187.16,115.65 173.74,102.23 171.83,102.23 171.3,101.69 171.3,100.35 v2(170.89,99.93)
  BOTTOM w0.114: v2(170.89,99.93) 170.52,100.31 UV1.R30 ; UV6.J12 v2(184.8,125.69)
FBA_CLK0#: length 39
  TOP w0.102: RV123.1 186.03,125.89 185.18,125.89 184.99,126.08 184.99,126.08 184.97,126.09 184.53,126.09 184.13,125.69 v2(184,125.69)
  IN1 w0.13: v2(170.88,100.71) 170.72,100.87 170.72,101.11 170.82,101.21 170.94,101.21 171.07,101.34 171.07,101.79 171.74,102.46 173.64,102.46 186.93,115.75 186.93,124.2 185.84,125.29 184.13,125.29 184,125.42 v2(184,125.69)
  BOTTOM w0.114: v2(170.88,100.71) 170.49,101.1 UV1.R31 ; UV6.J11 v2(184,125.69)
FBA_CLK1: length 38.8
  TOP w0.102: RV175.2 156.4,125.69 156.63,125.69 157.23,125.09 157.36,125.09 157.5,124.96 v2(157.5,124.89)
  IN1 w0.13: v2(164.21,101.51) 164.44,101.51 164.57,101.38 164.57,101.2 164.48,101.11 163.83,101.11 162.46,102.48 159.92,102.48 157.06,105.34 157.06,114.05 155.78,115.33 154.67,115.33 154.54,115.46 154.54,115.83 154.67,115.96 155.78,115.96 156.05,116.23 156.05,117.87 154.85,119.06 154.85,123.44 155.91,124.49 157.8,124.49 157.9,124.58 157.9,124.77 157.78,124.89 v2(157.5,124.89)
  BOTTOM w0.102: UV7.J12 v2(157.5,124.89)
  BOTTOM w0.114: UV1.AB31 164.61,101.11 v2(164.21,101.51)
FBA_CLK1#: length 39.6
  TOP w0.102: RV175.1 156.25,125.9 156.71,125.9 157.31,125.29 157.89,125.29 v2(158.3,124.89)
  IN1 w0.13: v2(164.21,100.71) 163.9,100.71 162.36,102.25 159.82,102.25 156.82,105.25 156.82,113.95 155.68,115.09 154.58,115.09 154.31,115.36 154.31,115.93 154.58,116.2 155.68,116.2 155.81,116.33 155.81,117.77 154.62,118.96 154.62,123.54 156.37,125.29 157.9,125.29 v2(158.3,124.89)
  BOTTOM w0.114: UV7.J11 v2(158.3,124.89) ; v2(164.21,100.71) 163.81,101.11 UV1.AC31
FBA_CS#_H: length 32.3
  IN1 w0.102: 157.61,105.91 157.61,105.59 160.15,103.05 162.5,103.05 163.65,101.9 164.46,101.9 164.9,101.46 164.9,100.87 v2(165.06,100.7)
  IN1 w0.147: v2(158.3,124.09) 158.12,124.09 157.71,123.68 156.34,123.68 155.63,122.96 155.63,118.91 156.6,117.94 156.6,115.73 157.61,114.73 157.61,105.91
  BOTTOM w0.102: UV1.AA31 165.47,101.11 v2(165.06,100.7) ; UV7.L12 v2(158.3,124.09)
FBA_CS#_L: length 31.8
  IN1 w0.102: 170.08,102.33 170.08,100.53 169.44,99.89 v2(169.16,99.89)
  IN1 w0.147: 170.08,102.33 171.25,103.49 172.23,103.49 177.48,108.73 177.48,114.26 182.3,119.08 182.3,122.31 182.89,122.9 183.61,122.9 v2(184,123.29)
  BOTTOM w0.102: v2(169.16,99.89) 168.79,100.26 UV1.U30
  BOTTOM w0.107: UV6.G12 v2(184,123.29)
FBA_D0: length 26.8
  IN3 w0.102: v2(174.2,98.24) 174.2,98.27 173.52,98.96 173.52,98.96 173.52,102.62 173.99,103.09
  IN3 w0.145: v2(177.68,118.35) 177.68,116.73 177.99,116.42 179.01,116.42 179.17,116.26 179.17,115.81 179.01,115.65 178.39,115.65 178.17,115.43 178.17,115.2 178.39,114.98 179.01,114.98 179.17,114.82 179.17,113.03 177.38,111.24 177.38,110.23 174.46,107.31 174.46,105.17 173.99,104.7 173.99,103.09
  BOTTOM w0.102: v2(177.68,118.35) 178,118.67 UV6.A4 ; UV1.L28 173.87,98.61 174.2,98.27 v2(174.2,98.24)
FBA_D1: length 27.5
  IN3 w0.102: 172.83,102.73 172.98,102.58 172.98,102.45 172.98,99.63 172.98,99.45 v2(172.56,99.03)
  IN3 w0.145: v2(176.09,118.33) 176.09,117.55 175.9,117.36 175.9,116.07 175.37,115.53 175.37,115.08 175.53,114.92 176.48,114.92 176.64,114.75 176.64,114.41 176.48,114.25 175.53,114.25 175.37,114.08 175.37,113.74 175.53,113.58 176.43,113.58 176.59,113.41 176.59,113.12 176.43,112.96 175.58,112.96 175.37,112.74 175.37,112.4 175.53,112.23 176.05,112.23 176.37,111.91 176.37,110.55 173.47,107.64 173.47,105.17 173.08,104.78 173.08,103.8 172.83,103.56 172.83,102.73
  BOTTOM w0.102: UV6.A2 176.09,118.58 v2(176.09,118.33) ; UV1.M29 v2(172.56,99.03)
FBA_D2: length 27.6
  IN3 w0.102: v2(174.22,99.03) 173.78,99.46 173.78,102.51 174.37,103.1 174.37,104.45 174.94,105.01
  IN3 w0.145: 174.94,105.01 174.94,107.13 177.83,110.02 177.83,111.03 179.64,112.84 179.64,116.84 179.48,117 178.61,117 178.44,117.16 178.44,117.51 178.61,117.67 179.48,117.67 179.64,117.83 179.64,118.4 179.31,118.74 178.15,118.74 v2(177.58,119.31)
  BOTTOM w0.102: UV6.B4 177.62,119.31 v2(177.58,119.31) ; v2(174.22,99.03) 173.79,99.45 UV1.L29
FBA_D3: length 26.9
  IN3 w0.102: 173.31,103.37 173.25,103.31 173.25,103.05 173.25,98.89 173.05,98.7 v2(172.56,98.21)
  IN3 w0.145: 173.31,103.37 173.54,103.61 173.54,104.69 173.95,105.1 173.95,107.46 176.89,110.41 176.89,111.41 177.4,111.93 177.4,113.5 177.57,113.66 178.54,113.66 178.7,113.82 178.7,114.17 178.54,114.33 177.57,114.33 177.4,114.49 177.4,116.09 176.57,116.93 176.57,119.07 176.79,119.29 v2(176.82,119.29)
  BOTTOM w0.102: v2(172.56,98.21) 172.96,98.61 UV1.M28 ; v2(176.82,119.29) 176.57,119.55 176.54,119.55 UV6.B2
FBA_D4: length 26.4
  IN3 w0.102: 171.68,105.14 171.68,104.63 171.49,104.45 171.49,101.73 v2(171.71,101.51)
  IN3 w0.145: v2(177.6,121.69) 177.21,121.3 174.35,121.3 172.97,119.92 172.97,117.73 173.1,117.61 173.11,117.61 173.24,117.48 173.24,116.97 173.11,116.84 173.1,116.84 172.97,116.72 172.97,116.17 173.12,116.03 173.26,116.03 173.39,115.9 173.39,115.43 173.26,115.3 173.12,115.3 172.97,115.16 172.97,113.24 171.68,111.94 171.68,105.14
  BOTTOM w0.102: UV1.N31 172.11,101.11 v2(171.71,101.51) ; UV6.E4 v2(177.6,121.69)
FBA_D5: length 29
  IN3 w0.102: v2(171.71,99.06) 172.12,99.46 172.12,100.13 171.96,100.29 171.54,100.29 171.29,100.54 171.29,101.01 171.13,101.17 171.13,104.5 171.21,104.57
  IN3 w0.145: v2(176.8,121.69) 176.39,122.09 174.49,122.09 172.41,120.02 172.41,113.34 171.21,112.13 171.21,104.57
  BOTTOM w0.102: UV1.P29 171.49,99.46 171.71,99.23 v2(171.71,99.06) ; UV6.E2 v2(176.8,121.69)
FBA_D6: length 31.9
  IN3 w0.102: 169.75,100.7 170.48,99.97 170.48,99.44 v2(170.9,99.02)
  IN3 w0.145: 169.75,100.7 169.75,101.87 169.11,102.5 169.11,104.37 169.46,104.71 169.46,105.26 169.78,105.58 169.78,112.02 171.48,113.73 171.48,120.43 174.74,123.69 176.16,123.69 176.2,123.65 177.24,123.65 v2(177.6,123.29)
  BOTTOM w0.102: UV1.R29 170.49,99.43 v2(170.9,99.02) ; UV6.F4 v2(177.6,123.29)
FBA_D7: length 30.9
  IN3 w0.102: 170.33,100.65 170.65,100.33 171.03,100.33 171.12,100.33 171.33,100.12 171.33,98.67 v2(170.87,98.21)
  IN3 w0.145: 170.33,100.65 170.33,103.57 170.21,103.69 170.21,104.57 170.33,104.69 170.33,105.19 170.74,105.6 170.74,112.33 171.95,113.53 171.95,120.21 174.63,122.89 176.46,122.89 176.77,123.21 176.77,123.23 v2(176.79,123.26)
  BOTTOM w0.102: UV1.P28 171.27,98.61 v2(170.87,98.21) ; v2(176.79,123.26) 176.77,123.26 UV6.F2
FBA_D8: length 24.9
  IN3 w0.102: v2(175.08,98.21) 175.41,98.54 175.41,103.13 176.19,103.91
  IN3 w0.145: 176.19,103.91 176.31,104.04 176.31,106.66 179.81,110.16 179.81,111.17 183.37,114.73 183.37,117.85 183.2,118.02 v2(183.2,118.49)
  BOTTOM w0.102: v2(175.08,98.21) 175.47,98.61 UV1.J28 ; UV6.A11 v2(183.2,118.49)
FBA_D9: length 24.3
  IN3 w0.102: 177.25,103.91 176.25,102.91 176.25,100.34 v2(176.71,99.88)
  IN3 w0.145: 177.25,103.91 177.25,106.27 180.83,109.86 180.83,110.86 184.8,114.83 v2(184.8,119.29)
  BOTTOM w0.102: UV1.H29 v2(176.71,99.88)
  BOTTOM w0.107: UV6.A13 v2(184.8,119.29)
FBA_D10: length 25.1
  IN3 w0.102: 176.78,103.9 175.69,102.8 175.69,99.19 v2(175.84,99.03)
  IN3 w0.145: 176.78,103.9 176.78,106.47 180.38,110.07 180.38,111.08 183.86,114.55 183.86,118.11 183.61,118.36 183.61,118.89 v2(184,119.29)
  BOTTOM w0.102: UV1.J29 175.49,99.39 v2(175.84,99.03)
  BOTTOM w0.107: UV6.B11 v2(184,119.29)
FBA_D11: length 26
  IN3 w0.145: v2(185.6,120.09) 185.6,114.97 181.32,110.69 181.32,109.68 177.83,106.19 177.83,104.7 177.64,104.51 177.64,103.66 177.7,103.6 177.7,103.06 177.14,102.51 177.14,99.46 v2(176.71,99.03)
  BOTTOM w0.102: UV1.H28 176.71,99.03 v2(176.71,99.03)
  BOTTOM w0.107: UV6.B13 v2(185.6,120.09)
FBA_D12: length 30.7
  IN3 w0.102: 177.99,101.85 177.99,100.31 v2(177.56,99.88)
  IN3 w0.145: 177.99,101.85 177.99,102.03 179.13,103.17 179.13,105.71 182.66,109.24 182.66,110.13 187.67,115.13 187.67,120.18 186.76,121.09 186.06,121.09 185.85,121.29 183.59,121.29 v2(183.2,121.69)
  BOTTOM w0.102: UV1.G29 v2(177.56,99.88)
  BOTTOM w0.107: UV6.E11 v2(183.2,121.69)
FBA_D13: length 27.1
  IN3 w0.102: 180.19,103.93 180.19,103.62 178.39,101.82 v2(178.39,101.51)
  IN3 w0.145: v2(185.6,121.69) 186.82,121.69 188.13,120.38 188.13,114.94 183.17,109.97 183.17,109.09 180.19,106.11 180.19,103.93
  BOTTOM w0.102: v2(178.39,101.51) UV1.E31
  BOTTOM w0.107: UV6.E13 v2(185.6,121.69)
FBA_D14: length 30.6
  IN3 w0.145: v2(184,122.49) 184.4,122.88 186.95,122.88 189.07,120.77 189.07,114.55 184.24,109.72 184.24,108.84 181.12,105.72 181.12,103.42 v2(179.21,101.51)
  BOTTOM w0.102: UV1.E32 178.81,101.91 v2(179.21,101.51)
  BOTTOM w0.107: UV6.F11 v2(184,122.49)
FBA_D15: length 29.9
  IN3 w0.102: 180.66,103.93 180.66,103.63 178.81,101.79 178.81,101.13 v2(178.39,100.71)
  IN3 w0.145: v2(184.8,122.49) 185.2,122.09 185.87,122.09 185.96,122.19 186.98,122.19 188.6,120.57 188.6,114.74 183.68,109.82 183.68,108.94 180.66,105.92 180.66,103.93
  BOTTOM w0.102: UV1.F30 v2(178.39,100.71)
  BOTTOM w0.107: UV6.F13 v2(184.8,122.49)
FBA_D16: length 38
  BOTTOM w0.102: 181.71,104.3 181.28,104.3 UV1.C34
  BOTTOM w0.13: 181.71,104.3 182.54,105.13 182.54,108.43 189.39,115.28 v1(189.39,120.74) 189.39,124.96 188.69,125.66 188.69,127.68 188.53,127.84 188.53,128.13 188.05,128.6 188.05,131.46 186.6,132.91 184.82,132.91 UV6.U11
FBA_D17: length 36.1
  BOTTOM w0.102: UV1.D32 180.05,102.32 180.05,102.95 179.81,103.19 179.81,103.75 180.07,104 180.07,104.46
  BOTTOM w0.13: 180.07,104.46 181.27,105.66 181.27,108.96 v1(188.47,116.17) 188.47,124.53 187.82,125.18 187.82,127.32 187.66,127.48 187.66,127.77 187.19,128.24 187.19,131.1 186.24,132.04 185.55,132.04 UV6.U13
FBA_D18: length 40.8
  BOTTOM w0.102: 182.2,104.13 182.2,103.77 181.29,102.86 UV1.B33
  BOTTOM w0.13: 182.2,104.13 183.18,105.1 183.18,108.17 189.82,114.82 189.82,115.07 189.85,115.09 v1(189.85,123.33) 189.85,125.15 189.15,125.85 189.15,127.66 188.94,127.88 188.94,128.34 188.49,128.78 188.49,131.64 186.76,133.37 184.66,133.37 183.22,131.92 183.22,131.27 UV6.T11
FBA_D19: length 37.7
  BOTTOM w0.102: UV1.C33 180.49,102.89 180.1,103.28 180.1,103.68 181.16,104.73 181.24,104.73
  BOTTOM w0.13: UV6.T13 184.79,131.3 184.79,131.92 185.35,132.47 186.42,132.47 187.62,131.28 187.62,128.42 188.09,127.95 188.09,127.66 188.26,127.5 188.26,125.4 188.93,124.72 v1(188.93,118.38) 188.93,115.73 181.9,108.7 181.9,105.39 181.24,104.73
FBA_D20: length 31.9
  BOTTOM w0.102: UV1.F33 177.99,103.02 177.62,103.38 177.62,104.39 ; UV6.N11 183.89,128.49 184.32,128.06 185.33,128.06 185.56,127.83 185.56,127.63 185.89,127.29 186.06,127.29 186.4,126.96
  BOTTOM w0.13: 177.62,104.39 177.9,104.67 177.9,105 179.35,106.45 179.35,109.76 v1(181.69,112.09) 186.74,117.14 186.74,119.91 186.75,119.92 186.75,120.25 186.74,120.26 186.74,123.78 186.52,124 186.52,124.03 186.52,124.03 186.52,124.41 186.52,124.41 186.52,126.84 186.4,126.96
FBA_D21: length 31.8
  BOTTOM w0.102: 186.95,127.04 186.9,127.09 186.9,127.57 186.36,128.12 185.84,128.12 185.47,128.49 UV6.N13 ; 178.51,104.49 178.51,103.89 178.38,103.75 178.38,102.29 UV1.F32
  BOTTOM w0.13: 178.51,104.49 178.54,104.51 178.54,104.73 179.99,106.19 179.99,108.43 179.99,108.44 179.99,109.49 v1(183.99,113.49) 187.2,116.7 187.2,124 186.79,124.41 186.79,124.94 186.95,125.1 186.95,127.04
FBA_D22: length 29.5
  BOTTOM w0.102: 176.62,104.68 176.62,104.18 176.65,104.16 176.65,103.35 176.29,103 UV1.H33
  BOTTOM w0.13: UV6.M11 183.3,127.69 182.87,128.12 182.1,128.12 181.6,127.62 181.6,115.59 v1(177.48,111.47) 177.48,106.38 176.62,105.52 176.62,104.68
FBA_D23: length 30.8
  BOTTOM w0.102: 177,104.48 176.87,104.35 176.87,103.29 176.68,103.1 176.68,102.28 176.31,101.91 UV1.H32
  BOTTOM w0.13: 177,104.48 177.26,104.74 177.26,105.26 178.19,106.19 178.19,111.4 v1(182.06,115.28) 182.06,126.83 182.05,126.84 182.5,127.28 184.79,127.28 UV6.M13
FBA_D24: length 37
  BOTTOM w0.102: 170.04,107.53 170.04,107.01 171.43,105.63 171.43,104.55 171.24,104.37 171.24,103.56 UV1.P34
  BOTTOM w0.13: UV6.U4 178.03,131.71 178.03,132.31 177.27,133.06 174.38,133.06 v1(170.75,129.43) 170.75,127.22 171.27,126.71 171.27,125.8 171.27,114.71 170.57,114.01 170.57,108.79 170.04,108.26 170.04,107.53
FBA_D25: length 34.2
  BOTTOM w0.102: UV1.P32 171.68,102.29 171.68,102.94 171.88,103.15 171.88,103.75 171.7,103.93 171.7,104.25 172.04,104.59 172.04,105.99 171.31,106.71
  BOTTOM w0.13: UV6.U2 176.4,131.84 176.13,132.11 174.88,132.11 172.19,129.42 v1(172.19,127.32) 172.19,126.98 172.19,113.83 171.74,113.38 171.74,108.16 171.31,107.73 171.31,106.71
FBA_D26: length 42.5
  BOTTOM w0.102: UV1.P31 170.9,101.5 170.9,103.73 171.04,103.87 171.04,104.45 171.2,104.61 171.2,105.27 169.4,107.07
  BOTTOM w0.13: 169.4,107.07 169.4,108.52 170.04,109.16 170.04,114.38 170.81,115.16 170.81,125.99 170.81,126.52 170.29,127.03 170.29,129.63 v1(171.94,131.28) 174.23,133.57 177.51,133.57 178.5,132.58 178.5,131.92 178.44,131.87 178.44,131.33 UV6.T4
FBA_D27: length 36.4
  BOTTOM w0.102: UV1.P33 171.29,103.01 171.65,103.37 171.65,103.68 171.44,103.88 171.44,104.28 171.73,104.57 171.73,105.82 170.68,106.88
  BOTTOM w0.13: UV6.T2 176.8,131.29 176.8,132.12 176.34,132.58 174.61,132.58 171.28,129.25 171.28,127.35 171.73,126.9 171.73,125.61 v1(171.73,121) 171.73,114.27 171.11,113.65 171.11,108.42 170.68,107.99 170.68,106.88
FBA_D28: length 32.1
  BOTTOM w0.102: 173.23,106.44 173.23,104.32 173.39,104.16 173.39,101.51 UV1.L31
  BOTTOM w0.13: 173.23,106.44 173.23,106.94 173.66,107.36 v1(173.66,111.34) 173.66,112.55 174.15,113.05 174.15,128.3 174.77,128.92 177.57,128.92 UV6.N4
FBA_D29: length 26.7
  BOTTOM w0.102: 173.86,105.92 173.86,105.1 173.79,105.02 UV1.L34
  BOTTOM w0.13: 173.86,105.92 v1(173.86,106.67) 174.29,107.1 174.29,112.22 174.64,112.57 174.64,127.05 174.65,127.07 174.65,127.9 174.87,128.11 176.02,128.11 UV6.N2
FBA_D30: length 31
  BOTTOM w0.102: UV1.L32 174.18,102.29 174.18,102.84 174.37,103.04 174.37,104.61 175.11,105.35
  BOTTOM w0.13: 175.11,105.35 175.14,105.38 175.14,106.14 175.57,106.57 v1(175.57,109.69) 175.57,111.92 180.14,116.49 180.14,127.84 179.84,128.13 178.44,128.13 UV6.M4
FBA_D31: length 30.1
  BOTTOM w0.102: 174.5,105.58 174.5,105.12 174.16,104.78 174.16,103.25 173.79,102.88 UV1.L33
  BOTTOM w0.13: 174.5,105.58 174.5,106.41 174.93,106.84 174.93,112.06 v1(177.26,114.39) 179.68,116.81 179.68,126.72 179.08,127.32 176.77,127.32 UV6.M2
FBA_D32: length 26.6
  IN3 w0.102: v2(160.92,99.89) 160.91,99.9 160.91,102.03 161.29,102.42 161.29,104.33 162.39,105.44 162.39,105.83
  IN3 w0.145: v2(164.7,119.29) 164.51,119.29 163.98,118.76 163.74,118.76 162.78,117.8 162.78,116.34 162.61,116.18 161.92,116.18 161.76,116.01 161.76,115.67 161.92,115.5 162.61,115.5 162.78,115.34 162.78,115 162.61,114.83 161.92,114.83 161.76,114.67 161.76,114.33 161.92,114.16 162.61,114.16 162.78,114 162.78,110.15 162.39,109.77 162.39,105.83
  BOTTOM w0.102: UV1.AG28 160.92,99.04 v2(160.92,99.89) ; UV7.U4 v2(164.7,119.29)
FBA_D33: length 26.1
  IN3 w0.102: v2(161.71,99.88) 162.12,100.29 162.12,102.28 162.6,102.76 162.6,104.83 163.33,105.56 163.33,105.91
  IN3 w0.145: 163.33,105.91 163.33,109.38 164.73,110.78 164.73,113.19 164.54,113.39 163.98,113.39 163.81,113.55 163.81,113.9 163.98,114.06 164.65,114.06 164.78,114.18 164.78,114.6 164.65,114.73 163.98,114.73 163.81,114.89 163.81,115.24 163.98,115.4 164.63,115.4 164.75,115.53 164.75,115.94 164.63,116.07 163.84,116.07 163.71,116.2 163.71,116.61 163.84,116.74 164.46,116.74 164.68,116.96 164.68,117.67 v2(165.5,118.49)
  BOTTOM w0.102: UV1.AF29 v2(161.71,99.88) ; UV7.U2 v2(165.5,118.49)
FBA_D34: length 26.4
  IN3 w0.102: v2(159.99,99.03) 160.51,99.55 160.51,102.1 160.97,102.56 160.97,104.48 161.93,105.43 161.93,105.83
  IN3 w0.145: v2(163.9,119.29) 163.12,119.29 160.92,117.08 160.92,113.4 161.08,113.24 161.75,113.24 161.91,113.08 161.91,112.73 161.75,112.57 161.26,112.57 161.1,112.41 161.1,112.06 161.26,111.9 162.04,111.9 162.16,111.78 162.16,111.3 161.93,111.07 161.93,105.83
  BOTTOM w0.102: UV1.AG29 160.42,99.46 v2(159.99,99.03) ; UV7.T4 v2(163.9,119.29)
FBA_D35: length 26.4
  IN3 w0.102: 162.86,105.93 162.86,105.58 162.36,105.08 162.36,103.42 161.8,102.86 161.8,102.29 161.16,101.65 161.16,100.29 161.3,100.15 161.3,99.45 v2(161.71,99.03)
  IN3 w0.145: 162.86,105.93 162.86,109.57 164.25,110.96 164.25,111.29 164.1,111.45 163.38,111.45 163.24,111.58 163.24,111.92 163.41,112.08 163.98,112.08 164.14,112.25 164.14,112.59 163.98,112.76 163.41,112.76 163.24,112.92 163.24,117.38 164.17,118.31 164.17,118.52 164.54,118.89 165.1,118.89 v2(165.5,119.29)
  BOTTOM w0.102: UV1.AF28 v2(161.71,99.03) ; UV7.T2 v2(165.5,119.29)
FBA_D36: length 27.9
  IN3 w0.102: v2(162.56,99.9) 163.34,100.68 163.34,104.23 163.65,104.54
  IN3 w0.145: 163.65,104.54 163.7,104.59 163.7,104.59 163.97,104.59 164.86,105.48 164.86,106.65 167.46,109.25 167.46,120.48 166.64,121.3 165.32,121.3 165.1,121.52 165.1,121.9 164.7,122.3 v2(164.7,122.49)
  BOTTOM w0.102: v2(162.56,99.9) 162.58,99.9 UV1.AD30 ; UV7.N4 v2(164.7,122.49)
FBA_D37: length 30.1
  IN3 w0.102: 165.47,102.58 165.47,102.14 165.46,102.13 165.46,102.11 164.45,101.11 164.01,101.11 163.76,100.86 163.76,99.73 163.09,99.06 v2(162.56,99.06)
  IN3 w0.145: v2(165.5,122.49) 165.9,122.89 166.51,122.89 168.39,121.01 168.39,107.97 167.26,106.84 167.26,105.81 167.27,105.81 167.42,105.65 167.42,105.2 165.89,103.67 165.89,103 165.47,102.58
  BOTTOM w0.102: UV1.AD29 162.96,99.46 v2(162.56,99.06) ; UV7.N2 v2(165.5,122.49)
FBA_D38: length 29.4
  IN3 w0.102: 163.68,102.69 163.68,102.25 163.55,102.12 163.55,100.07 v2(163.37,99.89)
  IN3 w0.145: 163.68,102.69 163.83,102.83 164.86,102.83 165.14,103.11 165.14,103.52 164.76,103.89 164.76,104.61 165.32,105.16 165.32,106.34 167.92,108.95 167.92,120.73 166.57,122.08 165.36,122.08 165.09,122.34 165.09,122.89 v2(164.7,123.29)
  BOTTOM w0.102: UV7.M4 v2(164.7,123.29)
  BOTTOM w0.127: v2(163.37,99.89) 163.79,99.47 UV1.AC29
FBA_D39: length 30.5
  IN3 w0.102: 165.91,102.1 164.65,100.84 164.65,99.8 163.07,98.21 v2(162.56,98.21)
  IN3 w0.145: 165.91,102.1 165.91,102.12 168.39,104.6 168.39,106.4 168.86,106.86 168.86,121.2 166.77,123.29 v2(166.3,123.29)
  BOTTOM w0.102: v2(162.56,98.21) 162.96,98.61 UV1.AD28 ; UV7.M2 v2(166.3,123.29)
FBA_D40: length 23.3
  IN3 w0.102: 159.49,105.63 159.08,105.22 159.08,104.71 158.93,104.56 158.93,101.56 158.57,101.21 158.57,100.14 v2(158.27,99.83)
  IN3 w0.145: 159.49,105.63 159.91,106.05 159.91,107.33 160.32,107.75 160.32,109.5 160.18,109.65 159.56,109.65 159.41,109.79 159.41,110.16 159.56,110.3 159.96,110.3 160.11,110.45 160.11,110.65 159.8,110.95 159.56,110.95 159.31,111.2 159.31,119.07 v2(159.1,119.29)
  BOTTOM w0.102: v2(158.27,99.83) 158.64,99.46 UV1.AJ29 ; UV7.U11 v2(159.1,119.29)
FBA_D41: length 25.5
  IN3 w0.102: v2(157.49,99.81) 157.49,100.15 157.98,100.64 157.98,101.03 157.77,101.24 157.77,103.65 158.24,104.12 158.24,105.68 158.54,105.97
  IN3 w0.145: v2(157.5,119.29) 157.5,118.8 158.41,117.89 158.41,115.82 158.27,115.68 157.49,115.68 157.36,115.55 157.36,115.15 157.49,115.03 158.27,115.03 158.41,114.88 158.41,114.43 158.2,114.21 157.59,114.21 157.46,114.09 157.46,111.8 158.02,111.24 158.02,110.94 157.74,110.66 157.59,110.66 157.46,110.53 157.46,110.05 158.97,108.54 158.97,106.41 158.54,105.97
  BOTTOM w0.102: UV7.U13 v2(157.5,119.29) ; UV1.AK29 v2(157.49,99.81)
FBA_D42: length 25.7
  IN3 w0.102: v2(159.21,99.88) 158.87,100.23 158.87,101.06 159.26,101.45 159.26,104.33 159.52,104.58 159.52,104.97
  IN3 w0.145: v2(159.1,120.09) 159.83,120.82 160.51,120.82 160.74,120.59 160.74,118.99 159.76,118.01 159.76,111.63 160.77,110.62 160.77,107.56 160.38,107.16 160.38,105.83 159.52,104.97
  BOTTOM w0.102: UV1.AJ30 v2(159.21,99.88) ; UV7.T11 v2(159.1,120.09)
