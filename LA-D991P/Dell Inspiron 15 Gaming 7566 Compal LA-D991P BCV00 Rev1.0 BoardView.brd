# Allegro board Dell Inspiron 15 Gaming 7566 Compal LA-D991P BCV00 Rev1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LPC_LAD1: length 105.9
  TOP w0.102: v2(230.82,25.47) 230.16,24.81 230.16,21.73 230.44,21.45 230.44,20.68 232.65,18.46 UE1.60
  IN3 w0.127: v2(245.98,26.23) 245.98,26.82 245.68,27.12 240.97,27.12 240.4,26.55 239.45,26.55 238.88,27.12 236.91,27.12 235.45,25.66 233.88,25.66 233.54,25.31 230.97,25.31 v2(230.82,25.47) 230.82,25.36 230.41,24.96 229.8,24.96 229.16,25.59 223.75,25.59 223.09,24.93 221.12,24.93 220.75,25.3 216.99,25.3 216.17,26.12 216.16,26.12 214.73,27.55 204.96,27.55 203.9,28.62 192.53,28.62 v2(192.09,28.18) 191.6,27.69 191.6,27.12 190.87,26.38 187.94,26.38 184.74,23.18 181.01,23.18 180.5,23.69 179.18,23.69 178.8,23.3 177.5,23.3 176.67,22.47 175.91,22.47 175.2,23.18 172.19,23.18 171.94,23.43 171.38,23.43 170.39,24.42 170.01,24.42 169.28,25.16 v2(169.28,25.28)
  BOTTOM w0.089: UH2.AV22 169.17,25.39 v2(169.28,25.28)
  BOTTOM w0.102: v2(192.09,28.18) 191.81,28.46 191.37,28.46 191.06,28.78 JNGFF1.20 ; v1(230.31,24.83) 230.31,24.97 230.81,25.47 v2(230.82,25.47) ; v2(245.98,26.23) 245.98,27.46 245.75,27.69 245.75,28.68 245.52,28.91 JLPDE1.4
LPC_LAD2: length 105.7
  TOP w0.102: UE1.61 233.05,18.75 231.56,20.24 231.56,21.02 230.64,21.93 230.64,24.6 231.35,25.31 231.35,26.26 231.07,26.54 231.07,26.94 v2(231.05,26.96)
  IN3 w0.127: v2(245.27,28.48) 245.02,28.73 245.02,30.09 243.94,31.17 242.37,31.17 242.05,30.85 242.05,30.07 240.62,28.64 236.28,28.64 234.82,27.18 233.21,27.18 232.94,26.92 231.09,26.92 v2(231.05,26.96) 231.02,26.94 230.01,26.94 229.76,27.19 228.91,27.19 228.89,27.18 228.12,27.18 228.11,27.19 220.98,27.19 220.6,27.57 217.93,27.57 216.61,28.9 216.3,28.9 214.53,30.67 208.43,30.67 208.13,30.98 206.02,30.98 205.18,30.14 192.49,30.14 191.5,31.13 190.74,31.13 v2(190.21,30.6) 188.02,28.41 185.96,28.41 185.39,27.84 184.76,27.84 184.59,27.68 184.59,26.59 184.1,26.1 181.55,26.1 180.66,26.99 178.39,26.99 177.66,26.27 174.33,26.27 174.06,26.53 172.25,26.53 171.94,26.23 169.97,26.23 v2(169.25,26.95)
  BOTTOM w0.089: v2(169.25,26.95) 169.25,26.94 169.77,26.42 UH2.AT19
  BOTTOM w0.102: JNGFF1.16 190.06,30.45 v2(190.21,30.6) ; v2(245.27,28.48) 245.02,28.72 JLPDE1.5 ; v1(230.64,27.52) 230.76,27.41 230.76,27.25 v2(231.05,26.96)
LPC_LAD3: length 101.5
  TOP w0.102: v2(231.2,22.93) 231.12,22.85 231.12,22.13 232.04,21.22 232.04,20.44 233.45,19.03 UE1.62
  IN3 w0.127: v2(170.55,20.05) 170.68,20.05 171.21,19.52 176.04,19.52 176.82,20.31 178.17,20.31 178.66,20.79 180.5,20.79 181.18,21.47 185.2,21.47 185.4,21.66 186.35,21.66 187.93,23.23 188.61,23.23 189.73,24.35 v2(190.55,24.35) 198.16,24.35 199.3,25.49 201.03,25.49 201.74,24.78 204.35,24.78 205.39,25.82 212.52,25.82 213.11,25.24 214.89,25.24 215.53,24.6 215.54,24.6 216.36,23.78 220.11,23.78 220.84,23.05 231.07,23.05 v2(231.2,22.93) 231.51,22.62 232.09,22.62 233.36,23.89 235.19,23.89 236.81,25.51 242.06,25.51 242.32,25.25 243.01,25.25 243.48,25.72 244.86,25.72 v2(245.38,26.24)
  BOTTOM w0.076: UH2.BD16 171.5,22.35 170.99,21.85 170.99,21.17 170.95,21.13 170.95,20.46 v2(170.55,20.05)
  BOTTOM w0.102: JLPDE1.6 244.52,28.23 245.38,27.38 v2(245.38,26.24) ; JNGFF1.19 190.81,23.69 190.55,23.95 v2(190.55,24.35) ; v2(231.2,22.93) v1(231.2,22.27)
LPC_LFRAME#: length 103.3
  TOP w0.102: UE1.58 231.85,17.88 229.47,20.26 229.47,21.05 229.14,21.38 229.14,23.95 v2(229.09,24.01)
  IN3 w0.127: v2(244.74,26.23) 244.74,26.38 244.52,26.61 241.18,26.61 240.59,26.02 236.53,26.02 235.29,24.78 233.26,24.78 232.18,23.71 231.56,23.71 231.32,23.94 229.16,23.94 v2(229.09,24.01) 229.09,23.94 228.71,23.56 221.05,23.56 220.32,24.29 216.57,24.29 215.75,25.11 215.74,25.11 215.1,25.75 213.32,25.75 212.73,26.33 205.17,26.33 204.16,25.31 202.03,25.31 201.33,26.01 199,26.01 198.06,25.07 v2(189.94,25.07) 189.74,25.07 188.4,23.74 187.69,23.74 186.12,22.16 185.18,22.16 184.99,21.97 180.96,21.97 180.29,21.3 178.44,21.3 177.96,20.81 176.61,20.81 176.51,20.71 174.93,20.71 174.32,21.32 174.32,21.56 174.05,21.83 173.49,21.83 173.29,21.63 173.29,20.97 173.42,20.84 173.42,20.31 173.14,20.03 171.42,20.03 v2(171.33,20.13)
  BOTTOM w0.076: UH2.BE16 171.16,21.64 171.16,20.3 v2(171.33,20.13)
  BOTTOM w0.102: JLPDE1.7 244.02,28.05 244.72,27.36 244.72,26.25 v2(244.74,26.23) ; v2(229.09,24.01) v1(228.43,23.35) ; v2(189.94,25.07) 189.94,23.86 190.31,23.49 JNGFF1.17
LX_1VALWP: length 10.6
  TOP w0.508: 250.83,17.52 252.61,17.52 v2(252.87,17.26) v2(252.87,16.63) ; 250.83,17.52 250.83,16.63 251.66,15.8 251.66,13.91 PR600.1 ; 250.83,17.52 v2(248.04,17.52) v2(248.04,16.88)
  vias: v1(251.9,16.93)
LX_3V: length 10.9
  IN1 w0.635: 53.73,16.25 55.31,14.67 58.3,14.67 59.76,13.21 v2(60.63,13.21) v2(60.63,12.45)
  BOTTOM w0.203: PU400.8 52.34,18.78 52.59,18.53 PC411.1
  vias: v2(53.4,17.49) v2(53.4,16.86)
LX_5V: length 15.3
  IN3 w0.635: v2(43.95,30.6) v2(44.71,30.6) 44.71,31.36 45.35,31.99 49.77,31.99 51.83,29.94 51.83,25.36
  BOTTOM w0.203: v2(52.28,23.99) 52.34,23.94 PU400.18
  vias: v2(45.6,30.98) v2(51.93,24.46) v3(46.05,30.47)
LX_+0.95VSP:
  vias: v1(68.7,70.44) v2(66.05,68.95) v2(68.92,68.93) v2(69.02,69.6) v2(69.61,69.6) v2(69.56,68.93) v2(70.21,69.61) v2(70.19,68.93) v2(70.19,68.29) v2(70.8,68.9) v2(70.8,68.27) v2(71.38,68.57)
LX_+1.05VSP: length 3
  TOP w0.254: v2(224.93,45.08) 224.93,44.82 224.55,44.44 224.55,42.41 PR802.1
  vias: v2(221.24,45.71) v2(221.24,45.08) v2(224.93,45.71) v3(222.84,45.05)
LX_CHG: length 13
  TOP w0.254: 24.9,23.87 v2(24.85,23.92)
  IN1 w0.635: 28.39,32.76 26.35,30.71 v2(26.35,21.33) v2(26.35,20.64)
  vias: v2(28.48,34.23) v2(28.48,33.62)
LX_DDR: length 0.6
  BOTTOM w0.102: v1(104.99,7.18) 105.32,7.51 105.47,7.51
M_CLK_DDR0: length 49.8
  IN3 w0.117: v2(105.42,37.46) 105.57,37.61 105.76,37.61 106.13,37.99 106.13,39.41 105.92,39.62 105.92,39.89 106.15,40.12 106.64,40.12 106.92,40.4 106.92,41.17 106.65,41.44 106.65,41.79 106.92,42.06 106.92,42.61 106.65,42.88 106.65,43.22 106.92,43.49 106.92,44.04 106.65,44.31 106.65,44.65 106.92,44.92 106.92,45.47 106.65,45.74 106.65,46.09 106.92,46.35 106.92,46.9 106.65,47.17 106.65,47.52 106.92,47.79 106.92,48.3 107.78,49.16 107.78,50.24 107.63,50.39 107.63,50.97 107.78,51.12 107.78,51.68 107.63,51.82 107.63,52.4 107.78,52.55 107.78,53.11 107.63,53.26 107.63,53.84 107.78,53.98 107.78,54.54 107.63,54.69 107.63,55.27 107.78,55.42 107.78,55.97 107.63,56.12 107.63,56.7 107.78,56.85 107.78,57.41 107.63,57.55 107.63,58.13 107.78,58.28 107.78,58.84 107.63,58.99 107.63,59.57 107.78,59.71 107.78,60.27 107.63,60.42 107.63,61 107.78,61.15 107.78,61.7 107.63,61.85 107.63,62.43 107.78,62.58 107.78,63.14 107.63,63.28 107.63,63.86 107.78,64.01 107.78,66.66 107.51,66.93 107.22,66.93 v2(107.06,67.08)
  BOTTOM w0.076: 109.48,72.1 109.48,72.12 109.49,72.13 109.49,73.89 109.39,73.99 109.29,73.99 109.16,73.86 UH1.AG1
  BOTTOM w0.089: v2(105.42,37.46) 105.42,37.6 105.33,37.68 105.02,37.68 104.82,37.88 104.82,39.94 104.65,40.11 JDIMM1.137 ; 109.48,72.1 109.48,72 108.95,71.47 108.95,68.43 108.86,68.34 107.92,68.34 107.73,68.15 107.73,67.7 107.92,67.5 108.91,67.5 109.03,67.39 109.03,67.06 108.91,66.94 107.2,66.94 v2(107.06,67.08)
M_CLK_DDR1: length 53.4
  IN3 w0.117: v2(107.08,70.37) 106.85,70.6 106.49,70.6 106.18,70.91 106.18,73.84 106.07,73.95 105.87,73.95 105.75,73.84 105.75,70.65 106.2,70.2 106.2,66.29 106.63,65.85 106.63,49.44 105.65,48.45 105.65,41.04 104.66,40.05 104.66,36.26 104.92,36 105.29,36 105.41,36.12 v2(105.41,36.27)
  BOTTOM w0.076: UH1.AK2 106.65,74.22 106.57,74.14 106.38,74.14 106.19,73.96 106.19,70.86 106.53,70.53 106.93,70.53 v2(107.08,70.37)
  BOTTOM w0.089: JDIMM1.138 104.9,33.61 105.06,33.77 105.06,34.49 104.75,34.79 104.75,35.74 104.98,35.97 105.27,35.97 105.41,36.1 v2(105.41,36.27)
M_CLK_DDR2: length 64.5
  IN1 w0.076: 106.62,67.64 106.62,67.66 106.61,67.67 106.61,75.1 106.86,75.34 106.86,77.01 106.47,77.41 105.87,77.41 105.53,77.74 105.53,78.89 105.28,79.15 105.17,79.15 v2(104.99,79.33)
  IN1 w0.091: v2(105.57,25.1) 105.57,25.1 105.79,25.32 105.97,25.32 106.18,25.53 106.18,26.52 105.59,27.11 105.59,27.98 104.47,29.1 104.47,32.13 104.84,32.5 104.84,34.19 104.98,34.32 104.98,39.1 104.54,39.54 104.54,39.82 104.7,39.98 105.08,39.98 105.32,40.22 105.32,50.32 108.36,53.36 108.36,54.64 107.9,55.09 107.9,55.3 108.36,55.76 108.36,63.7 106.62,65.44 106.62,67.64
  BOTTOM w0.076: UH1.AM9 v2(104.99,79.33)
  BOTTOM w0.089: JDIMM2.137 104.66,27.31 104.83,27.13 104.83,26.76 104.53,26.46 104.53,25.61 104.83,25.31 105.37,25.31 105.57,25.11 v2(105.57,25.1)
M_CLK_DDR3: length 66
  IN1 w0.076: 107.55,72.99 107.55,73.01 107.56,73.02 107.56,76.9 106.18,78.28 105.99,78.28 105.89,78.18 v2(105.89,77.97)
  IN1 w0.091: 107.55,72.99 107.55,65.24 108.95,63.83 108.95,53.25 106,50.29 106,34.61 105.35,33.96 105.35,33.58 105.55,33.39 105.74,33.39 105.83,33.29 105.83,32.88 105.74,32.79 105.55,32.79 105.35,32.59 105.35,32.02 105.55,31.83 105.74,31.83 105.83,31.74 105.83,31.32 105.74,31.23 105.55,31.23 105.35,31.03 105.35,30.46 105.55,30.27 105.74,30.27 105.83,30.18 105.83,29.76 105.74,29.67 105.55,29.67 105.35,29.47 105.35,28.92 106.1,28.17 106.1,27.31 106.77,26.64 106.77,25.32 106.21,24.76 106.21,22.56 106.08,22.43 105.97,22.43 v2(105.69,22.71)
  BOTTOM w0.076: UH1.AM7 v2(105.89,77.97)
  BOTTOM w0.089: v2(105.69,22.71) 105.48,22.49 105.28,22.49 105.03,22.24 105.03,21.01 104.91,20.89 JDIMM2.138
M_CLK_DDR#0: length 49.8
  IN3 w0.117: v2(105.41,38.23) 105.41,37.99 105.55,37.86 105.65,37.86 105.88,38.09 105.88,39.31 105.67,39.52 105.67,40 106.05,40.37 106.54,40.37 106.67,40.5 106.67,41.07 106.4,41.34 106.4,41.89 106.67,42.16 106.67,42.5 106.4,42.77 106.4,43.32 106.67,43.59 106.67,43.94 106.4,44.21 106.4,44.76 106.67,45.03 106.67,45.37 106.4,45.64 106.4,46.19 106.67,46.46 106.67,46.8 106.4,47.07 106.4,47.62 106.67,47.89 106.67,48.4 107.53,49.27 107.53,50.14 107.39,50.29 107.39,51.08 107.53,51.22 107.53,51.57 107.39,51.72 107.39,52.51 107.53,52.65 107.53,53.01 107.39,53.15 107.39,53.94 107.53,54.09 107.53,54.44 107.39,54.59 107.39,55.37 107.53,55.52 107.53,55.87 107.39,56.02 107.39,56.81 107.53,56.95 107.53,57.3 107.39,57.45 107.39,58.24 107.53,58.39 107.53,58.74 107.39,58.88 107.39,59.67 107.53,59.82 107.53,60.17 107.39,60.32 107.39,61.1 107.53,61.25 107.53,61.6 107.39,61.75 107.39,62.54 107.53,62.68 107.53,63.03 107.39,63.18 107.39,63.97 107.53,64.12 107.53,66.55 107.41,66.68 107.18,66.68 107.06,66.56 v2(107.06,66.45)
  BOTTOM w0.076: 109.66,72.07 109.66,72.12 109.65,72.13 109.65,73.96 109.46,74.16 109.26,74.16 109.16,74.26 UH1.AG2
  BOTTOM w0.089: JDIMM1.139 105.15,40.12 105.01,39.97 105.01,37.96 105.1,37.87 105.32,37.87 105.41,37.96 v2(105.41,38.23) ; v2(107.06,66.45) 107.38,66.76 108.99,66.76 109.21,66.98 109.21,67.46 108.99,67.69 108,67.69 107.91,67.78 107.91,68.07 108,68.16 108.94,68.16 109.13,68.36 109.13,71.4 109.66,71.93 109.66,72.07
M_CLK_DDR#1: length 53.3
  IN3 w0.117: v2(107.08,71.01) 106.92,70.85 106.59,70.85 106.43,71.01 106.43,73.94 106.17,74.2 105.76,74.2 105.5,73.94 105.5,70.55 105.95,70.1 105.95,66.18 106.39,65.75 106.39,49.54 105.4,48.56 105.4,41.14 104.41,40.15 104.41,36.16 104.82,35.75 105.22,35.75 v2(105.41,35.56)
  BOTTOM w0.076: v2(107.08,71.01) 107.08,70.86 106.91,70.69 106.6,70.69 106.36,70.93 106.36,73.89 106.45,73.98 106.57,73.98 106.65,73.9 UH1.AK1
  BOTTOM w0.089: JDIMM1.140 105.4,33.61 105.24,33.77 105.24,34.56 104.94,34.87 104.94,35.67 105.06,35.79 105.18,35.79 v2(105.41,35.56)
M_CLK_DDR#2: length 64.5
  IN1 w0.076: 106.44,67.58 106.44,67.66 106.45,67.67 106.45,75.16 106.7,75.41 106.7,76.94 106.4,77.24 105.8,77.24 105.37,77.67 105.37,78.82 105.21,78.99 105.08,78.99 104.97,78.88 v2(104.97,78.65)
  IN1 w0.091: v2(105.57,25.91) 105.57,25.6 105.67,25.5 105.9,25.5 106,25.6 106,26.45 105.41,27.04 105.41,27.9 104.29,29.03 104.29,32.2 104.66,32.58 104.66,34.27 104.8,34.4 104.8,39.03 104.36,39.46 104.36,39.9 104.62,40.16 105.01,40.16 105.14,40.3 105.14,50.4 108.18,53.43 108.18,54.56 107.72,55.02 107.72,55.38 108.18,55.83 108.18,63.63 106.44,65.36 106.44,67.58
  BOTTOM w0.076: UH1.AN9 104.63,79.06 104.74,79.06 104.97,78.84 v2(104.97,78.65)
  BOTTOM w0.089: JDIMM2.139 105.16,27.28 105.01,27.14 105.01,26.68 104.71,26.38 104.71,25.69 104.91,25.49 105.38,25.49 105.57,25.68 v2(105.57,25.91)
M_CLK_DDR#3: length 66.1
  IN1 w0.076: 107.73,72.99 107.73,73.01 107.72,73.02 107.72,76.97 106.25,78.44 106.07,78.44 v2(105.89,78.62)
  IN1 w0.091: v2(105.69,22.12) 105.82,22.25 106.15,22.25 106.39,22.49 106.39,24.69 106.95,25.25 106.95,26.72 106.28,27.39 106.28,28.25 105.53,29 105.53,29.4 105.63,29.49 105.82,29.49 106.01,29.68 106.01,30.25 105.82,30.45 105.63,30.45 105.53,30.54 105.53,30.96 105.63,31.05 105.82,31.05 106.01,31.24 106.01,31.81 105.82,32.01 105.63,32.01 105.53,32.1 105.53,32.52 105.63,32.61 105.82,32.61 106.01,32.8 106.01,33.37 105.82,33.57 105.63,33.57 105.53,33.66 105.53,33.89 106.18,34.53 106.18,50.22 109.13,53.18 109.13,63.91 107.73,65.31 107.73,72.99
  BOTTOM w0.076: UH1.AM8 v2(105.89,78.62)
  BOTTOM w0.089: v2(105.69,22.12) 105.5,22.31 105.36,22.31 105.21,22.17 105.21,21.11 105.41,20.92 JDIMM2.140
M_ODT0: length 52.3
  IN3 w0.178: v2(113.13,59.36) 114.08,59.36 114.42,59.02 114.42,58.63 114.25,58.45 113.51,58.45 113.33,58.27 113.33,57.69 113.51,57.51 114.58,57.51 114.77,57.32 114.77,56.77 114.59,56.59 114.28,56.59 114.1,56.41 114.1,56.06 114.28,55.88 114.59,55.88 114.77,55.7 114.77,55.28 114.1,54.62 114.1,47.42 113.23,46.54 113.23,45.52 113.41,45.34 113.96,45.34 114.14,45.16 114.14,44.81 113.96,44.63 113.41,44.63 113.23,44.45 113.23,44.1 113.41,43.92 113.96,43.92 114.14,43.74 114.14,43.39 113.96,43.21 113.41,43.21 113.23,43.03 113.23,42.01 112.71,41.49 112.71,40.94 112.89,40.76 113.27,40.76 113.45,40.58 113.45,40.23 113.27,40.05 112.89,40.05 112.71,39.87 112.71,39.09 112.89,38.91 v2(113.44,38.91)
  BOTTOM w0.076: UH1.AD3 111.96,74.75 111.96,74.22 112.15,74.03 112.15,68.82
  BOTTOM w0.17: v2(113.44,38.91) 113.29,38.77 113.14,38.77 112.97,38.6 112.97,38.3 112.8,38.13 112.46,38.13 112.29,38.3 112.29,38.74 112.12,38.91 111.72,38.91 111.55,39.08 111.55,39.49 111.15,39.88 JDIMM1.155 ; v2(113.13,59.36) 113.2,59.36 114.34,60.5 114.34,63.36 112.15,65.54 v1(112.15,68.67) 112.15,68.82
M_ODT1: length 52.4
  IN3 w0.178: v2(113.16,63.58) 116.35,60.39 116.35,50.74 115.66,50.05 115.66,42.26 114.99,41.59 114.99,35.94 114.05,34.99 113.79,34.99 113.5,35.29 v2(113.45,35.29)
  BOTTOM w0.076: 111.74,69.52 111.96,69.75 111.96,73.86 111.73,74.1 111.57,74.1 111.39,74.27 111.39,74.57 111.22,74.74 111.22,75.4 UH1.AE4
  BOTTOM w0.17: v2(113.16,63.58) 113.13,63.58 112.95,63.75 112.92,63.75 111.62,65.05 111.62,69.41 111.74,69.52 ; JDIMM1.161 112.67,40.96 112.67,40.03 112.85,39.85 113.83,39.85 114.46,39.22 114.46,36.29 113.46,35.29 v2(113.45,35.29)
M_ODT2: length 65
  IN1 w0.076: 117.77,63.78 117.77,63.95 112.01,69.71 112.01,73.83 110.93,74.91 110.93,77.53 v2(110.46,78)
  IN1 w0.193: 117.77,63.78 117.77,50.49 117.57,50.29 117.57,50.01 117.73,49.85 117.73,49.58 117.46,49.3 117.18,49.3 117.02,49.47 116.75,49.47 116.47,49.19 116.47,48.92 116.7,48.7 116.7,48.42 116.42,48.15 116.15,48.15 115.93,48.38 115.65,48.38 115.1,47.82 115.1,40.34 113.95,39.19 113.95,31.92 114.08,31.79 114.08,28.44 113.99,28.35 113.99,24.93 v2(113.95,24.88)
  BOTTOM w0.076: UH1.AF7 110.11,77.65 v2(110.46,78)
  BOTTOM w0.17: JDIMM2.155 111.16,27.05 113.32,24.88 v2(113.95,24.88)
M_ODT3: length 66.6
  IN1 w0.076: 118.76,63.63 118.76,63.8 112.49,70.08 112.49,76.55 111.75,77.28 111.75,77.47 111.35,77.86 v2(111.35,78.02)
  IN1 w0.193: 118.76,63.63 118.76,49.08 116.1,46.41 116.1,39.93 114.94,38.78 114.94,38.41 115.14,38.22 115.53,38.22 115.73,38.03 115.73,37.64 115.53,37.45 115.14,37.45 114.94,37.26 114.94,36.87 115.14,36.68 115.47,36.68 115.67,36.48 115.67,36.1 115.47,35.9 115.14,35.9 114.94,35.71 114.94,35.33 115.14,35.13 115.53,35.13 115.73,34.94 115.73,34.55 115.53,34.36 115.14,34.36 114.94,34.17 114.94,32.33 115.07,32.2 115.07,25.06 v2(115.28,24.85)
  BOTTOM w0.076: UH1.AE8 111.08,78.3 v2(111.35,78.02)
  BOTTOM w0.17: v2(115.28,24.85) 115.28,25.28 113.88,26.68 113.16,26.68 112.66,27.18 JDIMM2.161
MAINPWON: length 5
  BOTTOM w0.102: v1(56.99,44.95) 58,45.95 RT3.2 58.68,47.16 58.68,48 58.42,48.26 UT1.7
MCARD_PCIE#_SATA: length 80.2
  TOP w0.102: v2(161.7,30.57) 161.08,31.19 158.03,31.19 157.11,32.12 155.86,32.12 154.74,33.24 RH68.1
  IN2 w0.127: v2(161.7,30.57) 161.15,31.13 159.39,31.13 159.19,30.93 159.19,30.27 158.89,29.96 157.55,29.96 156.98,29.39 155.9,29.39 155.08,28.57 155.08,26.79 155.92,25.95 158.35,25.95 162.01,22.29 163.49,22.29 165.26,20.52 166.16,20.52 166.62,20.06 166.62,19.78 167.11,19.29 169.46,19.29 169.88,18.87 172.47,18.87 173.42,17.92 177.53,17.92 178.4,17.05 180.7,17.05 180.76,17.11 180.76,17.11 183,19.34 185.58,19.34 186.9,20.67 188.71,20.67 190.38,22.34 197.67,22.34 198.82,23.49 204.58,23.49 v2(205.01,23.92)
  BOTTOM w0.089: v2(161.7,30.57) 161.35,30.93 UH2.AG36
  BOTTOM w0.102: RD58.1 204.23,20.59 205.01,21.38 v2(205.01,23.92)
MCT0: length 2.6
  TOP w0.102: v2(303.41,91.35) v1(303.41,91.94)
  TOP w0.508: RL19.1 v2(303.41,91.35)
  BOTTOM w0.508: v2(303.41,91.35) 303.41,92.61 TL2.24
MCT1: length 3.3
  TOP w0.102: v2(301.1,91.15) v1(301.1,91.79)
  TOP w0.508: RL20.1 300.57,90.62 v2(301.1,91.15)
  BOTTOM w0.508: v2(301.1,91.15) 301.1,91.2 300.43,91.88 TL2.21
MCT2: length 3.3
  TOP w0.102: v2(297.16,91.35) v1(296.06,91.35)
  TOP w0.508: RL39.1 297.16,90.9 v2(297.16,91.35)
  BOTTOM w0.508: v2(297.16,91.35) 297.16,91.63 297.46,91.93 TL2.18
MCT3: length 2.8
  TOP w0.102: v2(294.49,91.34) 294.45,91.34 v1(293.94,91.85)
  TOP w0.508: RL40.1 294.52,91.3 v2(294.49,91.34)
  BOTTOM w0.508: TL2.15 v2(294.49,91.34)
MDI0+: length 40.8
  IN3 w0.089: v2(292.62,81.78) 292.88,81.51 292.88,75.37 289.95,72.44 289.95,65.4 285.02,60.47 285.02,50.31 284.69,49.98 284.69,49.39 v2(284.47,49.16)
  BOTTOM w0.089: v2(284.47,49.16) 284.67,48.96 284.67,47.21 284.61,47.15 UL1.1 ; TL2.12 292.51,82.77 292.86,82.42 292.86,82.02 v2(292.62,81.78)
MDI0-: length 40.8
  IN3 w0.089: v2(293.38,81.78) 293.11,81.51 293.11,75.28 290.18,72.35 290.18,65.3 285.25,60.37 285.25,50.21 284.92,49.88 284.92,49.34 v2(285.1,49.16)
  BOTTOM w0.089: v2(293.38,81.78) 293.14,82.02 293.14,82.42 293.5,82.77 TL2.11 ; UL1.2 285.01,47.17 284.95,47.23 284.95,49.02 v2(285.1,49.16)
MDI1+: length 41.5
  IN3 w0.089: v2(295.67,81.27) 295.86,81.08 295.86,80.51 294.8,79.46 294.8,75.76 291.27,72.23 291.27,65.07 287.59,61.38 287.59,51.29 285.91,49.61 285.91,48.35 v2(285.7,48.14)
  BOTTOM w0.089: v2(285.7,48.14) 285.75,48.14 285.86,48.02 285.86,47.41 285.81,47.36 UL1.4 ; v2(295.67,81.27) 295.83,81.44 295.83,82.42 295.48,82.77 TL2.9
MDI1-: length 41.6
  IN3 w0.089: v2(286.33,48.14) 286.14,48.33 286.14,49.52 287.82,51.2 287.82,61.29 291.5,64.97 291.5,72.13 295.03,75.66 295.03,79.37 296.09,80.42 296.09,81.05 v2(296.3,81.27)
  BOTTOM w0.089: v2(286.33,48.14) 286.26,48.14 286.14,48.02 286.14,47.44 286.21,47.36 UL1.5 ; v2(296.3,81.27) 296.11,81.46 296.11,82.42 296.47,82.77 TL2.8
MDI2+: length 45.9
  IN3 w0.089: v2(298.59,85.33) 298.87,85.05 298.87,83.71 297.47,82.31 297.47,76.37 292.9,71.8 292.9,63.92 288.89,59.9 288.89,51.03 287.17,49.31 287.17,48.54 v2(286.96,48.33)
  BOTTOM w0.089: TL2.6 298.45,84.49 298.8,84.85 298.8,85.12 v2(298.59,85.33) ; v2(286.96,48.33) 287.14,48.14 287.14,47.95 286.66,47.46 286.66,47.18 286.61,47.14 UL1.6
MDI2-: length 45.9
  IN3 w0.089: v2(287.63,48.33) 287.4,48.55 287.4,49.22 289.12,50.93 289.12,59.81 293.13,63.82 293.13,71.71 297.7,76.28 297.7,82.22 299.09,83.61 299.09,85.09 v2(299.34,85.33)
  BOTTOM w0.089: v2(287.63,48.33) 287.43,48.13 287.43,47.83 286.94,47.35 286.94,47.22 287.01,47.15 UL1.7 ; v2(299.34,85.33) 299.08,85.08 299.08,84.85 299.44,84.49 TL2.5
MDI3+: length 48.5
  IN3 w0.089: v2(301.51,85.33) 301.77,85.33 301.87,85.24 301.87,84.93 298.59,81.66 298.59,75.69 294.49,71.59 294.49,62.91 290.46,58.87 290.46,49.2 290.19,48.94 290.08,48.94 289.95,49.07 v2(289.95,49.27)
  BOTTOM w0.089: v2(301.51,85.33) 301.77,85.07 301.77,84.85 301.42,84.49 TL2.3 ; v2(289.95,49.27) 289.72,49.04 289.2,49.04 288.58,48.42 288.58,46.2 288.47,46.09 UL1.9
MDI3-: length 48.5
  IN3 w0.089: v2(289.95,48.5) 290.15,48.71 290.29,48.71 290.68,49.1 290.68,58.78 294.72,62.82 294.72,71.5 298.82,75.59 298.82,81.56 302.09,84.84 302.09,85.16 v2(302.27,85.33)
  BOTTOM w0.089: v2(302.27,85.33) 302.05,85.12 302.05,84.85 302.41,84.49 TL2.2 ; UL1.10 288.47,45.69 288.86,46.08 288.86,48.3 289.32,48.76 289.7,48.76 v2(289.95,48.5)
MDO0+: length 20.9
  BOTTOM w0.254: JLAN.1 294.48,108.4 293.25,108.4 292.05,107.19 292.05,106.31 289.86,104.13 v4(289.86,102.89) 289.86,100.89 292.51,98.24 TL2.13
MDO0-: length 20.9
  BOTTOM w0.254: TL2.14 293.5,93.73 293.29,93.93 293.09,93.93 292.88,94.14 292.88,98.4 v4(291.69,99.58) 290.23,101.04 290.23,103.98 292.41,106.16 292.41,107.04 293.41,108.03 294.33,108.03 294.52,107.84 294.52,106.54 JLAN.2
MDO1+: length 17.4
  BOTTOM w0.254: JLAN.3 293.86,105.37 293.23,104.74 292.62,104.74 291.41,103.53 v4(291.41,101.41) 291.41,101.31 293.91,98.8 293.91,94.95 295.48,93.38 TL2.16
MDO1-: length 17.4
  BOTTOM w0.254: TL2.17 296.47,93.49 296.25,93.7 295.68,93.7 294.28,95.1 294.28,98.96 291.78,101.46 v4(291.78,103.22) 291.78,103.38 292.77,104.37 293.21,104.37 293.43,104.16 293.43,103.25 JLAN.6
MDO2+: length 20.4
  TOP w0.254: v2(298.45,91.3) 298.73,91.58 298.73,92.08 298.24,92.56 295.28,92.56 293.2,94.64 293.2,98.54 292.24,99.5 292.24,102.49 293.34,103.58 293.99,103.58 294.37,103.96 JLAN.4
  BOTTOM w0.254: v2(298.45,91.3) 298.76,91.61 298.76,91.84 298.45,92.15 TL2.19
MDO2-: length 20.5
  TOP w0.254: v2(299.44,91.3) 299.09,91.64 299.09,92.23 298.39,92.93 v4(297.16,92.93) 295.43,92.93 293.57,94.79 293.57,98.69 292.61,99.65 292.61,102.33 293.49,103.21 294.14,103.21 294.26,103.33 JLAN.5
  BOTTOM w0.254: TL2.20 299.44,92.18 299.13,91.86 299.13,91.59 299.42,91.3 v2(299.44,91.3)
MDO3+: length 16.6
  TOP w0.254: JLAN.7 295.37,101.19 295.37,98.35 294.99,97.97 v4(294.99,96.19) 294.99,95.47 296.14,94.33 298.95,94.33 300.01,93.27 301.71,93.27 301.9,93.46 301.9,93.78 301.58,94.1 v2(301.41,94.1)
  BOTTOM w0.254: v2(301.41,94.1) 301.51,94.1 301.71,93.89 301.71,93.57 301.42,93.27 TL2.22
MDO3-: length 16.7
  TOP w0.254: JLAN.8 295.01,99.63 295.01,98.51 294.62,98.13 294.62,95.32 295.98,93.96 298.8,93.96 299.86,92.9 301.86,92.9 302.27,93.31 v2(302.27,94.1)
  BOTTOM w0.254: v2(302.27,94.1) 302.08,93.91 302.08,93.53 302.41,93.2 TL2.23
ME_EN: length 1.8
  TOP w0.102: v1(187.36,15.48) RH18.1 RH47.1
ME_FWP_EC: length 64.5
  TOP w0.102: 185.51,16.37 185.51,16.65 v2(185.97,17.11) ; UE1.80 v1(237.5,23.74) 237.81,23.74 238.26,24.2 238.26,25.34 RE21.1 238.44,26.35 238.3,26.49 v2(238.3,26.47)
  IN2 w0.127: v2(185.97,17.11) 186.38,16.7 187.27,16.7 188.92,18.35 191.49,18.35 192.07,18.94 194.6,18.94 195.34,19.68 197.69,19.68 199.97,21.96 207.71,21.96 208.21,22.47 211.87,22.47 212.63,21.71 213.67,21.71 214.53,20.86 216.59,20.86 216.73,21 220.2,21 220.88,21.68 222.5,21.68 224.39,23.56 226.25,23.56 227.11,24.42 229.53,24.42 229.74,24.64 229.74,25.7 230.06,26.03 237.85,26.03 238.3,26.47 v2(238.3,26.47)
ME_SUS_PWR_ACK: length 69.2
  TOP w0.102: UE1.42 225.45,17.38 226.12,18.05 226.12,20.26 v2(226.15,20.28) ; RH67.1 169.68,19.39 169.5,19.57 v1(169.5,19.9) 169.5,20.53 169.55,20.57 v2(169.55,20.98)
  IN1 w0.114: v2(226.15,20.28) 225.68,20.75 220.67,20.75 218.79,22.63 216.95,22.63 216.76,22.45 216.07,22.45 215.89,22.63 214.6,22.63 213.67,21.71 212.66,21.71 212.2,22.17 207.5,22.17 207.3,21.97 199.7,21.97 199,21.26 196.33,21.26 196.08,21.02 193.78,21.02 193.08,20.32 187.05,20.32 186.39,19.66 181.55,19.66 180.52,20.69 178.69,20.69 178.35,20.35 175.82,20.35 175.48,20.7 174.76,20.7 174.33,21.12 174.03,21.12 173.85,20.95 173.38,20.95 173.14,21.19 173.14,21.48 173.09,21.53 172.87,21.75 172.24,21.75 171.99,21.49 170.74,21.49 170.32,21.07 169.64,21.07 v2(169.55,20.98)
  BOTTOM w0.076: UH2.BD19 169.73,22.22 169.73,21.16 v2(169.55,20.98)
MEC_XTAL1: length 2.8
  TOP w0.102: RE66.2 CE102.1 222.69,36.13 223.38,36.83 Y1.1
MEC_XTAL1_R: length 4.2
  TOP w0.102: v1(224.72,34.53) RE66.1 223.61,34.13 223.3,33.82 223.3,33.29 223.85,32.74 UE1.123
MEC_XTAL2: length 6.2
  TOP w0.102: UE1.125 223.05,33.18 v1(222.88,33.36) RE106.2 CE101.1 221.7,35.75 220.88,36.57 Y1.2
MEM_VREF: length 145.1
  TOP w0.457: v2(201.56,93.03) 202.01,93.48 QV21.2
  TOP w0.508: v2(174.56,129.3) 174.5,129.3 173.62,128.42 173.62,127.04 QV20.2
  VCC w0.406: 210.96,109.59 211.47,109.08 211.47,94.56 v2(211.44,94.53) 210.12,93.21 201.71,93.21 201.56,93.06 v2(201.56,93.03)
  VCC w0.508: 210.96,109.59 197.88,122.67 192.67,122.67 188.58,126.76 188.58,131.46 187.08,132.96 174.97,132.96 174.18,132.17 174.18,129.68 v2(174.56,129.3)
  IN2 w0.508: v2(211.52,75.53) 211.85,75.86 211.85,94.12 v2(211.44,94.53)
  IN3 w0.508: v2(174.46,74.82) 175.55,74.82 175.98,74.39 180.57,74.39 180.61,74.35 186.18,74.35 186.66,73.87 192.41,73.87 193.45,72.82 203.4,72.82 203.97,72.25 205.37,72.25 208.65,75.53 v2(211.52,75.53)
  BOTTOM w0.254: v2(174.46,74.82) 173.95,75.33 173.95,76.02 173.99,76.06 173.95,76.11 UV1.L1
  BOTTOM w0.508: RV27.2 173.69,74.23 174.27,74.82 v2(174.46,74.82)
MIC2_VREFO: length 7.8
  TOP w0.203: HDA1.29 285.6,24.15 v2(285.66,24.09)
  BOTTOM w0.508: v2(285.66,24.09) 285.66,23.94 v1(286.65,22.95) 286.65,21.73 287.49,20.89 RA42.1 287.54,20.06 287.77,19.83 288.81,19.83 288.99,20.01 RA43.1
MSATA_DEVSLP: length 80.9
  IN2 w0.127: v2(158.76,30.56) 158.75,30.57 158.75,30.57 158.73,30.59 157.38,30.59 156.82,30.03 156.03,30.03 154.76,28.76 154.76,26.66 155.72,25.69 158.24,25.69 161.9,22.04 162.93,22.04 163.41,21.55 163.41,21.07 165.44,19.04 169.35,19.04 169.77,18.62 172.36,18.62 173.37,17.62 177.48,17.62 178.3,16.8 180.8,16.8 180.87,16.86 180.87,16.86 183.1,19.09 185.89,19.09 187.11,20.31 188.81,20.31 190.54,22.04 197.98,22.04 199.17,23.23 206.59,23.23 207.22,23.87 212.37,23.87 214.27,25.77 217.33,25.77 217.92,26.36 v2(217.97,26.36)
  BOTTOM w0.089: UH2.AG42 158.76,30.59 v2(158.76,30.56)
  BOTTOM w0.102: RD59.2 217.92,24.83 218.09,25.01 218.09,26.23 v2(217.97,26.36)
MSCLK: length 3.4
  BOTTOM w0.102: JDEG1.6 251.72,34.06 252.21,33.57 252.38,33.57 253.2,32.76 253.58,32.76 RE63.2
MSDATA: length 3.8
  BOTTOM w0.102: RE65.2 254,33.22 v1(253.55,33.22) 253.2,33.22 252.64,33.79 252.44,33.79 252.22,34.01 JDEG1.7
NRB_BIT: length 3.8
  TOP w0.102: RH92.2 164.6,19.68 164.86,19.93 165.24,19.93 v2(165.36,20.06)
  BOTTOM w0.076: v2(165.36,20.06) v1(165.36,20.61) 165.36,20.72 165.05,21.03 165.05,21.49 165.27,21.72 165.27,22.19 165.34,22.26 UH2.BD28
NVVDD PWM_VID: length 32.8
  IN1 w0.114: v2(172.56,78.88) 171.13,77.45 171.13,75.89 172.15,74.87 172.15,73.16 172.95,72.36 172.95,71.81 173.47,71.29 173.47,69.64 173.82,69.28 173.82,66.74 180.51,60.05 181.68,60.05 182.69,59.05 v2(183.42,59.05)
  BOTTOM w0.102: v2(183.42,59.05) 182.15,59.05 180.82,60.38 178.97,60.38 178.83,60.24 PR1000.1 ; UV1.M5 v2(172.56,78.88)
P_SYS: length 79.1
  TOP w0.102: v2(64.84,84.01) v3(63.94,84.01)
  IN2 w0.127: v2(64.84,84.01) 62.86,82.03 62.86,80.39 62.76,79.26 62.35,75.89 62.35,73.31 v2(61.88,72.84)
  BOTTOM w0.102: PU300.9 29.07,39.9 PR329.1 31,41.82 31,42.74 32.05,43.79 33.91,43.79 34.21,44.08 36.79,44.08 38.2,45.49 39.02,45.9 40.1,46.24 43.21,46.24 45.3,48.33 47.85,48.33 49.35,49.82 51.2,49.82 52.15,50.78 58.19,50.78 62.91,55.51 62.91,58.87 62.43,59.36 62.43,62.89 61.14,64.18 61.14,71.74 61.23,72.06 61.32,72.38 61.77,72.84 v2(61.88,72.84)
  BOTTOM w0.203: PU1100.1 68.62,87.37 68.36,87.11 68.36,86.88
  BOTTOM w0.254: v2(64.84,84.01) PR1100.2 PC1100.2 66.43,85.18 66.75,85.5 67.54,85.5 68.36,86.32 68.36,86.88
PANEL_BKEN_EC: length 186.1
  TOP w0.102: RV566.1 64.27,28.95 v2(64.4,29.07) ; v2(224.54,33.42) 224.57,33.45 v1(225.51,33.45) 226.25,32.7 UE1.117
  IN2 w0.127: v2(64.4,29.07) 66.18,30.85 69.86,30.85 71.31,32.3 98.59,32.3 98.9,31.99 106.27,31.99 109.76,28.51 140.4,28.51 141.44,29.55 147.24,29.55 149.17,31.47 152.08,31.47 154.62,34.01 154.62,35.76 156.14,37.28 158.79,37.28 160.26,35.8 160.57,35.8 160.79,35.58 161.75,35.58 162.07,35.27 162.07,33.74 164.86,30.95 169.79,30.95 171.17,32.33 171.17,34.2 171.26,34.29 171.67,34.7 172.88,34.7 175.83,31.75 175.83,30.42 176.13,30.11 177.83,30.11 179.65,28.29 181.53,28.29 181.57,28.34 181.58,28.34 184.96,31.72 186.39,31.72 189.65,34.99 205.04,34.99 207.58,32.45 220.76,32.45 221.4,33.08 221.4,33.63 221.82,34.05 223.91,34.05 v2(224.54,33.42)
PBAT_CHG_SMBCLK: length 302.7
  TOP w0.102: v2(221.51,26.75) 221.32,26.94 UE1.9
  IN1 w0.114: v2(220.89,10.84) 220.7,11.03 220.7,11.28 220.32,11.66 213.25,11.66 210.68,14.23 204.64,14.23 204.13,14.75 201.32,14.75 197.56,11 185,11 182.43,8.42 180.76,8.42 179.63,7.29 171.86,7.29 166.5,12.66 160.94,12.66 158.44,10.15 126.73,10.15 123.4,13.48 111.08,13.48 109.98,14.57 104.13,14.57 103.82,14.27 103.24,13.68 100.14,13.68 99.91,13.9 88.38,13.9 81.74,7.25 27.38,7.25 22.2,12.44 19.99,12.44 19.71,12.71 19.71,13.06 v2(19.9,13.25) 19.75,13.4 19.75,13.73 19.49,13.99 17.72,13.99 7.97,23.74 7.97,37.46 8.53,38.01 14.73,38.01 18.83,42.12 32.7,42.12 32.95,42.37 32.95,42.76 v2(33.12,42.94)
  BOTTOM w0.102: v2(220.89,10.84) 220.69,11.04 220.69,12.66 221.02,12.99 221.02,21.58 220.53,22.06 220.53,23.89 220.91,24.26 220.91,26.27 221.39,26.75 v2(221.51,26.75) 221.88,26.38 222.97,26.38 RE44.1 ; PR328.2 32.95,42.56 32.95,42.77 v2(33.12,42.94) ; PR108.2 23.94,14.6 23.94,14.79 23.81,14.91 22.68,14.91 22.01,14.24 21.66,14.24 21.56,14.14 21.56,13.72 21.43,13.59 PD101.2 20.77,13.97 19.86,13.97 19.67,13.78 19.67,13.48 v2(19.9,13.25)
PBAT_CHG_SMBDAT: length 304.5
  TOP w0.102: UE1.8 221.69,27.34 222.14,26.89 222.14,26.78 222.14,26.78 222.14,26.78 222.13,26.77 v2(222.13,26.76)
  IN1 w0.114: v2(32.53,42.94) 32.71,42.76 32.71,42.47 32.6,42.36 18.73,42.36 14.63,38.26 8.43,38.26 7.73,37.56 7.73,23.64 17.62,13.74 19.39,13.74 19.5,13.63 19.5,13.44 v2(19.31,13.25) 19.47,13.1 19.47,12.61 19.89,12.19 22.1,12.19 27.28,7.01 81.84,7.01 88.48,13.66 99.81,13.66 100.04,13.44 103.34,13.44 103.56,13.66 104.23,14.33 109.88,14.33 110.98,13.24 123.3,13.24 126.63,9.91 158.54,9.91 161.04,12.42 166.4,12.42 171.76,7.05 179.86,7.05 180.98,8.18 182.53,8.18 185.11,10.76 197.66,10.76 201.42,14.51 204.03,14.51 204.54,13.99 210.58,13.99 213.15,11.42 220.22,11.42 220.46,11.18 220.46,10.99 v2(220.3,10.84)
  BOTTOM w0.102: v2(19.31,13.25) 19.44,13.38 19.44,13.88 19.77,14.2 20.77,14.2 PD101.3 21.46,14.59 21.57,14.47 21.91,14.47 22.58,15.14 23.9,15.14 24.17,14.88 24.17,14.39 PR109.2 ; v2(32.53,42.94) 32.73,42.75 32.73,42.56 PR327.2 ; RE43.1 222.54,27.17 v2(222.13,26.76) 221.67,27.22 221.29,27.22 220.68,26.6 220.68,24.36 220.3,23.99 220.3,21.97 220.79,21.49 220.79,13.12 220.46,12.79 220.46,10.99 v2(220.3,10.84)
PBAT_PRES#: length 359
  TOP w0.102: UE1.97 234.25,32.68 v1(234.93,33.37) 235.48,33.91 235.48,34.28 235.66,34.46 CE76.1 239.05,34.46 240.85,32.66 240.85,31.47 241.46,30.86 241.46,29.94 242.99,28.41 242.99,27.35 243.16,27.17 243.16,24.32 242.76,23.92 v2(242.76,23.82) ; v2(36.56,42.89) 36.56,43.35 38.74,45.53 39.16,45.53 39.47,45.84 42.61,45.84 45.69,48.92 49.96,48.92 50.8,48.08 50.8,47.53 50.27,47 50.27,44.44 48.21,42.38 48.21,41.57 48.4,41.38 50.82,41.38 v2(50.94,41.27)
  IN1 w0.114: v2(242.76,23.82) 241.98,23.03 240.37,23.03 237.92,20.58 233.03,20.58 231.48,19.03 231.48,18.01 230.44,16.98 228.61,16.98 227.65,16.02 222.39,16.02 221.29,14.93 219.82,14.93 219.21,15.53 216.76,15.53 216.72,15.49 215.25,14.02 211.77,14.02 210.94,14.86 204.9,14.86 204.35,15.41 201.09,15.41 199.26,13.57 197.56,13.57 195.61,11.62 184.7,11.62 182.23,9.15 181.3,9.15 180.22,9.15 179.09,8.02 172.02,8.02 166.75,13.28 159.67,13.28 157.18,10.8 127.68,10.8 123.04,15.44 118.17,15.44 117.02,14.29 111.14,14.29 110.24,15.19 103.87,15.19 103.2,14.53 88.13,14.53 81.48,7.88 28.47,7.88 20.61,15.74 20.58,15.74 v2(20.51,15.81) 16.78,15.81 13.08,19.51 13.08,20.17 9.48,23.76 9.48,30.57 9.49,30.58 9.49,30.92 9.48,30.93 9.48,36.09 10.43,37.04 14.65,37.04 19.11,41.49 34.09,41.49 35.34,42.75 35.34,42.99 35.71,43.36 36.09,43.36 v2(36.56,42.89)
  BOTTOM w0.102: PR111.2 PR112.1 25.33,14.59 PD102.2 PD102.3 24.91,15.6 23.99,16.53 21.32,16.53 20.61,15.81 v2(20.51,15.81) ; v2(36.56,42.89) 35.95,42.28 PR321.2 ; 50.38,40.71 PC203.1 ; 50.38,40.71 v2(50.94,41.27) ; 50.38,40.71 PR208.2
PCH_BATLOW#: length 8.1
  BOTTOM w0.076: 173.24,20.95 173.24,21.07 173.19,21.12 173.19,22.37 UH2.BD13
  BOTTOM w0.102: RH81.1 170.62,16.58 170.62,16.65 170.92,16.95 171.59,16.95 172.26,17.62 172.52,17.62 172.81,17.91 172.81,19.34 173.24,19.77 173.24,20.95
PCH_CPU_BCLK_N: length 110.5
  IN3 w0.127: v2(189.75,43.01) 189.6,43.16 189.6,43.63 188.39,44.85 188.39,47.17 183.27,52.29 183.27,55.85 181.47,57.65 179.97,57.65 176.39,61.23 173.75,61.23 171.1,63.87 171.1,63.89 170.9,64.1 170.9,68.06 170.44,68.52 170.44,70.58 166.81,74.21 158.48,74.21 157.95,74.74 155.18,74.74 154.44,75.48 154.44,75.65 150.74,79.35 150.74,82.45 142.27,90.92 139.66,90.92 137.14,93.44 137.14,94.96 137.55,95.37 137.55,96.12 137.24,96.43 136.66,96.43 v2(136.59,96.51)
  BOTTOM w0.076: UH2.H2 178.49,40.29 179.17,40.29 179.24,40.35 180.12,40.35 180.19,40.42 180.19,40.42 180.2,40.43
  BOTTOM w0.102: v2(136.59,96.51) 136.59,96.33 136.39,96.13 135.85,96.13 134.55,94.83 134.09,94.83 133.76,94.5 130.41,94.5 129.78,95.14 129.78,96.03 129.3,96.51 128.67,96.51 128.55,96.62 128.55,96.81 128.46,96.91 128.28,96.91 128.21,96.84 UH1.A32 ; v2(189.75,43.01) 189.56,42.82 189.56,42.58 189.18,42.19 188.42,42.19 187.29,41.06 180.84,41.06 180.2,40.43
PCH_CPU_BCLK_P: length 110.5
  IN3 w0.127: v2(189.11,43.01) 189.35,43.24 189.35,43.53 188.14,44.74 188.14,47.07 183.02,52.19 183.02,55.74 181.37,57.39 179.87,57.39 176.28,60.98 173.64,60.98 170.85,63.77 170.85,63.79 170.65,63.99 170.65,67.96 170.19,68.42 170.19,70.47 166.71,73.96 158.38,73.96 157.85,74.49 155.08,74.49 154.19,75.37 154.19,75.55 150.49,79.25 150.49,82.35 142.17,90.67 139.55,90.67 136.89,93.33 136.89,95.06 137.3,95.47 137.3,96.02 137.14,96.18 136.85,96.18 136.76,96.09 136.62,96.09 136.51,95.98 136.51,95.83 v2(136.6,95.75)
  BOTTOM w0.076: 180.04,40.55 180.02,40.54 180.02,40.51 179.17,40.51 179.11,40.45 178.45,40.45 178.31,40.59 UH2.G2
  BOTTOM w0.102: 180.04,40.55 180.75,41.27 187.21,41.27 188.34,42.4 189.09,42.4 189.36,42.66 189.36,42.76 v2(189.11,43.01) ; UH1.B31 127.65,96.26 128.38,96.26 128.43,96.3 129.21,96.3 129.58,95.94 129.58,95.05 130.33,94.3 133.84,94.3 134.17,94.63 134.64,94.63 135.93,95.93 136.42,95.93 v2(136.6,95.75)
PCH_CPU_PCIBCLK_N: length 113.9
  IN3 w0.127: v2(126.08,98.79) 126.57,99.28 126.8,99.28 128.99,101.47 131.11,101.47 132.36,100.23 133.12,100.23 134.76,98.59 134.76,96.64 135.36,96.03 135.36,93.46 139.51,89.32 142.91,89.32 150.06,82.17 150.06,79.06 153.73,75.39 153.73,75.12 154.8,74.06 157.41,74.06 158.36,73.1 164.46,73.1 164.7,73.34 166.66,73.34 169.74,70.27 169.74,68.24 170.12,67.85 170.12,63.82 173.8,60.13 175.78,60.13 177.86,58.05 177.86,57.47 178.7,56.63 178.7,55.87 179.08,55.49 179.71,55.49 182.51,52.7 182.51,51.88 187.71,46.69 187.71,43.82 189.57,41.96 189.57,41.52 v2(189.77,41.32)
  BOTTOM w0.102: v2(126.08,98.79) 126.73,98.79 UH1.C36 ; v2(189.77,41.32) 189.71,41.32 189.34,40.94 189.34,40.75 189.04,40.45 181.09,40.45 180.35,39.72 179.22,39.72 179.05,39.54 178.91,39.54 UH2.J1
PCH_CPU_PCIBCLK_P: length 113.9
  IN3 w0.127: v2(189.14,41.32) 189.32,41.5 189.32,41.85 187.45,43.72 187.45,46.58 182.26,51.78 182.26,52.59 179.61,55.24 178.98,55.24 178.45,55.77 178.45,56.53 177.61,57.37 177.61,57.95 175.68,59.88 173.69,59.88 169.87,63.71 169.87,67.75 169.48,68.13 169.48,70.16 166.56,73.09 164.8,73.09 164.56,72.85 158.26,72.85 157.31,73.81 154.69,73.81 153.48,75.02 153.48,75.28 149.81,78.96 149.81,82.07 142.8,89.07 139.4,89.07 135.11,93.36 135.11,95.93 134.51,96.53 134.51,98.48 133.01,99.97 132.26,99.97 131.01,101.22 129.1,101.22 126.9,99.03 126.67,99.03 126.51,98.86 126.51,98.51 126.63,98.39 127.02,98.39 v2(127.07,98.43)
  BOTTOM w0.102: v2(189.14,41.32) 189.14,40.84 188.96,40.66 181,40.66 180.27,39.92 178.67,39.92 178.47,39.72 UH2.J2 ; v2(127.07,98.43) 127.02,98.48 126.44,98.48 UH1.D35
PCH_DPWROK: length 7.2
  TOP w0.102: RH9.2 178.5,26.79 RH13.2 177.61,26.71 v3(177.12,27.19) 177.12,26.71 176.34,25.92 174.85,25.92 v2(174.58,25.66)
  BOTTOM w0.089: v2(174.58,25.66) 174.32,25.66 UH2.AV11
PCH_JTAG_TCK: length 14.9
  BOTTOM w0.076: UH2.AN3 178.14,27.77 178.33,27.58 179.02,27.58 179.36,27.92 181.33,27.92 182.38,28.97 183.02,28.97
  BOTTOM w0.102: 183.02,28.97 184.46,30.42 185.43,30.42 v3(187.79,32.78) 189.37,34.36 RH95.2
PCH_JTAG_TDI: length 194.1
  TOP w0.102: v2(182.74,28.08) 182.81,28.16 182.81,31.03 182.13,31.71 182.13,32.25 181.98,32.4 v3(181.98,32.78) 181.11,33.65 RH100.2 ; v2(81.11,97.4) 83.96,97.4 84.59,96.76 RH118.1
  IN1 w0.114: v2(182.74,28.08) 182.66,28.16 177.2,28.16 176.77,27.73 175.9,27.73 175.51,28.12 174,28.12 173.75,27.87 172.29,27.87 172.03,27.61 168.24,27.61 167.46,28.39 167.46,29.16 167.1,29.52 165.06,29.52 164.74,29.83 164.74,31.17 163.34,32.57 158.35,32.57 157.21,33.71 154.28,33.71 153.3,34.69 152.87,34.69 146.73,40.82 146.73,41.56 141.58,46.72 141.58,62.12 147.08,67.62 147.08,70.63 147.38,70.93 147.38,72.5 145.73,74.15 145.73,74.95 146.11,75.33 146.11,82.13 146.26,82.29 v2(146.26,82.45)
  IN2 w0.127: v2(146.26,82.45) 145.26,82.45 141.41,86.3 141.41,97.88 132.06,107.23 88.33,107.23 81.09,99.99 81.09,97.42 v2(81.11,97.4)
  BOTTOM w0.076: UH2.AP2 178.45,27.21 178.74,26.91 180.86,26.91 182.03,28.08 v2(182.74,28.08)
PCH_JTAG_TDO: length 196.7
  TOP w0.102: v2(83.68,94.35) 84.65,94.35 RH115.1 ; RH97.2 182,33.62 182.33,33.29 v2(183.09,33.29) 183.09,30.65 183.19,30.55 v3(183.19,29.86) 183.19,28.9 183.22,28.87 v2(183.22,28.46)
  IN2 w0.127: v2(183.09,33.29) 183.91,34.11 184.65,34.11 185.96,35.42 185.96,37.7 181.53,42.14 181.53,44.66 177.91,48.28 170.83,48.28 170.01,47.46 150.25,47.46 147.62,44.82 142.93,44.82 140.65,47.1 140.65,57.12 146.77,63.24 146.77,70.61 147.05,70.89 147.05,75.49 146.26,76.27 146.26,78.4 140.09,84.57 140.09,96.04 134.78,101.35 134.78,102.45 131.4,105.83 105.17,105.83 104.45,105.12 101.79,105.12 100.99,105.92 89.93,105.92 89.14,105.13 89.14,105.12 84.57,100.55 84.57,95.23 v2(83.68,94.35)
  BOTTOM w0.076: UH2.AP1 178.94,27.08 180.77,27.08 182.15,28.46 v2(183.22,28.46)
PCH_JTAG_TMS: length 13.1
  TOP w0.102: RH98.2 RH492.1 v3(183.78,32.27) 183.78,31.71 183.58,31.51 183.58,28.7 v2(183.82,28.46)
  BOTTOM w0.076: UH2.AR2 178.4,26.58 181.14,26.58
  BOTTOM w0.102: v2(183.82,28.46) 183.82,28.3 183.55,28.03 183.22,28.03 182.33,27.14 181.7,27.14 181.14,26.58
PCH_JTAGX: length 188.4
  IN1 w0.114: v2(143.65,82.31) 144.84,82.31 145.82,81.33 145.82,75.38 145.49,75.05 145.49,74.05 147.14,72.4 147.14,71.03 146.83,70.73 146.83,67.72 141.34,62.22 141.34,46.62 146.49,41.46 146.49,40.72 151.39,35.82 151.39,34.56 152.49,33.47 157.11,33.47 158.25,32.32 163.24,32.32 164.5,31.07 164.5,29.73 164.96,29.28 166.94,29.28 167.22,29 167.22,28.49 167.22,28.29 168.14,27.36 169.46,27.36 170.04,26.78 170.91,26.78 171.28,27.14 171.9,27.14 172.39,27.63 173.89,27.63 174.06,27.8 175.4,27.8 175.75,27.45 177.38,27.45 177.48,27.55 179.51,27.55 180.07,27 181.07,27 181.67,27.6 v2(182.2,27.6)
  IN2 w0.127: v2(83.7,91.91) 83.19,92.42 83.19,100.32 89.32,106.44 131.68,106.44 140.65,97.48 140.65,85.63 143.65,82.63 v2(143.65,82.31)
  BOTTOM w0.076: v2(182.2,27.6) 181.87,27.6 181.02,26.75 178.62,26.75 178.55,26.83 178.25,26.83 178.01,26.59 UH2.AR3
  BOTTOM w0.102: v2(83.7,91.91) 83.7,91.99 83.91,92.19 RH38.1 ; v2(143.65,82.31) v1(143.65,81.32)
PCH_PCIE_WAKE#: length 12.8
  BOTTOM w0.076: UH2.BC13 173.42,22.65 173.42,22.2 173.36,22.15 173.36,21.22 173.43,21.16 173.43,20.92
  BOTTOM w0.102: RH114.1 173.47,13.33 172.55,14.24 171.76,14.24 171.56,14.44 171.56,15.84 RH17.1 171.46,16.7 171.67,16.7 172.22,17.25 v1(172.36,17.25) 172.43,17.31 172.58,17.31 173.04,17.77 173.04,17.93 173.04,17.93 173.04,19.25 173.43,19.64 173.43,20.92
PCH_PLTRST#: length 12.6
  BOTTOM w0.076: UH2.BB27 166.57,23.04 166.57,22.48 166.62,22.44 166.62,20.1
  BOTTOM w0.102: 166.51,16.53 166.3,16.53 166.11,16.33 UH7.1 166.11,15.33 166.69,14.75 167.66,14.75 168.37,14.04 RH1.1 ; 166.51,16.53 166.76,16.27 UH7.2 ; 166.51,16.53 166.58,16.6 v1(166.58,17.01) 166.39,17.2 166.39,19.88 166.62,20.1
PCH_PLTRST#_EC: length 269
  TOP w0.102: v2(228.84,18.91) 228.84,18.84 229.4,18.28 230.05,18.28 231.05,17.28 UE1.56 231.05,14.98 230.79,14.72 v2(230.44,14.72) ; v2(196.22,20.41) 196.22,20.59 198.54,22.9 198.54,24.45 197.46,25.52 v2(197.46,26.74)
  IN1 w0.114: v2(228.84,18.91) 228.61,18.68 226.76,18.68 225.59,19.85 220.25,19.85 219.03,21.07 218.04,21.07 217.35,21.77 216.15,21.77 215.81,22.11 214.74,22.11 v2(214.59,21.96)
  IN2 w0.127: v2(286.62,38.85) 286.62,38.83 286.37,38.57 279.71,38.57 278.5,37.35 278.5,36.97 277.77,36.25 273.36,36.25 267.58,30.47 260.41,30.47 259.73,29.78 256.1,29.78 254.68,28.36 250.64,28.36 245.91,23.64 v2(245.33,23.64) ; v2(214.59,21.96) 213.95,22.6 213.6,22.6 213.22,22.98 207.66,22.98 207.15,22.47 199.56,22.47 198.29,21.2 198.28,21.2 198.18,21.1 196.91,21.1 v2(196.22,20.41) 195.29,20.41 194.43,19.55 191.97,19.55 191.38,18.96 187.82,18.96 186.83,17.97 183.49,17.97 180.7,15.18 180.27,15.18 178.58,13.49 170.52,13.49 v2(169.74,14.27) 169.96,14.49 169.96,15.26 169.68,15.53 164.25,15.53 163.26,16.53 161.83,16.53 160.84,15.53 160.23,15.53 159.47,16.3 159.47,17.16 158.33,18.3 156.93,18.3 155.82,19.42 155.82,20.38 151.93,24.27 151.93,26.66 151.18,27.41 v2(151.18,28.48)
  IN3 w0.127: v2(228.84,18.91) 228.84,18.84 229.07,18.61 229.65,18.61 230.16,19.12 231.4,19.12 231.86,19.57 234.81,19.57 236.04,20.81 237.88,20.81 238.8,21.72 238.8,22.5 239.39,23.09 243.27,23.09 244,23.82 245.15,23.82 v2(245.33,23.64)
  BOTTOM w0.102: JNGFF2.50 213.84,24.57 213.14,23.87 213.14,22.98 214.16,21.96 v2(214.59,21.96) ; UH7.4 167.54,14.03 168.44,13.12 RH1.2 169.28,13.12 RH77.1 169.67,14.2 v2(169.74,14.27) ; UL1.19 286.61,42.13 287.13,41.61 287.13,39.59 286.74,39.19 286.74,38.97 v2(286.62,38.85) ; v2(151.18,28.48) 151.18,28.73 149.94,29.96 148.79,29.96 148.41,29.58 142.76,29.58 142.31,30.03 142.31,33.18 142.62,33.48 143.16,33.48 143.71,34.03 143.71,43.55 141.36,45.91 141.36,52.31 140.47,53.19 140.47,64.13 135.65,68.95 135.65,72.99 135.87,73.22 135.87,74.01 136.34,74.48 137.52,74.48 138.06,75.02 138.86,75.02 138.97,75.14 139.69,75.14 140.36,75.81 140.57,75.81 140.66,75.9 142.69,75.9 142.91,76.12 142.91,76.67 142.63,76.95 UV14.2 ; CE72.1 230.64,14.93 v2(230.44,14.72) ; v2(197.46,26.74) 197.46,27.23 197.06,27.63 JNGFF1.44 ; JLPDE1.8 243.52,27.82 244.17,27.18 244.17,24.85 245.33,23.69 v2(245.33,23.64)
PCH_PWROK: length 19
  TOP w0.102: RH94.1 188,27.46 UH14.4 186.89,26.97 v2(186.8,27.07) ; RH94.1 RH102.2 ; RH94.1 188.52,28.74 v3(188.94,29.15)
  IN3 w0.127: v2(174.63,25.06) 174.71,25.06 175.39,24.38 178.43,24.38 178.76,24.7 178.77,24.7 178.82,24.76 181.32,24.76 181.65,25.09 184.82,25.09 v2(186.8,27.07)
  BOTTOM w0.089: UH2.AW11 174.07,24.64 174.48,25.06 v2(174.63,25.06)
PCH_RSMRST#: length 87.4
  TOP w0.102: v2(179.21,12.56) 179.21,16.78 180.15,17.72 180.88,17.72 RH503.1 181.81,18.33 182.03,18.54 182.03,19.5 181.59,19.93 181.59,21.67 181.84,21.91 181.84,22.48 v3(181.82,22.49) 181.84,22.51 181.84,25.07 180.65,26.25 180.32,26.25 RH9.1 ; UE1.88 237.01,26.94 237.03,26.96 237.58,26.96 237.86,26.69 v2(237.86,25.02)
  IN2 w0.127: v2(179.21,12.56) 179.45,12.56 183.34,16.45 187.39,16.45 189.04,18.1 191.68,18.1 192.26,18.68 194.73,18.68 195.46,19.42 197.81,19.42 200.1,21.71 208.06,21.71 208.52,22.16 211.82,22.16 212.53,21.45 213.57,21.45 214.42,20.6 214.42,20.6 214.46,20.56 216.31,20.56 217.02,19.85 219.57,19.85 221.14,21.42 222.61,21.42 224.49,23.31 229.25,23.31 230.9,24.96 231.76,24.96 232.57,25.77 237.11,25.77 v2(237.86,25.02)
PCH_RSMRST#_R: length 11.4
  TOP w0.102: v2(174.63,24.48) 175.09,24.02 175.09,23.36 176.04,22.41 176.04,21.19 176.18,21.05 176.68,21.05 177.06,20.67 v1(177.58,20.67) 179.31,20.67 179.69,20.28 179.69,19.57 180.02,19.24 RH88.2 RH503.2
  BOTTOM w0.089: UH2.BA11 174.07,23.91 v2(174.63,24.48)
PCH_RTCRST#: length 19.9
  TOP w0.102: JAPS.9 177.18,12.29 v2(177.48,12.59) 177.48,14.09 178.01,14.62 v3(178.01,15.2) 178.01,17.39 177.38,18.02 173.83,18.02 173.08,18.78 173.08,19.29 173.47,19.68 CH53.1 ; v2(174.18,20.69) 174.38,20.49 CH53.1 ; CH53.1 RH84.2
  BOTTOM w0.076: UH2.BC10 174.2,22.74 174.2,22.25 174.23,22.22 174.23,21.77 174.36,21.65 174.36,20.87 v2(174.18,20.69)
  BOTTOM w0.102: CLRP1.1 177.48,13.5 v2(177.48,12.59)
PCH_RTCX1: length 7.6
  BOTTOM w0.076: 175.03,20.68 174.69,21.03 174.69,21.78 174.56,21.91 174.56,22.1 174.68,22.22 174.68,22.84 UH2.BC9
  BOTTOM w0.089: 175.03,20.68 175.09,20.63
  BOTTOM w0.127: YH1.1 176.27,16.65 175.48,17.43 CH45.1 175.48,19.03 RH70.1 v1(175.47,20.06) 175.47,20.25 175.09,20.63
PCH_RTCX2: length 6.6
  BOTTOM w0.076: 174.62,20.64 174.62,20.84 174.52,20.93 174.52,21.71 174.39,21.84 174.39,22.17 174.51,22.29 UH2.BD10
  BOTTOM w0.127: 173.77,16.37 173.77,16.82 174.62,17.67 CH46.1 174.62,18.98 RH70.2 174.62,19.1 174.62,20.64
PCH_SATA_LED#: length 157.3
  TOP w0.102: RH80.1 151.98,30.55 v2(151.9,30.47)
  IN2 w0.127: v2(60.72,28.82) 61.2,28.34 67.62,28.34 68.05,28.77 108.27,28.77 109.33,27.71 111.21,27.71 111.54,27.37 117.13,27.37 117.44,27.68 141.11,27.68 141.44,28.01 147.39,28.01 149.05,29.67 151.1,29.67 v2(151.9,30.47)
  IN3 w0.127: v2(23.66,16.09) 24.19,16.63 27.31,16.63 28.33,15.61 36.08,15.61 36.97,14.72 40.6,14.72 41.13,15.26 47.81,15.26 52.44,19.88 54.77,19.88 57.36,22.47 57.36,23.31 60.23,26.18 60.23,28.34 v2(60.72,28.82)
  BOTTOM w0.089: 155.99,32.05 157.46,32.05 UH2.AD44
  BOTTOM w0.102: v2(23.66,16.09) 22.13,16.09 21.12,15.08 20.12,15.08 v1(19.52,15.69) RH502.1 19.52,17.69 19.19,18.02 17.87,18.02 17.41,18.48 16.68,18.48 16.39,18.19 QE21.2 ; 155.99,32.05 153.86,32.05 152.28,30.47 v2(151.9,30.47)
PCH_SMBCLK: length 44.5
  TOP w0.102: RH27.2 153.56,21.37 QH4.1 152.35,21.49 151.89,21.49 v2(151.66,21.72)
  IN1 w0.114: v2(151.66,21.72) 150.96,22.42 148.82,22.42 148,23.23 141.04,23.23 v2(140.6,23.68) 140.8,23.88 140.8,26.88 139.95,27.73 139.95,30.99 v2(140.42,31.46)
  BOTTOM w0.102: JDIMM2.253 135.66,26.54 136.53,25.66 136.53,23.61 137.04,23.1 140.03,23.1 v2(140.6,23.68) ; v2(140.42,31.46) 140.19,31.23 139.96,31.23 139.71,31.49 139.71,32.37 139.11,32.97 139.11,34.88 138.53,35.46 137.45,35.46 136.54,36.37 136.54,39.32 135.65,40.2 JDIMM1.253
PCH_SMBDATA: length 36.1
  TOP w0.102: v2(149.3,23.36) 149.43,23.23 149.43,22.74 RH26.2 149.49,22.67 QH4.4
  IN1 w0.114: v2(140.42,30.83) 140.19,30.6 140.19,27.83 141.04,26.98 141.04,23.87 v2(141.23,23.68) 141.44,23.47 148.1,23.47 148.92,22.66 149.17,22.66 149.3,22.79 v2(149.3,23.36)
  BOTTOM w0.102: JDIMM2.254 135.91,21.78 136.98,22.85 140.41,22.85 v2(141.23,23.68) ; v2(140.42,30.83) 140.24,31 139.87,31 139.48,31.39 139.48,32.28 138.88,32.88 138.88,34.79 138.44,35.23 137.42,35.23 135.9,33.71 JDIMM1.254
PCH_SPI_CLK: length 4.8
  BOTTOM w0.076: UH2.BC31 164.06,22.79 164.29,22.56 164.29,22.26 164.22,22.19 164.22,21.06 163.32,20.16
  BOTTOM w0.102: 163.32,20.16 v1(163.03,19.87) 162.32,19.16 RH507.1
PCH_SPI_CLK_R: length 2.7
  BOTTOM w0.102: UH8.6 173.57,9.01 173.48,8.92 v1(173.15,8.92) 172.6,8.37 RE126.2
PCH_SPI_CS#: length 10
  BOTTOM w0.076: UH2.BD31 164.02,22.37 164.02,21.13 163.18,20.28 162.9,20.28 161.68,19.07 161.68,17.9 161.72,17.86 161.72,16.44 161.43,16.14 v1(161.43,15.71) 161.86,15.28 RH101.1
  BOTTOM w0.102: RH74.2 RH101.1
PCH_SPI_HOLD#: length 7.8
  BOTTOM w0.076: UH2.BD30 164.68,22.35 164.39,22.05 164.39,20.86 163.88,20.35 163.88,20.17
  BOTTOM w0.102: 163.88,20.17 163.88,19.6 RH104.1 163.66,18.47 163.66,16.78 163.46,16.58 v1(162.49,16.58)
PCH_SPI_HOLD#_R: length 2.8
  BOTTOM w0.102: RE71.2 172.55,10.28 v1(173.09,10.28) UH8.7
PCH_SPI_SI: length 4.8
  BOTTOM w0.076: UH2.BB29 165.22,23.23 165.01,23.02 165.01,22.83 164.91,22.74 164.91,21.86 164.72,21.67 164.72,20.65
  BOTTOM w0.102: RH509.1 164.72,19.19 164.72,20.65
PCH_SPI_SI_R: length 2.6
  BOTTOM w0.102: UH8.5 173.57,7.74 173.47,7.64 v1(173.14,7.64) 172.86,7.36 RE128.2
PCH_SPI_SO: length 3.3
  BOTTOM w0.076: 164.31,20.53 164.55,20.77 164.55,21.86 UH2.BE30
  BOTTOM w0.102: 164.31,20.53 v1(164.31,19.85) 164.31,19.14 RH508.1
PCH_SPI_SO_R: length 3.7
  BOTTOM w0.102: RE127.2 183.87,11.59 v1(183.41,11.59) 183.41,11.45 183.47,11.38 183.47,10.71 183.04,10.28 UH8.2
PCH_SPI_WP#: length 4.5
  BOTTOM w0.076: 164.96,20.84 164.88,20.92 164.88,21.58 165.09,21.79 165.09,22.51 165.24,22.66 UH2.BC29
  BOTTOM w0.102: RH510.1 165.67,19.05 164.96,19.76 164.96,20.84
PCH_SPI_WP#_R: length 3
  BOTTOM w0.102: UH8.3 182.64,9.01 v1(183.33,9.71) 183.88,10.25 RE129.2
PCH_SRTCRST#: length 6.4
  TOP w0.254: v2(174.62,23.88) 174.51,23.76 174.51,22.95 CH52.1 175.54,21.92 v1(175.54,20.72) 175.7,20.56 175.81,20.56 175.84,20.54 176.36,20.54 177.05,19.85 RH83.2
  BOTTOM w0.089: UH2.BB10 174.31,23.68 174.44,23.81 174.55,23.81 v2(174.62,23.88)
PCH_TRIGGER: length 120.4
  TOP w0.102: RH167.1 v2(135.9,93.59)
  IN2 w0.127: v2(181.09,29.36) 180.18,29.36 178.7,30.85 178.7,32.1 178.92,32.32 179.88,32.32 183.14,35.58 183.14,37.61 182.17,38.59 181.94,38.59 180.26,40.26 180.26,44.13 177.43,46.95 171.3,46.95 170.54,46.19 160.94,46.19 160.89,46.14 150.73,46.14 148.13,43.54 142.42,43.54 139.38,46.58 139.38,57.64 143.34,61.61 143.34,72.99 139.61,76.73 139.61,77.39 136.03,80.97 136.03,93.44 135.9,93.57 v2(135.9,93.59)
  BOTTOM w0.076: UH2.AL2 178.5,28.86 178.6,28.76 180.18,28.76 180.4,28.99 v1(180.72,28.99) v2(181.09,29.36)
PCH_TRIGGER_R: length 12.3
  TOP w0.102: v2(131.96,91.99) 132.06,92.09 132.55,92.09 RH167.2
  IN1 w0.114: v2(131.96,91.99) 129.83,89.86 124.37,89.86 v2(123.98,89.47)
  BOTTOM w0.076: UH1.H23 123.61,89.84 v2(123.98,89.47)
PCIE_PRX_LANTX_N3_C: length 2.4
  BOTTOM w0.102: UL1.18 287.01,42.19 287.91,41.29 287.91,40.96 CL31.2
PCIE_PRX_LANTX_N5: length 132.8
  IN1 w0.114: v2(287.66,38.65) 287.71,38.69 287.88,38.69 288.03,38.54 288.03,38.37 287.74,38.09 286.89,38.09 286.66,38.32 283.84,38.32 282.57,37.05 278.97,37.05 277.89,35.98 275.35,35.98 270.65,31.27 270.21,31.27 269,30.06 255.2,30.06 254.26,29.12 234.4,29.12 234.13,28.84 221.93,28.84 221.6,29.17 214.1,29.17 213.63,28.71 211.85,28.71 210.78,29.78 208.57,29.78 207.88,30.47 206,30.47 204.31,32.17 199.43,32.17 196.85,29.58 190.41,29.58 186.05,33.94 182.44,33.94 180.81,35.57 178.99,35.57 178.76,35.34 174.72,35.34 173.61,36.44 173.61,37.94 172.29,39.26 171.4,39.26 171.13,39.54 170.57,39.54 170.32,39.79 v2(170.32,39.84)
  BOTTOM w0.102: v2(287.66,38.65) 287.98,38.97 287.98,39.47 CL31.1 ; UH2.K19 169.77,39.53 170.09,39.84 v2(170.32,39.84)
