# Allegro board Dell Inspiron 15 Gaming 7566 Compal LA-D991P BCV00 Rev1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HDA_SDOUT: length 20.4
  TOP w0.102: v2(185.33,14.19) 185.51,14.37 RH18.2 ; v2(180.18,20.2) 180.18,20.35 179.48,21.05 177.24,21.05 177,21.3 177,22.09 175.52,23.56 v2(175.52,23.94) 176.2,24.62 CH51.2
  BOTTOM w0.089: v2(175.52,23.94) 175.63,23.94 175.81,23.75 UH2.BB7
  BOTTOM w0.102: v2(180.18,20.2) 180.97,19.41 RP15.8 180.97,16.64 181.49,16.12 181.49,15.36 182.51,14.34 185.18,14.34 v2(185.33,14.19)
HDA_SDOUT_AUDIO: length 104.3
  IN3 w0.127: v2(187.37,12.98) 187.37,13.51 189.21,15.36 198.57,15.36 200.27,17.06 208.31,17.06 209.48,15.89 215.22,15.89 216.07,16.73 220.61,16.73 221.12,16.22 230.69,16.22 232.36,17.9 234.68,17.9 236.83,20.04 238.2,20.04 239.44,21.28 240.95,21.28 241.58,21.91 241.58,22.35 241.78,22.55 243.57,22.55 244.15,23.13 244.59,23.13 244.79,22.93 245.6,22.93 246.43,23.75 252,23.75 252.52,24.27 259.62,24.27 260.56,23.33 261.89,23.33 263.75,25.19 267.88,25.19 268.18,24.88 270.11,24.88 270.52,25.29 v2(270.52,25.34)
  BOTTOM w0.102: v2(187.37,12.98) 186.59,13.76 184.79,13.76 184.46,14.09 182.13,14.09 v1(181.87,14.34) 180.97,15.24 RP15.1 ; v2(270.52,25.34) 270.65,25.21 271.08,25.64 271.54,25.64 272.42,26.53 273.19,26.53 273.64,26.08 CA31.1 RA29.1
HDA_SYNC: length 8.8
  BOTTOM w0.089: 175.47,20.92 175.47,21.71 174.91,22.27 UH2.BD9
  BOTTOM w0.102: 175.47,20.92 177.65,18.74 177.65,18.03 v1(178.15,17.53) 179.73,17.53 179.97,17.29 RP15.6
HDA_SYNC_AUDIO: length 115.8
  TOP w0.102: HDA1.10 277.12,23.36 277.04,23.27 v2(276.96,23.27)
  IN3 w0.127: v2(271,23.84) 270.93,23.77 268.08,23.77 265.41,21.11 265.41,17.11 265.08,16.78 260.21,16.78 257.57,19.42 255.67,19.42 253.06,22.04 248.59,22.04 247.85,22.77 245.91,22.77 245.25,22.11 243.42,22.11 242.33,21.03 239.54,21.03 238.3,19.79 236.93,19.79 236.57,19.43 236.57,18.75 234.84,17.02 231.84,17.02 230.79,15.97 220.99,15.97 220.48,16.48 216.24,16.48 215.4,15.64 209.38,15.64 208.26,16.75 200.49,16.75 198.84,15.1 189.32,15.1 187.91,13.69 187.91,12.65 v2(187.33,12.08)
  BOTTOM w0.102: v2(187.33,12.08) 186.45,12.08 185.94,12.59 184.34,12.59 183.8,13.12 v1(182.94,13.12) 181.73,13.12 179.97,14.88 RP15.3 ; v2(271,23.84) 271.15,23.84 271.97,23.03 272.97,23.03 273.63,22.37 275.78,22.37 276.64,23.23 276.92,23.23 v2(276.96,23.27)
HDD_DEVSLP: length 59.6
  TOP w0.102: v2(194.02,20.51) v1(194.02,18.91) 194.02,17.1 RD62.1
  IN2 w0.127: v2(194.02,20.51) 191.55,20.51 191.02,19.98 187.59,19.98 186.34,18.74 183.1,18.74 180.98,16.61 180.97,16.61 180.91,16.54 179.99,16.54 177.84,14.39 173.09,14.39 171.82,15.66 171.82,17.57 171.02,18.37 169.55,18.37 169.13,18.79 165.33,18.79 163.15,20.97 163.15,21.45 162.82,21.78 161.8,21.78 161.06,22.52 159.67,22.52 157.41,24.78 155.25,24.78 154.44,25.59 154.44,28.95 v2(156.07,30.57)
  BOTTOM w0.102: v2(156.07,30.57) 156.45,30.95 157.22,30.95 157.48,31.21 157.82,31.21 158.02,31.01 UH2.AG43
HDD_DEVSLP_R: length 4.6
  TOP w0.102: RD62.2 194.59,15.58 v3(194.59,14.51) 194.59,14.09 v2(194.26,13.76)
  BOTTOM w0.102: JHDD1.5 193.67,13.18 v2(194.26,13.76)
HDMI_CEC: length 78.7
  TOP w0.102: RM19.2 271.64,32.88 v2(272.31,33.56)
  IN3 w0.127: v2(272.31,33.56) 276.93,33.56 278.49,35.11 278.49,37.32 280.71,39.54 285.79,39.54 286.14,39.18 286.14,38.7 286.65,38.19 289.06,38.19 290.05,39.18 290.05,40.71 290.56,41.21 290.56,44.8 292.26,46.5 292.26,57.46 293.87,59.06 294.66,59.06 295.78,60.18 295.78,64.7 298.05,66.97 298.05,73.4 v2(298.12,73.47)
  BOTTOM w0.102: v2(298.12,73.47) 298.18,73.53 298.18,74.97 v1(297.36,75.8) 296.38,76.77 CV601.2 300.87,78.35 301.25,77.97 301.25,72.78 JHDMI1.13
HDMI_HPLUG: length 76.6
  TOP w0.102: UM1.G1 267.69,32.49 267.32,32.87 267.32,33.42 v2(267.29,33.44) ; v2(259.18,31.24) 259.18,31.14 v1(259.53,30.79) 259.53,30.06 260.33,29.25 RM27.1
  IN2 w0.127: v2(259.18,31.24) 260.44,32.5 266,32.5 266.94,33.44 v2(267.29,33.44) 267.73,33.01 268.28,33.01 269.12,33.85 269.12,34.79 273.09,38.75 275.27,38.75 275.88,39.36 278.88,39.36 279.84,40.33 287.06,40.33 288.1,41.37 289.32,41.37 290.1,42.15 290.1,46.78 290.94,47.62 290.94,56.63 v2(289.85,57.72)
  IN3 w0.127: v2(297.07,62.22) 297.07,65.07 301.17,69.17 JHDMI1.19
  BOTTOM w0.102: v2(289.85,57.72) 291.12,58.99 294.67,58.99 296.38,60.7 RV561.1 CV599.2 v2(297.07,62.22)
HDMI_ID: length 6.6
  TOP w0.102: UM1.D8 265.29,38.09 263.84,39.55 263.84,40.02 263.57,40.29 263.57,40.76 263.13,41.2 v1(263.13,41.47) 263.13,42.01 RM23.2 RM24.1
HDMI_RESERVED: length 4.3
  BOTTOM w0.102: CV600.2 v1(297.7,71.62) 300.61,71.62 JHDMI1.14
HOST_DEBUG_TX: length 80.3
  TOP w0.102: v2(237.73,24.45) 237.42,24.14 UE1.81 ; RN5.1 194.14,28.69 RN3.1 195.51,28.18 195.82,28.18 196.28,27.73 196.28,25.11 v3(196.71,24.68) 197.85,23.54 197.85,23.27 v2(197.86,23.26)
  IN1 w0.114: v2(197.86,23.26) 198.93,24.33 212.5,24.33 212.57,24.4 219.41,24.4 221,22.81 230.45,22.81 230.85,22.42 231.86,22.42 232.95,23.51 235.72,23.51 236.51,24.31 237.58,24.31 v2(237.73,24.45)
  IN2 w0.127: v2(237.73,24.45) 237.77,24.41 239.93,24.41 240.19,24.68 240.19,26.15 240.79,26.75 240.79,27.27 242.44,28.93 248.03,28.93 250.44,31.35 256.42,31.35 v2(256.53,31.23)
  BOTTOM w0.102: v2(256.53,31.23) 256.53,31.26 256.3,31.49 256.3,32.12 256.09,32.32 RE64.2 254.56,33.56 253.29,33.56 252.72,34.13 JDEG1.8
I2C0_SCK: length 7.5
  TOP w0.102: RH14.2 155.28,26.03 157.11,26.03 157.46,26.38 158.53,26.38 158.94,26.79 160.41,26.79 160.83,26.37 v2(160.83,26.22)
  BOTTOM w0.089: v2(160.83,26.22) 160.6,26.44 UH2.AR38
I2C0_SDA: length 5.8
  TOP w0.102: v2(159.01,26.28) 158.89,26.15 157.56,26.15 157.2,25.8 v4(155.97,25.8) 155.37,25.8 155.2,25.63 155.2,25.09 154.77,24.65 RH15.2
  BOTTOM w0.102: UH2.AT42 158.58,26.46 158.76,26.28 v2(159.01,26.28)
I2C1_SCK_TP: length 23.7
  TOP w0.102: v2(159.6,27.3) 159.29,26.99 158.68,26.99 158.33,26.63 157.92,26.63 157.77,26.79 154.9,26.79 RH119.2 154.56,26.45 154.54,26.45 154.16,26.08 152.11,26.08 151.35,25.32 149.61,25.32 147.81,23.52 147.81,18 148.75,17.06 149.42,17.06 149.62,17.26 v2(149.62,17.65)
  BOTTOM w0.089: v2(159.6,27.3) 159.6,27 159.34,26.73 UH2.AR41
  BOTTOM w0.102: QE19.4 v2(149.62,17.65)
I2C1_SCK_TP_C: length 31.4
  BOTTOM w0.102: RE9.1 CT79.1 149.86,18.72 QE19.3 148.27,17.13 148.27,14.9 148.09,14.72 148.09,12.38 147.13,11.42 145.58,11.42 145.33,11.17 DE4.3 145.33,9.69 v2(145.65,9.36) 146.18,8.84 146.18,8.44 145.95,8.21 138.6,8.21 134.85,11.95 134.85,13.97 134.69,14.14 134.4,14.42 134.4,14.57 134.76,14.93 JTP.6
I2C1_SDA_TP: length 22.1
  TOP w0.102: v2(155.66,27.19) 155.56,27.3 153.01,27.3 v4(152.43,26.72) 151.26,25.55 149.51,25.55 147.58,23.62 147.58,17.9 148.65,16.84 149.41,16.84 149.62,16.63 v2(149.62,16.35)
  BOTTOM w0.076: v2(155.66,27.19) 156.04,26.81 156.91,26.81 156.94,26.79 157.39,26.79 157.63,27.03 UH2.AR44
  BOTTOM w0.102: RH120.2 155.58,27.12 v2(155.66,27.19) ; QE19.1 v2(149.62,16.35)
I2C1_SDA_TP_C: length 28.6
  BOTTOM w0.102: QE19.6 150.7,16.33 CE80.1 RE7.1 148.75,15.05 148.32,14.63 148.32,12.29 147.23,11.19 DE4.1 147.23,9.49 v2(147.11,9.37) 146.41,8.67 146.41,8.35 146.04,7.98 138.5,7.98 134.62,11.86 134.62,13.88 134.18,14.33 134.18,14.52 133.76,14.93 JTP.7
I2CB_SCL: length 10.5
  TOP w0.102: RV512.1 164.62,75.99 164.92,75.99 165,76.06 167.7,76.06 168.11,76.47 168.11,76.88 v4(168.69,77.46) 169.02,77.8 169.02,79.65 169.67,80.3 169.67,80.99 v2(170.05,81.37)
  BOTTOM w0.102: UV1.R7 170.42,81.01 v2(170.05,81.37)
I2CB_SDA: length 10
  TOP w0.102: v2(170.08,80.58) 170.08,80.38 169.25,79.55 169.25,77.7 168.34,76.79 168.34,76.37 167.8,75.83 v4(166.25,75.83) 165.09,75.83 165.02,75.76 164.62,75.76 RV513.1
  BOTTOM w0.102: v2(170.08,80.58) 170.08,80.57 UV1.R6
I_ADP: length 306.8
  TOP w0.102: v2(28.78,42.92) 29.74,41.95 34.95,41.95 v2(35.9,42.9)
  IN1 w0.114: v2(35.9,42.9) 35.9,42.97 34.19,41.25 19.21,41.25 14.75,36.79 14.4,36.79 10.53,36.79 9.73,35.99 9.73,31.03 9.73,31.02 9.73,30.48 9.73,30.47 9.73,23.86 13.32,20.27 13.32,20.07 13.32,19.61 16.38,16.55 20.56,16.55 28.99,8.12 81.38,8.12 88.04,14.78 103.12,14.78 103.77,15.43 110.34,15.43 111.24,14.53 116.92,14.53 118.07,15.68 123.14,15.68 127.78,11.04 156.98,11.04 159.46,13.52 167.45,13.52 170.11,10.86 171.13,10.86 171.56,10.43 171.56,8.96 172.26,8.26 178.64,8.26 179.77,9.39 181.4,9.39 182.13,9.39 184.69,11.95 186.11,11.95 186.71,12.56 187.47,12.56 188.13,11.9 195.55,11.9 197.46,13.81 199.16,13.81 200.99,15.65 204.45,15.65 205,15.1 211.04,15.1 211.87,14.26 215.15,14.26 216.48,15.59 216.66,15.78 216.86,15.78 219.32,15.78 219.93,15.17 221.19,15.17 222.29,16.26 227.55,16.26 228.52,17.24 229.24,17.24 229.9,17.89 230.74,17.89 231.24,18.39 231.24,19.23 229.75,20.72 v2(228.94,20.72)
  BOTTOM w0.102: PR200.1 35.73,42.9 v2(35.9,42.9) ; PR319.1 28.78,42.32 v2(28.78,42.92) ; v2(228.94,20.72) 228.94,20.77 230.16,21.99 230.16,24.13 RE36.2
I_ADP_R: length 7.8
  TOP w0.102: v2(231.45,29.28) 229.8,29.28 229.02,30.06 229.02,30.7 229.05,30.73 UE1.110
  BOTTOM w0.102: CE87.1 231.68,27.5 ; 231.68,27.5 RE36.1 ; 231.68,27.5 232.34,28.15 232.34,28.37 v1(232.1,28.6) 231.74,28.96 231.74,28.99 v2(231.45,29.28)
ICSP_CLK: length 22.4
  TOP w0.102: UE1.101 232.65,30.4 v2(232.62,30.37)
  IN2 w0.127: v2(232.62,30.37) 232.62,30.39 233.54,31.31 245.88,31.31 247.25,32.68 v2(247.25,33.62)
  BOTTOM w0.102: v2(247.25,33.62) 247.61,33.62 249.82,31.41 RE109.2 ; v1(232.83,30.98) 232.62,30.77 v2(232.62,30.37)
ICSP_CLR: length 25.8
  TOP w0.102: UE1.87 235,26.54 234.73,26.81 234.73,28.41 233.94,29.19 233.94,29.35 233.79,29.5 v2(233.79,30.37)
  IN2 w0.127: v2(233.79,30.37) 233.77,30.39 233.77,30.6 234.22,31.05 248.16,31.05 v2(250.25,33.15)
  BOTTOM w0.102: v1(234.1,29.86) 234.1,30.06 v2(233.79,30.37) ; v2(250.25,33.15) 250.25,32.96 250.58,32.63 250.58,31.74 250.91,31.41 RE110.2
ICSP_DAT: length 28.5
  TOP w0.102: v2(231.99,30.37) 232.01,30.37 232.25,30.61 UE1.102
  IN2 w0.127: v2(231.99,30.37) 231.99,30.42 233.13,31.56 244.47,31.56 246.98,34.08 250.72,34.08 v2(251.75,33.05)
  BOTTOM w0.102: RE112.2 252.94,31.41 252.61,31.74 252.61,32.62 252.45,32.78 252.02,32.78 v2(251.75,33.05) ; v1(233.93,31.71) 233.01,31.71 231.99,30.69 v2(231.99,30.37)
ILIM_HI1: length 4.2
  TOP w0.102: v1(279.18,39.44) 279.51,39.44 279.59,39.51 280.58,39.51 281.01,39.08 RI45.1 281.94,38.13 US1.16
ILIM_LO1: length 3.8
  TOP w0.102: US1.15 282.36,37.38 v1(282.36,38.55) 282.36,39.46 281.82,40 RI49.1
ILIM_SEL_R: length 3.5
  TOP w0.102: US1.4 280.35,35 280.16,34.81 v1(279.99,34.81) 279.94,34.81 279.84,34.71 279.36,34.71 279.13,34.94 279.13,35.7 278.93,35.91 RI30.2
ILMT_1VALWP: length 4.8
  BOTTOM w0.102: v1(251.09,10.56) 251.09,12 PR606.2
  BOTTOM w0.254: PR606.2 PR607.1 250.58,12.56 250.58,13.25 250.45,13.38 PU600.13
ILMT_+0.95VSP: length 5.2
  TOP w0.102: v1(65.31,61.92) 65.73,61.92 65.9,62.08 65.9,62.88 PR707.2
  TOP w0.254: PR707.2 PR709.1 67.5,65.37 PU700.13
ILMT_+1.05VSP: length 3.9
  BOTTOM w0.102: v1(225.21,41.01) 225.03,41.01 PR809.2
  BOTTOM w0.254: PR809.2 PR810.1 223.16,40.62 PU800.13
ILMT_DDR: length 4.9
  BOTTOM w0.254: PR506.1 PR504.2 97.77,8.88 98,9.11 v1(99.02,9.11) 99.65,9.11 100.25,9.7 PU500.17
IMVP_VR_ON: length 64.7
  TOP w0.102: 188.85,21.69 189.14,21.4 v3(189.14,20.89) 189.14,18.07 188.25,17.19 v2(187.16,17.19) ; 188.85,21.69 189.01,21.85 RH499.2 ; 188.85,21.69 UZ21.1 ; v2(233.64,21.1) 233.85,20.88 234.84,20.88 234.89,20.94 UE1.73
  IN3 w0.127: v2(187.16,17.19) 187.16,17.39 188.27,18.51 197.52,18.51 200.08,21.06 206.87,21.06 207.89,22.09 212.25,22.09 212.63,21.71 213.15,21.71 214.92,19.94 215.79,19.94 216.77,18.96 220.17,18.96 221.11,18.02 222.56,18.02 223.4,18.86 228.1,18.86 228.71,19.47 231.4,19.47 231.76,19.83 232.37,19.83 v2(233.64,21.1)
  BOTTOM w0.102: RE23.1 CE82.1 233.49,20.95 v2(233.64,21.1)
IMVP_VR_PG: length 202.2
  TOP w0.102: v2(67.09,82.41) 67.09,82.77 67.42,83.1 PR1117.1 ; v2(193,36.69) 189.77,33.47 v1(189.77,31.11) 189.77,28.5 RH102.1 189.75,27.42 189.37,27.42 189.16,27.22 189.16,25.9 189.41,25.65 UH14.1
  IN2 w0.127: v2(141.82,99.58) 140.07,99.58 132.07,107.58 87.94,107.58 77.84,97.48 77.84,95.67 78.97,94.54 78.97,93.49 76.16,90.68 76.16,87.51 73.15,84.5 69.18,84.5 v2(67.09,82.41)
  IN3 w0.127: v2(193,36.69) 192.95,36.64 192.36,36.64 192.12,36.89 192.12,37.24 192.47,37.59 192.47,46.98 186.06,53.38 186.06,56.91 184.19,58.79 184.19,59.38 183.17,60.39 181.03,60.39 174.15,67.27 174.15,69.43 173.19,70.39 173.19,72.2 172.08,73.31 171.47,73.31 167.93,76.85 159.9,76.85 159.24,77.51 156.93,77.51 155.94,78.49 155.94,81.19 153.43,83.7 153.43,88.97 142.81,99.58 v2(141.82,99.58)
INTRUDER#: length 3.8
  TOP w0.254: RH143.1 176.16,19.68 175.65,20.18 175.54,20.18 175.46,20.26 175.33,20.26 174.54,21.04 174.54,21.11 v1(174.25,21.4) v2(173.72,21.4)
  BOTTOM w0.254: v2(173.72,21.4) 173.75,21.43 173.75,21.96 UH2.BE11
INV_PWM: length 5.8
  TOP w0.102: v2(61.73,31.23) 61.99,30.98 RV537.1 62.87,30.98 63.38,30.47 v1(64.91,30.47) 65.4,30.97 DV2.1
  BOTTOM w0.102: JEDP1.16 62.01,31.51 v2(61.73,31.23)
IR_CAM_DET#: length 110.4
  TOP w0.102: v2(149.13,30.37) 149.36,30.6 v3(149.36,31.11)
  IN2 w0.127: v2(232.41,41.86) 232.41,41.31 230.79,39.69 220.45,39.69 220.19,39.42 218.55,39.42 217.36,38.23 217.36,36.12 217.1,35.87 209.01,35.87 206.84,38.04 202.14,38.04 200.9,39.28 188.43,39.28 186.47,37.33 186.47,35.21 185,33.74 v2(185,33.06)
  IN3 w0.127: v2(149.13,30.37) 150.1,31.33 154.72,31.33 155.38,31.99 157.36,31.99 157.79,32.43 164.18,32.43 164.64,31.97 171.59,31.97 171.74,32.12 175.24,32.12 175.99,31.37 176.86,31.37 177.99,32.5 179.79,32.5 181.16,33.87 184.3,33.87 185.02,33.15 185.02,33.09 v2(185,33.06)
  BOTTOM w0.102: v2(149.13,30.37) 149.86,30.37 150.75,29.48 155.79,29.48 156.47,28.79 157.21,28.79 157.36,28.64 UH2.AL44 ; v2(232.41,41.86) 232.82,41.86 233.02,42.06 JCAM1.9 233.02,43.94 232.83,44.14 232.83,45.41 RZ96.1
IRQ_SERIRQ: length 72.8
  TOP w0.102: RH111.1 181.04,23.99 181.37,23.66 v2(181.42,23.66) ; v2(228.48,24.01) 228.43,23.95 228.43,18.67 229.08,18.02 229.98,18.02 230.65,17.36 UE1.55
  IN1 w0.114: v2(228.48,24.01) 227.38,24.01 226.65,24.74 224.38,24.74 224.12,24.48 221.11,24.48 220.2,25.39 213.17,25.39 212.55,26.01 211.39,26.01 210.84,25.46 210.44,25.46 202.68,25.46 202.12,26.03 198.99,26.03 197.57,24.6 193.13,24.6 192.2,23.68 187.41,23.68 186.8,24.29 184.14,24.29 183.52,23.66 v2(181.42,23.66)
  IN2 w0.127: v2(181.42,23.66) 180.48,22.72 179.35,22.72 178.97,23.1 177.15,23.1 176.64,22.6 175.96,22.6 175.5,23.05 173.31,23.05 172.49,23.88 171.49,23.88 v2(171.46,23.91)
  BOTTOM w0.089: UH2.BA17 171.42,23.86 v2(171.46,23.91)
  BOTTOM w0.102: v2(228.48,24.01) 228.48,24.45 v1(228.66,24.63)
ISEN1_GT: length 18.9
  TOP w0.254: v2(64.32,100.42) 63.59,101.16 v3(63.59,101.46) 63.59,103.47 64.5,104.38 PR1526.2
  IN3 w0.254: v2(67.24,91.1) 67.24,91.33 64.32,94.25 v2(64.32,100.42)
  BOTTOM w0.203: PU1100.9 68.04,90.57 67.51,91.1 v2(67.24,91.1)
  BOTTOM w0.254: PR1510.2 63.94,100.8 v2(64.32,100.42) ; PC1129.2 66.99,91.43 67.24,91.18 v2(67.24,91.1)
ISEN1_VCORE: length 22.6
  TOP w0.254: v2(72.65,94.1) 72.78,94.22 v1(72.78,99.18) 72.78,100.7 72.27,101.21 v2(71.64,101.21)
  IN1 w0.254: v2(71.64,101.21) 72.32,100.52 75.55,100.52 75.88,100.19 76.84,100.19 v2(77.1,100.45)
  BOTTOM w0.203: PU1100.21 72.74,94.01 v2(72.65,94.1)
  BOTTOM w0.254: PC1128.1 73.03,94.35 72.78,94.1 v2(72.65,94.1) ; v2(71.64,101.21) 72.32,101.21 PR1426.2 71.89,100.52 71.89,99.69 71.64,99.43 70.62,99.43 70.04,100.02 PR1440.2 ; PR1409.2 78.24,101.21 v2(77.1,100.45)
ISEN2_GT: length 19.6
  TOP w0.254: PR1525.2 64.96,102.99 66.16,101.78 v2(66.56,101.78)
  BOTTOM w0.203: PC1126.2 66.63,92.29 67.05,91.88 67.18,91.88 68.09,90.97 PU1100.10
  BOTTOM w0.254: PC1126.2 66.63,92.62 65.29,93.97 65.29,100.14 66.33,101.18 66.33,101.55 v2(66.56,101.78) 66.56,101.84 67.52,102.81 PR1522.2
ISEN2_VCORE: length 21.7
  TOP w0.254: v2(73.54,94.1) 73.42,94.22 v1(73.42,95.75) 73.42,100.45 v2(74.05,101.08)
  IN1 w0.254: v2(76.34,100.7) 75.96,101.08 v2(74.05,101.08) 73.03,101.08 72.15,101.97 70.62,101.97 69.42,100.76 v2(69.42,100.51)
  BOTTOM w0.203: PU1100.22 73.14,93.51
  BOTTOM w0.254: PR1441.2 69.99,101.08 v2(69.42,100.51) ; 76.34,101.08 PR1412.2 ; 76.34,101.08 v2(76.34,100.7) ; 76.34,101.08 76.84,101.08 77.23,101.46 PR1423.2 ; PC1127.1 73.92,94.48 v2(73.54,94.1) 73.14,93.7 73.14,93.51
ISEN3_VCORE: length 17.4
  TOP w0.254: v2(74.05,104.26) 74.05,103.88 74.56,103.37 74.56,100.45 v2(74.05,99.94) v1(74.05,97.6) 74.05,94.1 v2(74.18,93.97)
  BOTTOM w0.203: PU1100.23 73.54,93.33 v2(74.18,93.97)
  BOTTOM w0.254: PR1427.2 72.45,99.69 72.7,99.43 73.72,99.43 74.05,99.76 v2(74.05,99.94) 74.18,100.07 PR1413.2 ; v2(74.18,93.97) 74.81,94.61 PC1125.1 ; v2(74.05,104.26) 73.92,104.38 PR1437.2
ISOLATEB: length 7.9
  BOTTOM w0.102: RL30.1 286.06,38.22 286.06,38.9 286.6,39.44 286.6,39.97 286.9,40.27 286.9,41.52 286.21,42.21 UL1.20 ; RL30.1 285.23,38.17 RL1.2 ; RL30.1 RL33.2 v1(287.97,38.17)
ISUMN_GT: length 68.5
  TOP w0.254: PR1136.1 PR1132.1 65.68,90.54 v2(65.06,90.54)
  BOTTOM w0.254: PC1126.1 PC1124.1 ; PC1124.1 PR1131.2 ; PC1124.1 64.35,92.95 v1(63.7,93.6) 63,94.3 63,104.38 ; PR1131.2 PC1129.1 ; PR1131.2 PC1117.2 v2(65.06,90.54) PC1118.2 ; PH1102.2 87.77,121.53 87.2,122.1 83.47,122.1 81.12,124.45 64.32,124.45 63,123.14 63,104.38 ; 63,104.38 PR1523.2 PR1511.2
ISUMN_SA: length 80.5
  TOP w0.254: v2(129.04,116.83) v1(129.8,116.07) PR1529.2
  IN1 w0.254: v2(79.44,88.76) 79.44,88.74 79.69,88.48 79.69,88.19 80.11,87.77 80.89,87.77 81.29,88.17 81.29,89.2 81.06,89.43 81.06,90.9 82.89,92.73 82.89,96.59 89.75,103.44 104.48,103.44 106.08,105.04 109.87,105.04 110.51,105.68 119.42,105.68 120.15,106.42 125.01,106.42 128.41,109.81 128.41,116.55 128.69,116.83 v2(129.04,116.83)
  BOTTOM w0.254: PC1112.1 v2(79.44,88.76) ; PC1112.1 PC1113.1 PR1126.1 PC1111.1 ; PC1112.1 78.48,88.13 PR1124.2 78.36,88 PR1121.2 ; v2(129.04,116.83) 129.29,116.83 129.37,116.75 129.42,116.75 129.45,116.73 129.8,116.73 130.34,117.26 PH1101.1
ISUMN_VCORE: length 84.8
  IN1 w0.254: v2(74.05,101.97) 74.18,102.1 75.7,102.1 76.72,101.08 77.86,101.08 78.85,100.09 82.08,100.09 88.48,106.49 109.87,106.49 110.02,106.64 118.61,106.64 119.99,108.02 119.99,111.92 v2(119.64,112.26)
  BOTTOM w0.254: 72.48,103.56 71.19,103.56 70.04,102.4 PR1439.2 68.91,100.97 68.91,99.37 69.35,98.92 v1(71.79,98.92) 75.19,98.92 75.57,98.54 ; 72.48,103.56 72.45,103.53 PR1425.2 ; 72.48,103.56 74.42,103.56 74.74,103.24 PR1411.2 74.18,102.1 v2(74.05,101.97) ; 75.57,98.54 PC1130.1 ; 75.57,98.54 75.57,96.69 ; 75.57,96.69 PR1139.2 ; 75.57,96.69 PR1138.1 PC1132.1 PC1131.1 PC1128.2 PC1127.2 PC1125.2 74.86,95.75 PR1137.2 ; PH1103.1 119.77,112.39 v2(119.64,112.26)
ISUMP_GT: length 71.2
  IN3 w0.254: v2(64.14,105.35) 63.64,104.84 63.64,103.62 v2(64.09,103.16) 63.64,102.71 63.64,90.9 63.03,90.29 v2(63.03,89.75) 63.66,89.12 65.49,89.12 66.76,90.39 v2(67.27,90.39)
  BOTTOM w0.203: PU1100.7 68.09,89.77 68.06,89.73 67.62,89.73 67.27,90.08 v2(67.27,90.39) 67.19,90.39 67.04,90.54 PC1118.1
  BOTTOM w0.254: PR1130.1 86.64,121.59 83.26,121.59 80.91,123.94 64.53,123.94 63.51,122.93 63.51,106.67 63.64,106.54 ; v2(63.03,89.75) 63.18,89.75 63.43,90.01 PC1117.1 PR1131.1 ; v2(64.14,105.35) 63.64,105.86 63.64,106.54 ; 63.64,106.54 PR1521.2 ; v2(64.09,103.16) 63.95,103.03 PR1509.2
ISUMP_SA: length 82.4
  TOP w0.254: PR1528.2 129.78,117.21 129.52,117.47 v2(129.04,117.47)
  IN1 w0.254: v2(80.33,88.78) 80.26,88.78 80.08,88.6 80.08,88.34 80.26,88.15 80.65,88.15 80.91,88.41 80.91,89.04 80.68,89.27 80.68,91.05 82.51,92.88 82.51,96.74 89.62,103.85 104.35,103.85 105.92,105.43 109.71,105.43 110.35,106.06 119.26,106.06 119.99,106.8 124.85,106.8 128.03,109.97 128.03,116.93 128.56,117.47 v2(129.04,117.47)
  BOTTOM w0.203: PU1100.32 75.22,88.97 75.27,89.02 75.91,89.02
  BOTTOM w0.254: 75.91,89.02 76.36,88.56 78.34,88.56 79.03,89.25 79.86,89.25 v2(80.33,88.78) 80.35,88.76 PC1112.2 PC1113.2 PR1126.2 ; PR1125.2 128.25,117.72 128.51,117.47 v2(129.04,117.47)
ISUMP_VCORE: length 85.5
  TOP w0.254: v2(72.27,96.89) 72.27,98.29 70.75,99.81 70.75,102.86 71.64,103.75 72.27,103.75 v3(73.37,104.84) 74.7,106.18 v2(76.34,106.18) 76.58,106.18 78.88,103.88 78.88,102.07 v2(79.99,100.96)
  IN1 w0.254: v2(119.26,112.89) 119.26,112.77 119.14,112.64 119.14,112 119.52,111.62 119.52,108.09 118.45,107.03 109.86,107.03 109.71,106.87 88.33,106.87 82.28,100.83 80.12,100.83 v2(79.99,100.96)
  BOTTOM w0.203: 72.02,94.33 71.84,94.15 71.84,93.36 71.94,93.26 PU1100.19
  BOTTOM w0.254: PR1424.2 75.51,104.38 PR1438.2 ; v2(119.26,112.89) 118.88,113.27 PR1140.2 ; PR1438.2 76.02,105.53 77.48,105.53 78.83,104.18 78.83,102.87 PR1410.2 ; PR1438.2 76.2,106.04 v2(76.34,106.18) ; 72.02,94.33 72.5,94.81 72.5,96.66 v2(72.27,96.89) 72.27,97.35 72.53,97.6 PC1131.2 PC1132.2 PR1138.2
JACK_PLUG: length 19.5
  TOP w0.102: v2(295.79,10.72) v1(295.09,10.72)
  IN1 w0.254: JHP1.6 305.04,8.12 299.29,8.12 296.68,10.72 v2(295.79,10.72)
  BOTTOM w0.254: v2(295.79,10.72) 295.79,11.42 295.03,12.18 295.03,12.69 293.63,14.09 293.2,14.09 DA5.2 291.6,15.69 RA56.1
JTAG_CLK: length 2.9
  BOTTOM w0.102: RE111.1 251.85,32.58 251.62,32.58 251.44,32.76 251.27,32.76 250.99,33.04 v1(250.99,33.35) 250.99,33.4 250.72,33.67 JDEG1.4
JTAG_TDI: length 3.7
  BOTTOM w0.102: JDEG1.2 249.72,33.03 250.07,32.68 RE109.1 249.56,32.32 v3(248.9,32.98)
JTAG_TDO: length 3.1
  BOTTOM w0.102: RE112.1 253.12,32.51 252.62,33.01 252.46,33.01 v1(252.28,33.19) 252.27,33.19 251.96,33.51 251.66,33.51 251.22,33.95 JDEG1.5
JTAG_TMS: length 4.9
  BOTTOM w0.102: JDEG1.3 250.22,33.76 250.66,33.32 250.66,32.93 251.09,32.5 RE110.1 251.24,32.32 251.6,31.97 251.6,31.12 v1(250.92,30.44)
KB_BL_DET: length 56.1
  TOP w0.102: v2(119.66,14.69) 119.66,14.79 119.8,14.93 119.8,15.71 RE3.1 RE4.2
  IN2 w0.127: v2(149.91,28.42) 150.79,29.3 151.32,29.3 152.46,30.44 152.46,30.78 155.38,33.7 155.38,35.44 156.25,36.31 156.5,36.31 v2(156.55,36.36)
  BOTTOM w0.102: v2(156.55,36.36) 156.78,36.12 UH2.T45 ; v2(149.91,28.42) 148.53,28.42 148.1,27.99 141.7,27.99 141.21,27.5 141.21,25.59 142.45,24.35 142.45,22.22 140.93,20.69 139.41,20.69 135.98,17.26 128.61,17.26 125.31,13.96 120.14,13.96 119.66,14.44 v2(119.66,14.69)
KB_DET#: length 49.7
  TOP w0.102: v2(183.12,20.92) 183.6,21.4 v3(183.6,23.74) 184.19,24.32 184.19,26.48 184.52,26.81 184.52,27.42 184.92,27.83 185.84,27.83 187.69,29.68 187.69,31.28 189.24,32.83 189.24,34.38 192.39,37.53 193.05,37.53 196.41,34.18 196.78,34.18 196.92,34.04 JKB1.30
  IN2 w0.127: v2(183.12,20.92) 183.12,21.25 182.76,21.61 181.09,21.61 180.63,21.15 180.63,20.03 180.38,19.78 179.81,19.78 179.49,19.46 174.58,19.46 174.11,19.93 173.28,19.93 173.06,20.14 172.74,20.14 172.37,20.51 172.37,20.72 172.15,20.95 172.15,21.25 171.88,21.51 170.72,21.51 170.07,22.17 169.71,22.17 169.35,21.81 v2(169.35,21.53)
  BOTTOM w0.076: UH2.BD22 169,22.02 169,21.87 169.33,21.53 v2(169.35,21.53)
  BOTTOM w0.102: RH128.1 169.86,19.57 169.48,19.57 169.12,19.93 169.12,21.3 v2(169.35,21.53)
KB_LED_PWM: length 125.6
  TOP w0.102: v2(225.61,14.77) 225.73,14.77 226.25,15.3 UE1.44 ; QE5.2 116.48,16.06 115.95,15.52 v2(115.94,15.52) v1(115.58,15.17)
  IN2 w0.127: v2(225.61,14.77) 223.33,17.06 216.19,17.06 214.91,15.78 210.3,15.78 208.86,17.21 199.16,17.21 198.21,16.26 193.22,16.26 192.71,15.75 189.92,15.75 188.23,14.06 187.31,14.06 183.27,10.02 182.25,10.02 180.32,8.09 171.97,8.09 167.12,12.94 166.66,12.94 160.56,12.94 158.76,11.14 154.72,11.14 150.89,14.98 148.49,14.98 145.76,17.71 143.58,17.71 142.97,17.1 117.8,17.1 116.73,16.02 116.44,16.02 v2(115.94,15.52)
KB_LED_PWM#: length 5.4
  TOP w0.102: QE5.1 119.1,15.38 119.1,14.7 v2(119.07,14.68) 118.08,13.68 v3(116.21,13.68)
  BOTTOM w0.102: JBL1.4 118.59,15.34 119.07,14.86 v2(119.07,14.68)
KSI0: length 46.5
  TOP w0.102: v2(207.1,42.79) v3(206.55,42.24) 204.05,39.74 197.78,39.74 197.41,40.11 JKB1.22 ; UE1.98 233.85,32.82 234.12,33.09 v2(234.12,33.16) 234.12,33.39 234.69,33.96 RPE2.4
  IN3 w0.127: v2(207.1,42.79) 207.15,42.74 207.15,42.34 210.72,38.78 215.96,38.78 219.31,35.42 232.3,35.42 234.12,33.6 v2(234.12,33.16)
KSI1: length 44
  TOP w0.102: UE1.99 233.45,33.08 v2(233.54,33.16) 233.54,33.37 234.19,34.02 RPE2.3 ; JKB1.24 199.75,38.51 200.76,37.51 202.12,37.51 202.57,37.96 205.84,37.96 v3(206.49,38.6) 206.87,38.6 206.96,38.51 211.45,38.51 211.88,38.08 v2(211.88,38.05)
  IN3 w0.127: v2(211.88,38.05) 211.88,38.15 212.25,38.52 215.86,38.52 219.21,35.17 232.19,35.17 233.54,33.82 v2(233.54,33.16)
KSI2: length 48.5
  TOP w0.102: JKB1.26 197.58,36.91 197.7,37.02 197.7,37.38 198.12,37.81 199.81,37.81 200.59,37.02 202.75,37.02 v2(203.02,37.29) ; RPE2.2 233.69,34.36 233.05,33.72 v2(233.05,33.65) ; v3(217.81,28.23) 217.81,28.57 218.18,28.93 218.51,28.93 v2(218.93,28.51) 219.3,28.14 UE1.6
  IN2 w0.127: v2(218.93,28.51) 220.17,28.51 221.11,29.45 227.09,29.45 228.71,31.07 231.44,31.07 233.11,32.73 233.11,33.52 233.05,33.57 v2(233.05,33.65)
  IN3 w0.127: v2(203.02,37.29) 203.01,37.28 203.36,37.28 208.95,31.69 215.86,31.69 217.28,30.27 217.28,30.06 218.28,29.06 218.67,29.06 218.93,28.79 v2(218.93,28.51)
KSI3: length 46.2
  TOP w0.102: v2(200.97,37.91) 199.58,39.31 v3(198.69,39.31) JKB1.23 ; UE1.7 219.12,27.74 v2(218.35,28.51) ; RPE2.1 233.19,34.55 232.47,33.82 v2(232.47,33.65)
  IN2 w0.127: v2(218.35,28.51) 218.35,28.59 218.93,29.17 220.47,29.17 221.01,29.71 226.98,29.71 228.6,31.32 230.66,31.32 231.96,32.63 231.96,33.14 v2(232.47,33.65)
  IN3 w0.127: v2(218.35,28.51) 218.32,28.51 217.17,29.66 216.62,29.66 214.84,31.44 208.8,31.44 203.46,36.77 202.57,36.77 201.43,37.91 v2(200.97,37.91)
KSI4: length 40.7
  TOP w0.102: JKB1.27 197.37,36.11 197.83,36.57 207.53,36.57 208.77,37.81 v3(209.97,37.81) 210.36,37.81 210.53,37.64 211.09,37.64 211.29,37.84 v2(211.29,38.09) ; UE1.104 231.45,32.98 v2(231.51,33.04)
  IN3 w0.127: v2(231.51,33.04) 231.51,33.14 231.63,33.26 231.63,33.9 230.72,34.81 229.35,34.81 229.25,34.92 219.05,34.92 218.14,35.83 217.93,35.83 217.93,35.83 213.42,35.83 211.34,37.91 211.34,38 211.29,38.05 v2(211.29,38.09)
  BOTTOM w0.102: RPE3.4 231.26,32.69 231.51,32.93 v2(231.51,33.04)
KSI5: length 39.3
  TOP w0.102: UE1.105 231.05,32.91 230.95,33.01 230.95,33.01 v2(230.92,33.04) ; JKB1.25 197.44,37.71 197.77,38.04 199.9,38.04 200.66,37.28 202.21,37.28 202.66,37.73 v3(208.01,37.73) 208.53,38.25 210.1,38.25 210.3,38.05 v2(210.7,38.05)
  IN3 w0.127: v2(210.7,38.05) 211.64,37.11 211.64,36.89 212.96,35.58 218.03,35.58 218.95,34.66 229.14,34.66 230.77,33.04 v2(230.92,33.04)
  BOTTOM w0.102: RPE3.3 230.76,32.91 230.89,33.04 v2(230.92,33.04)
KSI6: length 39.7
  TOP w0.102: JKB1.28 197.38,35.31 198.41,36.34 207.88,36.34 209.03,37.48 209.76,37.48 209.83,37.41 210.79,37.41 211.02,37.18 v2(211.02,37) ; v3(229.41,33.59) 229.42,33.59 229.49,33.52 229.6,33.52 v2(230.08,33.04) 230.25,32.87 UE1.107
  IN3 w0.127: v2(230.08,33.04) 230.08,33.11 228.79,34.41 218.84,34.41 218.24,35.01 212.05,35.01 211.06,36 211.06,36.96 v2(211.02,37)
  BOTTOM w0.102: v2(230.08,33.04) 230.26,32.85 RPE3.2
KSI7: length 37.8
  TOP w0.102: v2(229.5,33.04) 229.5,33.01 229.85,32.66 UE1.108 ; v2(209.78,36.96) 209.32,36.96 208.66,36.3 208.66,36.28 208.24,35.85 v3(206.99,35.85) 206.61,35.85 206.46,36.01 198.56,36.01 197.06,34.51 JKB1.29
  IN3 w0.127: v2(229.5,33.04) 228.38,34.15 218.74,34.15 218.14,34.75 211.94,34.75 210.28,36.41 210.02,36.41 209.78,36.66 v2(209.78,36.96)
  BOTTOM w0.102: RPE3.1 229.77,32.72 229.5,32.98 v2(229.5,33.04)
KSO0: length 53.2
  TOP w0.102: RPE4.8 217.66,25.47 v2(218.57,26.38) ; v2(195.64,47.84) 195.87,47.62 195.87,47.59 196.15,47.31 JKB1.13 199.99,47.31 v3(200.38,46.92) ; v2(220.95,30.6) 221.37,30.18 221.37,29.96 221.15,29.74 UE1.2
  IN2 w0.127: v2(218.57,26.38) 218.57,27.03 217.66,27.94 217.66,29.38 218.4,30.11 220.66,30.11 220.95,30.41 v2(220.95,30.6)
  IN3 w0.127: v2(220.95,30.6) 220.95,30.79 220.3,31.44 218.95,31.44 217.17,33.21 210.35,33.21 207.91,35.65 207.91,38.51 204.19,42.23 200.37,42.23 200.16,42.43 200.16,42.99 199.7,43.45 198.86,43.45 198.49,43.82 198.49,44.71 199.08,45.31 199.08,46.18 197.95,47.31 196.15,47.31 195.87,47.59 195.87,47.62 v2(195.64,47.84)
KSO1: length 45.9
  TOP w0.102: JKB1.15 197.65,45.71 v2(197.72,45.63) ; v2(222.72,28.13) 222.72,25.31 222.35,24.94 UE1.14 218.88,24.94 218.86,24.97 v3(218.45,24.97) RPE4.7
  IN3 w0.127: v2(222.72,28.13) 222.72,28.26 222.36,28.62 222.36,28.82 221.96,29.23 220.06,29.23 218.9,30.39 218.55,30.39 216.75,32.2 209.93,32.2 206.89,35.23 206.89,38.09 203.77,41.21 198.89,41.21 197.32,42.79 197.32,45.23 v2(197.72,45.63)
KSO2: length 48.2
  TOP w0.102: v3(198.46,46.24) 198.46,46.29 198.31,46.45 197.75,46.45 v2(197.72,46.47) 197.69,46.51 JKB1.14 ; RPE4.6 218.92,24.47 219,24.54 UE1.15 221.02,24.54 221.14,24.67 222.48,24.67 222.97,25.16 222.97,27.78 v2(223.33,28.13)
  IN3 w0.127: v2(223.33,28.13) 223.33,28.23 222.08,29.48 220.17,29.48 219,30.65 218.66,30.65 216.86,32.45 210.03,32.45 207.15,35.34 207.15,38.2 203.87,41.47 199.58,41.47 197.72,43.32 197.72,45 198.16,45.43 198.16,46.04 v2(197.72,46.47)
KSO3: length 51.8
  TOP w0.102: RPE4.5 219.01,23.97 219.18,24.14 UE1.16 221.06,24.14 221.36,24.44 222.58,24.44 223.2,25.06 223.2,27.27 223.91,27.98 223.91,28.12 v2(223.92,28.13) ; v3(202.02,45.86) 199.04,45.86 v2(198.66,45.48) 198.31,45.13 197.86,45.13 197.65,44.91 JKB1.16
  IN3 w0.127: v2(198.66,45.48) 198.57,45.48 198.05,44.97 198.05,43.35 199.68,41.72 203.98,41.72 207.4,38.3 207.4,35.44 210.14,32.71 216.96,32.71 218.76,30.9 219.11,30.9 220.27,29.73 222.34,29.73 223.91,28.16 223.91,28.13 223.9,28.12 223.91,28.12 223.92,28.14 v2(223.92,28.13)
KSO4: length 52.5
  TOP w0.102: RPE5.8 224.1,13.92 223.99,14.04 223.99,14.75 223.73,15.01 223.64,15.01 223.45,15.21 UE1.37 223.45,17.14 223.91,17.59 223.91,22.6 225.13,23.82 225.13,27.8 224.85,28.08 224.8,28.08 v2(224.75,28.13) ; JKB1.20 198.57,41.71 v3(198.89,42.02) v2(199.65,42.79)
  IN3 w0.127: v2(199.65,42.79) 199.65,42.38 200.06,41.98 204.08,41.98 207.65,38.41 207.65,35.55 210.24,32.96 217.07,32.96 218.84,31.18 219.19,31.18 220.38,29.99 222.74,29.99 224.6,28.13 v2(224.75,28.13)
KSO5: length 57.6
  TOP w0.102: v3(227.27,12.15) 226.98,12.44 224.9,12.44 224.6,12.74 RPE5.7 224.6,14.11 224.25,14.46 224.25,14.81 223.85,15.21 UE1.38 223.85,17.09 224.14,17.38 224.14,18.53 225.41,19.8 225.41,26.46 225.74,26.79 225.74,27.96 v2(225.56,28.13) ; v2(200.62,42.79) 199.07,41.24 197.72,41.24 197.39,40.91 JKB1.21
  IN3 w0.127: v2(200.62,42.79) 200.64,42.81 203.97,42.81 205.72,41.06 205.79,40.99 208.16,38.62 208.16,36.14 209.29,35.02 209.88,35.02 211.43,33.47 217.28,33.47 218.98,31.77 223.94,31.77 224.44,31.26 224.44,29.25 v2(225.56,28.13)
KSO6: length 56.4
  TOP w0.102: JKB1.18 197.76,43.31 v3(198.38,43.93) v2(198.97,43.93) ; v2(226.73,28.13) 226.73,27.24 225.64,26.15 225.64,19.7 224.37,18.43 224.37,17.29 224.25,17.17 UE1.39 224.25,15.14 224.56,14.84 224.56,14.57 225.1,14.03 RPE5.6
  IN3 w0.127: v2(226.73,28.13) 226.5,28.36 226.5,31.28 225.77,32.02 219.08,32.02 217.38,33.72 211.54,33.72 209.99,35.27 209.4,35.27 208.42,36.25 208.42,39.08 203.72,43.78 199.12,43.78 v2(198.97,43.93)
KSO7: length 61.8
  TOP w0.102: JKB1.19 198.21,42.51 199.68,43.98 v2(199.68,44.58) ; v2(228.51,28.11) 228.51,27.47 226.7,25.67 226.7,24.9 227.05,24.56 227.05,18.7 228.65,17.09 UE1.50 228.65,14.51 228.25,14.11 227.44,14.11 v3(227.37,14.04) 227.27,14.14 225.92,14.14 225.6,13.82 RPE5.5
  IN3 w0.127: v2(228.51,28.11) 228.51,28.46 227.9,29.07 227.9,30.69 226.01,32.58 219.24,32.58 217.59,34.23 211.75,34.23 210.07,35.91 209.48,35.91 208.92,36.46 208.92,39.41 203.9,44.44 200.26,44.44 200.12,44.58 v2(199.68,44.58)
KSO8: length 71.9
  TOP w0.102: v2(227.92,28.13) 227.92,27.24 226.48,25.8 226.48,24.81 226.82,24.46 v2(226.82,17.4) 226.83,17.39 226.83,17.14 227.05,16.92 UE1.46 ; RPE7.8 238.83,22.43 238.27,21.87 v2(238.3,21.87) ; JKB1.17 197.65,44.11 198.1,44.57 v2(198.97,44.57) 198.98,44.57 199.58,45.16 v3(200.31,45.16)
  IN2 w0.127: v2(226.82,17.4) 226.83,17.41 226.83,17.64 229.78,20.59 230.32,20.59 231.03,21.3 232.36,21.3 233.48,22.42 234.61,22.42 236.39,20.64 237.95,20.64 238.3,20.98 v2(238.3,21.87)
  IN3 w0.127: v2(227.92,28.13) 227.92,28.18 227.49,28.62 227.49,30.73 225.93,32.3 219.16,32.3 217.49,33.98 211.64,33.98 210.09,35.53 209.5,35.53 208.67,36.36 208.67,39.23 203.79,44.11 199.43,44.11 v2(198.97,44.57)
KSO9: length 73.6
  TOP w0.102: v2(237.08,19.17) 236.85,18.94 UE1.68 234.78,18.94 234.67,19.05 234.67,19.48 234.13,20.02 233.78,20.02 232.98,20.83 232.98,21.75 232.42,22.31 232.42,24.34 231.89,24.87 231.89,28 v2(231.71,28.18) ; v2(202.78,47.18) v3(202.78,49.01) 202.78,49.71 200.38,52.11 JKB1.7
  IN3 w0.127: v2(231.71,28.18) 231.73,28.18 232.32,28.77 234.63,28.77 236.1,30.24 236.1,30.93 236.08,30.96 236.08,34.26 234.55,35.78 234.55,37.26 233.93,37.87 232.21,37.87 229.69,40.4 212.1,40.4 211.03,41.47 211.03,43.81 207.66,47.18 v2(202.78,47.18)
  BOTTOM w0.102: RE30.1 236.7,18.79 v2(237.08,19.17)
KSO10: length 72.9
  TOP w0.102: JKB1.5 199.07,53.71 v3(199.07,53.71) 199.82,53.71 204.63,48.9 204.63,45.18 v2(205.06,44.74) ; v2(231.12,28.16) 231.15,28.18 231.15,28.32 231.47,28.64 231.96,28.64 232.12,28.49 232.12,24.97 232.65,24.43 232.65,22.57 233.23,21.99 233.23,20.9 233.59,20.54 UE1.72 237.3,20.54 237.7,20.95 237.7,21.24 v2(237.72,21.25)
  IN3 w0.127: v2(231.12,28.16) 231.12,28.67 230.95,28.84 230.95,29.43 231.45,29.94 231.45,30.7 231.76,31 232.98,31 234.76,32.78 234.76,33.32 232.35,35.73 230.88,35.73 230.87,35.72 230.52,35.72 230.52,35.72 219.38,35.72 216.04,39.06 210.8,39.06 207.6,42.25 207.6,43.09 205.93,44.77 205.09,44.77 v2(205.06,44.74)
  BOTTOM w0.102: v2(237.72,21.25) 237.7,21.24 237.7,20.82 237.21,20.32 RPE6.8
KSO11: length 68.8
  TOP w0.102: v2(237.11,21.25) 237.11,21.29 237.05,21.34 UE1.74 235.08,21.34 233.11,23.31 233.11,24.62 232.57,25.16 232.57,29.2 232.52,29.25 v2(232.52,29.26) ; v2(203.69,46.12) v3(203.69,47.3) 203.69,49.28 200.06,52.91 JKB1.6
  IN3 w0.127: v2(203.69,46.12) 204.07,45.74 208.39,45.74 210.53,43.6 210.53,40.88 211.59,39.82 229.34,39.82 235.52,33.64 235.52,31.86 234.88,31.22 234.88,30.04 234.67,29.83 232.87,29.83 232.52,29.48 v2(232.52,29.26)
  BOTTOM w0.102: v2(237.11,21.25) 237.12,21.23 237.12,20.98 236.97,20.82 RPE6.7
KSO12: length 60.7
  TOP w0.102: v3(198.36,48) 198.25,48.11 JKB1.12 196.49,48.11 v2(196.22,47.84) ; v2(237.11,21.85) 237.01,21.74 UE1.75 235,21.74 233.33,23.41 233.33,24.72 232.88,25.18 232.88,27.6 233.23,27.96 v2(233.23,28.18)
  IN3 w0.127: v2(233.23,28.18) 233.23,28.13 233.04,27.94 232.89,27.94 232.65,27.7 230.33,27.7 228.19,29.84 228.19,30.75 226.11,32.83 219.35,32.83 217.7,34.48 211.85,34.48 210.18,36.16 209.59,36.16 209.18,36.57 209.18,39.54 204,44.72 201.05,44.72 198.21,47.56 196.48,47.56 196.2,47.84 v2(196.22,47.84)
  BOTTOM w0.102: RPE6.6 236.6,21.32 237.12,21.84 v2(237.11,21.85)
KSO13: length 69.7
  TOP w0.102: v2(233.1,29.28) 233.1,29.18 233.64,28.64 233.64,27.98 233.11,27.45 233.11,25.27 233.56,24.81 233.56,23.64 235.06,22.14 UE1.76 236.68,22.14 236.85,22.31 237.53,22.31 237.65,22.19 237.65,21.91 237.71,21.85 v2(237.71,21.86) ; JKB1.9 200.81,50.51 v3(201.07,50.25) 201.81,49.51 201.81,47.95 v2(201.79,47.92)
  IN3 w0.127: v2(201.79,47.92) 201.76,47.89 201.76,47.34 202.5,46.6 207.89,46.6 210.78,43.71 210.78,40.99 211.7,40.07 229.66,40.07 232.11,37.62 233.83,37.62 234.3,37.15 234.3,35.68 235.82,34.15 235.82,30.85 235.85,30.83 235.85,30.34 234.78,29.28 v2(233.1,29.28)
  BOTTOM w0.102: v2(237.71,21.86) 237.7,21.87 237.7,21.87 237.68,21.89 237.68,22.13 237.54,22.27 236.87,22.27 RPE6.5
KSO14: length 68.6
  TOP w0.102: JKB1.8 197.85,51.31 198,51.46 v3(199.67,51.46) 200.54,51.46 202.3,49.71 v2(202.3,47.56) ; RPE7.6 238.39,23.61 238.13,23.36 238.13,22.82 237.85,22.54 UE1.77 235.04,22.54 233.79,23.79 233.79,24.91 233.39,25.31 233.39,27.35 234.05,28.01 v2(234.05,28.18)
  IN3 w0.127: v2(234.05,28.18) 234.43,28.18 236.36,30.11 236.36,31.08 236.33,31.11 236.33,34.36 234.81,35.89 234.81,37.36 234.04,38.13 232.32,38.13 229.79,40.66 212.21,40.66 211.29,41.57 211.29,43.92 207.56,47.64 202.37,47.64 v2(202.3,47.56)
KSO15: length 76
  TOP w0.102: v2(239.99,21.99) 239.84,21.99 239.4,22.42 239.4,22.9 239.2,23.11 RPE7.7 ; JKB1.10 v3(198.76,49.71) 200.07,49.71 v2(200.97,48.81) ; UE1.86 234.93,26.14 234.5,26.57 234.5,28.31 233.72,29.1 233.72,29.25 233.21,29.76 v2(233.21,30.37)
  IN3 w0.127: v2(200.97,48.81) 200.67,48.5 200.67,46.17 201.61,45.23 205.83,45.23 207.91,43.15 207.91,42.3 210.9,39.31 229.13,39.31 235.01,33.43 235.01,32.35 233.21,30.55 v2(233.21,30.37)
  BOTTOM w0.102: v2(239.99,21.99) 240.56,22.56 240.56,23.37 240.93,23.74 240.93,27 240.28,27.65 239.88,27.65 239.25,28.28 239.25,30.87 238.59,31.54 234.25,31.54 233.21,30.5 v2(233.21,30.37)
KSO16: length 67.1
  TOP w0.102: v2(234.38,30.37) 234.4,30.34 234.4,29.06 234.92,28.54 UE1.92 ; JKB1.11 199.99,48.91 v3(200.21,48.68) 200.54,48.35 v2(201.38,48.35) ; RPE7.5 239.27,24.11 239.61,24.45 239.63,24.45 239.78,24.59 v2(239.78,24.87)
  IN3 w0.127: v2(201.38,48.35) 201.05,48.02 201.05,46.45 202.02,45.48 205.94,45.48 208.19,43.23 208.19,42.38 211.01,39.56 229.23,39.56 235.26,33.53 235.26,31.96 234.38,31.08 v2(234.38,30.37)
  BOTTOM w0.102: v2(239.78,24.87) 240.55,25.65 240.55,27.05 240.18,27.42 239.79,27.42 239.02,28.18 239.02,30.77 238.49,31.31 235.29,31.31 234.38,30.39 v2(234.38,30.37)
L_BKLT_EN_EC: length 105
  TOP w0.102: UE1.91 236.85,28.14 237.14,28.44 RE114.2 238.95,28.95 239.84,28.95 240.4,29.5 240.4,31.82 239.18,33.04 v2(238.87,33.04)
  IN2 w0.127: v2(161.6,35.02) 161.6,33.84 164.75,30.7 169.9,30.7 171.42,32.22 171.42,34.1 171.77,34.45 172.16,34.45 173.71,32.9 174.27,32.9 175.55,31.61 175.55,30.32 176.01,29.86 176.28,29.86 177.74,28.4 178.21,28.4 178.58,28.03 181.63,28.03 181.68,28.09 181.68,28.09 185.05,31.46 186.48,31.46 189.76,34.74 204.86,34.74 207.4,32.2 220.89,32.2 221.65,32.96 221.65,33.52 221.92,33.79 222.6,33.79 223.42,32.97 225.37,32.97 228.13,35.73 228.13,36.54 228.38,36.79 229.07,36.79 229.26,36.97 231.27,36.97 233.65,34.6 234.59,34.6 236.33,32.86 238.74,32.86 238.87,32.98 v2(238.87,33.04)
  BOTTOM w0.102: v2(161.6,35.02) 162.05,34.57 UH2.W35
LAN_CLKREQ#: length 162.6
  TOP w0.102: RP3.5 163.32,20.15 164.27,21.11 164.27,21.15 165.26,22.14 165.26,23.71 165.52,23.97 165.52,24.35 165.82,24.65 166.43,24.65 v2(166.76,24.98)
  IN1 w0.114: v2(166.76,24.98) 166.76,24.76 167.27,24.25 167.27,24.01 167.89,23.38 168.15,23.38 168.92,22.61 171.52,22.61 171.78,22.86 173.59,22.86 174.17,22.28 175.48,22.28 175.77,21.99 178.47,21.99 178.65,21.81 180.4,21.81 180.52,21.92 186.3,21.92 186.69,22.32 192.8,22.32 193.03,22.56 195.45,22.56 195.69,22.8 198.36,22.8 199.06,23.5 206.66,23.5 206.87,23.71 212.75,23.71 212.83,23.78 219.15,23.78 221.14,21.8 232.12,21.8 233.21,22.89 235.97,22.89 236.74,23.66 239.45,23.66 240.09,24.3 241.12,24.3 241.29,24.48 245.25,24.48 245.64,24.08 260.4,24.08 260.59,23.89 261.78,23.89 263.66,25.77 271.62,25.77 272.16,26.31 272.16,29.72 275.02,32.58 281.14,32.58 281.82,33.26 286.7,33.26 287.53,34.09 292.15,34.09 292.69,34.64 292.69,36.74 293,37.05 293,38.83 293.48,39.31 293.48,44.67 291.81,46.35 v2(291.22,46.35)
  BOTTOM w0.089: v2(166.76,24.98) 166.79,25.01 166.79,25.31 167.33,25.86 UH2.AT24
  BOTTOM w0.102: v2(291.22,46.35) 291.22,45.96 290.8,45.54 289.98,45.54 289.69,45.25 289.39,45.25 289.04,44.89 UL1.12
LAN_DISABLE#_R: length 139.1
  IN3 w0.127: v2(281.92,39.03) 282.05,38.9 282.05,37.58 281.44,36.97 279.13,36.97 278.8,36.64 278.8,35.04 274.56,30.8 274.56,29.58 272.02,27.04 270.72,27.04 269.99,26.3 263.81,26.3 263.79,26.28 263.76,26.28 262.77,25.29 253.04,25.29 249.34,29 246.83,29 244.14,31.68 242.16,31.68 241.48,31 241.48,30.45 240.17,29.15 235.87,29.15 234.41,27.69 232.99,27.69 232.75,27.45 230.22,27.45 229.97,27.7 228.69,27.7 228.68,27.69 228.33,27.69 228.32,27.7 221.19,27.7 220.81,28.08 218.15,28.08 216.82,29.41 216.51,29.41 214.74,31.18 208.65,31.18 208.34,31.49 205.9,31.49 205.45,31.94 198.74,31.94 197.24,33.44 195.69,33.44 195.51,33.62 188.25,33.62 185.96,31.33 184.77,31.33 184.41,30.98 183.36,30.98 182.16,29.79 180.59,29.79 179.6,28.79 176.49,28.79 176.36,28.67 174.34,28.67 174.33,28.66 174.01,28.66 174.01,28.67 171.21,28.67 170.61,29.26 166.52,29.26 165.87,28.62 v2(165.77,28.62)
  BOTTOM w0.102: RL43.1 281.44,39.79 281.92,39.31 v2(281.92,39.03) 282.41,38.55 v1(283.19,38.55) 283.93,38.55 RL1.1 ; UH2.AL27 166.15,28.99 v2(165.77,28.62)
LAN_EN: length 74.5
  TOP w0.102: v2(218.53,29.61) 218.6,29.53 218.63,29.53 218.82,29.34 UE1.3
  IN2 w0.127: v2(272.15,47.69) 272.15,46.98 270.04,44.87 265.89,44.87 262.48,43.53 260.97,42.03 258.71,42.03 258.01,41.33 253.47,41.33 244.21,32.07 236,32.07 233.89,34.18 228.72,34.18 227.85,33.31 227.85,32.91 226.63,31.69 224.5,31.69 223.45,30.65 223.45,30.23 223.19,29.96 220.9,29.96 220.44,29.5 218.63,29.5 v2(218.53,29.61)
  BOTTOM w0.102: UL2.4 277.85,48.34 RL27.2 277.85,46.92 276.44,45.51 275.57,45.51 v1(274.34,46.75) 273.39,47.69 v2(272.15,47.69)
LAN_WAKE#: length 10.3
  BOTTOM w0.076: 173.95,21.03 174.18,21.26 174.18,21.59 174.06,21.7 174.06,22.15 173.77,22.44 UH2.BD11
  BOTTOM w0.102: RH11.1 173.36,14.21 172.55,15.03 172.55,15.87 RH181.1 172.09,16.47 173.01,17.39 173.27,17.65 173.27,19.11 173.76,19.6 v1(173.76,19.93) 173.76,20.84 173.95,21.03
LAN_WAKE#_R: length 4.6
  TOP w0.102: RL42.2 285.68,40.68 v2(286.39,41.39) v1(286.9,40.88)
  BOTTOM w0.102: v2(286.39,41.39) 286.39,40.96 RL2.2
  BOTTOM w0.203: UL1.21 285.81,42.18 285.98,42.01 285.98,40.87 RL2.2
LCD_TST: length 187.9
  TOP w0.102: 63.71,27.37 63.71,27.51 63.51,27.71 63.51,28.18 63.64,28.31 65.41,28.31 66.05,28.95 66.05,29.2 ; 63.71,27.37 62.42,27.37 62.12,27.08 62.12,26.42 61.76,26.05 v2(61.68,26.05) 61.3,26.43 60.69,26.43 58.91,24.65 v1(58.48,24.65) ; 63.71,27.37 RV538.1 ; 66.05,29.2 66.56,28.69 66.94,28.69 67.19,28.95 67.19,29.96 66.56,30.6 66.56,31.36 DV2.3 ; 66.05,29.2 UZ23.2 ; UE1.26 219.35,20.14 219.08,20.41 218.84,20.41 v2(218.83,20.41)
  IN1 w0.114: v2(61.68,26.05) 61.68,26.05 61.68,25.92 62.68,24.92 62.68,21.59 66.88,17.39 70.8,17.39 71.63,18.22 100.85,18.22 101.01,18.38 101.01,18.98 101.64,19.6 140.07,19.6 140.6,19.07 142.28,19.07 142.82,18.53 149.81,18.53 150.63,17.71 153.97,17.71 154.9,18.63 160.44,18.63 162.3,20.5 166.2,20.5 167.84,18.86 168.96,18.86 169.33,18.49 169.58,18.25 171.97,18.25 172.19,18.47 173.06,18.47 173.22,18.32 178.33,18.32 179.24,17.4 180.07,17.4 180.77,18.1 187.3,18.1 187.52,18.32 197.41,18.32 197.61,18.32 198.97,19.68 205.14,19.68 205.68,20.22 210.25,20.22 210.88,20.84 211.59,20.84 211.7,20.74 212.04,20.74 212.33,21.02 213.83,21.02 213.89,20.96 217,20.96 217.97,20 218.42,20 v2(218.83,20.41)
LCD_TST_R: length 10
  TOP w0.102: v2(61.08,26.02) 61.47,25.63 61.89,25.63 62.24,25.99 62.24,26.2 62.35,26.31 62.35,26.51 62.75,26.91 RV538.2 62.8,25.97 RV567.1 62.9,25.95 63.38,25.47 v1(64.86,25.47) 65.4,26.01 UZ23.4
  BOTTOM w0.102: v2(61.08,26.02) 61.51,25.59 61.86,25.59 62.28,26.01 JEDP1.5
LCD_VCC_TEST_EN: length 189.9
  TOP w0.102: v2(227.66,36.14) 227.19,35.66 v1(227.19,35.32) 227.19,34.99 227.85,34.33 UE1.113 ; DV3.2 67.56,33.25 67.95,33.65 v2(67.95,34.03)
  IN2 w0.127: v2(67.95,34.03) 69.42,34.03 70.63,32.81 98.8,32.81 99.11,32.5 106.69,32.5 107.19,32 111.79,32 112.63,31.16 112.63,30.69 113.14,30.18 114,30.18 116.52,32.69 140.09,32.69 142.12,30.66 147.46,30.66 148.53,31.73 151.97,31.73 154.37,34.12 154.37,35.86 156.04,37.54 158.89,37.54 160.37,36.06 160.67,36.06 160.9,35.83 161.86,35.83 162.32,35.37 162.32,33.84 164.96,31.21 169.51,31.21 170.24,31.93 170.24,33.64 171.56,34.95 173.2,34.95 173.7,34.46 176.9,34.46 177.18,34.17 177.18,31.12 179.75,28.55 181.42,28.55 184.85,31.98 186.23,31.98 189.62,35.37 205.06,35.37 207.73,32.71 220.66,32.71 221.14,33.19 221.14,33.73 221.75,34.34 226.38,34.34 227.66,35.63 v2(227.66,36.14)
LDO2_CAP: length 2.8
  TOP w0.203: HDA1.39 282.71,28.7 282.79,28.77 v2(282.79,28.84)
  BOTTOM w0.102: v2(282.79,28.84) v1(282.79,28.08)
  BOTTOM w0.203: CA22.2 283.09,29.15 v2(282.79,28.84)
LDO_1VALWP: length 1.4
  BOTTOM w0.102: PC611.1 247.89,12.77 v1(246.9,11.78)
LDO_+0.95VSP: length 4
  BOTTOM w0.102: v2(69.83,66.82) v3(65.85,66.82)
LDO_+1.05VSP: length 1
  BOTTOM w0.102: PC811.1 v1(219.24,42.61)
LED1: length 298.5
  TOP w0.102: JLED.3 247.49,23.94 246.78,23.23 246.04,23.23 244.78,21.97 244.78,21.8 v2(244.94,21.63) ; v2(12.41,16.48) 12.2,16.27 v3(12.2,15.31)
  IN1 w0.114: v2(12.41,16.48) 12.41,14.95 15.99,11.37 22.04,11.37 26.51,6.9 27.02,6.39 82.09,6.39 87.17,11.47 97.34,11.47 98.64,12.77 103.69,12.77 104.63,13.71 109.63,13.71 110.78,12.55 122.98,12.55 126.91,8.63 148.22,8.63 148.88,9.29 158.79,9.29 161.3,11.79 166.14,11.79 171.5,6.43 180.59,6.43 181.72,7.56 182.61,7.56 182.81,7.56 185.39,10.13 197.94,10.13 198.84,11.03 201.69,13.89 203.77,13.89 204.29,13.37 205.61,13.37 206.39,12.58 208.13,12.58 209.73,10.99 212.7,10.99 213.58,10.1 255.23,10.1 255.66,10.53 255.66,17.36 254.95,18.07 253.3,18.07 252.05,19.32 252.05,20.26 251.34,20.97 245.6,20.97 v2(244.94,21.63)
  BOTTOM w0.102: QE21.3 17.04,17.05 16.6,16.6 15.58,16.6 15.3,16.32 15.3,15.51 15.61,15.2 15.61,13.96 15.35,13.71 13.95,13.71 12.95,14.71 QE20.6 12.95,16.17 12.64,16.48 v2(12.41,16.48)
LED2: length 291.4
  TOP w0.102: v2(13.28,16.5) 13.08,16.5 12.65,16.93 v3(11.39,16.93) ; v2(244.31,21.66) 244.31,21.88 246.49,24.07 JLED.2
  IN1 w0.114: v2(13.28,16.5) 12.67,15.89 12.67,15.02 16.09,11.61 22.14,11.61 26.75,7 27.12,6.63 81.99,6.63 87.11,11.75 97.22,11.75 98.51,13.05 103.59,13.05 104.49,13.95 109.73,13.95 110.88,12.79 123.2,12.79 127.11,8.88 148.09,8.88 148.74,9.53 158.69,9.53 161.2,12.04 166.24,12.04 171.6,6.67 180.24,6.67 181.37,7.8 182.71,7.8 185.29,10.38 197.84,10.38 198.6,11.13 201.59,14.13 203.87,14.13 204.39,13.61 205.71,13.61 206.49,12.82 208.23,12.82 209.83,11.23 212.8,11.23 213.69,10.35 255.07,10.35 255.41,10.68 255.41,17.26 254.95,17.72 253.17,17.72 251.47,19.42 251.47,20.34 251.11,20.69 245.27,20.69 v2(244.31,21.66)
  BOTTOM w0.102: QE23.3 14.85,17.04 14.31,16.5 v2(13.28,16.5)
LG_3V: length 19.1
  IN1 w0.635: v2(50.05,20.36) v2(50.05,19.68) 50.05,18.66 49.54,18.15 49.54,13.96 54.24,9.26 v2(59.32,9.26) v2(60.08,9.26)
LG_5V: length 12.6
  TOP w0.635: 49.92,35.3 49.92,29.73 v3(49.03,28.84) 49.03,25.77 49.54,25.26 49.54,23.49 49.41,23.36
  vias: v2(49.41,22.72) v2(49.82,36.31) v2(49.84,36.9) v2(50.05,22.72)
LG_+1.35VS_VGAP: length 13.4
  IN1 w0.508: v2(139.33,127.63) v2(139.96,127.63) 139.96,123.05 140.5,122.52 140.5,119.02 139.49,118.01 139.49,115.91 139.19,115.6
  vias: v2(139.04,114.81) v2(139.04,114.22)
LID_CL_SIO#: length 294.4
  TOP w0.102: v2(241.16,22.31) 241.36,22.52 241.36,22.88 v3(241.46,22.98) 242.33,23.84 242.33,23.99 242.94,24.6 242.94,26.46 242.73,26.66 RE68.1 ; JIO1.25 v2(4.9,34.75)
  IN3 w0.127: v2(241.16,22.31) 240.99,22.48 239.7,22.48 239.37,22.14 239.37,21.57 238.09,20.3 236.36,20.3 234.47,18.41 232.15,18.41 230.47,16.73 220.97,16.73 220.46,17.24 217.63,17.24 217.26,17.62 214.98,17.62 213.8,16.44 211.32,16.44 210.68,17.08 210.68,17.08 210.42,17.34 200.19,17.34 198.51,15.66 189.16,15.66 187.74,14.24 187.19,14.24 182.27,9.31 180.92,9.31 180.03,8.42 172.22,8.42 171.64,9.01 171.23,9.01 166.74,13.5 160.62,13.5 158.61,15.52 158.61,16.71 158.37,16.94 154.31,16.94 153.68,17.58 150.44,17.58 149.62,18.41 143.52,18.41 142.29,17.17 116.78,17.17 115,15.39 110.54,15.39 109.32,16.61 100.25,16.61 99.8,17.06 64.41,17.06 61.75,14.4 55.67,14.4 51.8,10.53 51.8,8.68 49.97,6.85 25.11,6.85 21.05,10.91 16.6,10.91 13.45,14.06 3.65,14.06 1.51,16.2 1.51,31.36 v2(4.9,34.75)
LID_CLOSE#: length 15.3
  TOP w0.102: RE25.2 RE68.2 CE8.1 240.62,27.78 240.62,32.57 239.06,34.13 v1(238.19,34.13) 237.69,33.63 237.69,32.06 236.71,31.08 236.71,30.24 236.61,30.14 UE1.96
LINE1-L_C: length 2.4
  TOP w0.102: v1(295.01,12.99) 295.01,13.48 295.41,13.88 CA64.2
  TOP w0.508: CA64.2 295.48,14.09 RA48.1
LINE1-L_R: length 1.7
  TOP w0.254: RA51.1 292.82,14.21 294.08,14.21 CA65.2
  vias: v1(292.94,13.58)
LINE1_L: length 22.1
  TOP w0.102: v1(297.04,19.32) 296.68,18.96 v2(295.63,18.96)
  TOP w0.203: v2(283.27,20.84) 283.25,20.82 283.14,20.82 282.71,21.25 HDA1.22
  TOP w0.508: CA64.1 295.41,16.32 294.33,17.4 294.33,18.24 295.06,18.96 v2(295.63,18.96)
  IN3 w0.508: v2(295.63,18.96) 295.17,18.51 294.71,18.51 293.39,17.19 290.13,17.19 288.86,18.46 288,18.46 285.61,20.84 v2(283.27,20.84)
LINE1_R: length 16.4
  TOP w0.203: HDA1.21 282.31,21.06 282.71,20.67 v2(282.71,20.54)
  TOP w0.508: CA65.1 294.19,15.6 v2(294.19,16.37)
  IN3 w0.508: v2(282.71,20.54) 282.71,20.36 283.17,19.9 285.38,19.9 287.66,17.62 288.55,17.62 289.8,16.37 v2(294.19,16.37)
  BOTTOM w0.102: v1(283.02,21.33) 282.71,21.02 v2(282.71,20.54)
LINE1_VREFO_L: length 26.1
  TOP w0.203: HDA1.31 v1(285.66,24.95) 286.22,24.95 v2(286.32,24.86)
  TOP w0.508: RA46.1 v2(295.79,12.31)
  IN2 w0.508: v2(286.32,24.86) 286.34,24.83 287,24.83 290.08,21.76 290.08,20.16 292.85,17.39 294.37,17.39 295.41,16.35 297.67,16.35 299.02,15 299.02,12.79 298.46,12.23 295.87,12.23 v2(295.79,12.31)
LINE1_VREFO_R: length 13
  TOP w0.102: v2(290.28,17.95) 290.97,18.63 v1(290.97,18.98)
  TOP w0.203: v2(286.45,24.15) 286.27,24.15 285.86,24.55 HDA1.30
  TOP w0.457: RA53.1 290.15,17.82 v2(290.28,17.95)
  IN3 w0.508: v2(290.28,17.95) 290.28,18.41 290.48,18.61 290.48,20.51 288.5,22.49 288.5,23.15 287.54,24.12 286.47,24.12 v2(286.45,24.15)
LINE2_L: length 45.2
  TOP w0.254: v2(256.3,21.02) 255.69,20.41 255.69,19.04 256.04,18.68 256.04,11.06 256.7,10.4 277.96,10.4 v1(280.3,12.74) 280.3,13.83 282.78,16.31 283.54,16.74 283.63,17.2 RA72.2 283.66,17.73 284.22,17.73 RA71.1
  BOTTOM w0.254: v2(256.3,21.02) 256.73,21.02 257.49,21.78 CD91.2
LPC_LAD0: length 103.2
  TOP w0.102: v2(230.2,25.48) 230.12,25.48 229.68,25.03 229.68,21.53 229.96,21.25 229.96,20.47 232.25,18.18 UE1.59
  IN3 w0.127: v2(246.21,28.09) 245.75,27.63 236.7,27.63 235.24,26.16 233.63,26.16 233.36,25.9 230.62,25.9 v2(230.2,25.48) 230,25.48 229.38,26.1 223.54,26.1 223.25,25.81 217.71,25.81 217.42,26.11 217.42,26.38 216.94,26.86 216.14,26.86 214.92,28.08 211.95,28.08 210.75,29.28 209.18,29.28 207.96,28.06 205.39,28.06 204.32,29.12 192.06,29.12 v2(191.04,28.11) 190.66,28.11 189.44,26.89 187.51,26.89 184.69,24.07 181.87,24.07 181.75,24.2 178.97,24.2 178.58,23.81 177.29,23.81 176.46,22.98 176.12,22.98 175.67,23.43 172.73,23.43 172.12,24.04 172.12,24.98 171.96,25.15 170.61,25.15 170.37,25.39 170.09,25.39 169.36,26.12 v2(169.25,26.12)
  BOTTOM w0.089: UH2.AT22 169.22,26.15 v2(169.25,26.12)
  BOTTOM w0.102: JLPDE1.3 246.02,29.13 246.24,28.92 246.24,28.11 v2(246.21,28.09) ; JNGFF1.18 190.56,28.59 v2(191.04,28.11) ; v1(229.78,26) 229.78,25.9 v2(230.2,25.48)
